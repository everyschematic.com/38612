# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW3_DP1_P2_C: length 1.1
  TOP w0.089: C441.1 163.11,154.86 163.11,155.18 R2176.2
SW3_DP1_P2_R: length 3.3
  TOP w0.089: v2(162.71,157.63) 162.83,157.52 162.83,157.13 163.12,156.84 163.12,156.65 R2176.1
  BOTTOM w0.089: v2(162.71,157.63) 162.83,157.51 162.83,157.14 162.75,157.06 JDOCK1.22
SW3_DP1_P3: length 48.8
  TOP w0.089: v2(164.7,150.31) 165,150.62 165,150.85 164.71,151.14 C443.2
  IN3 w0.114: v2(164.7,150.31) 164.65,150.26 164.65,150.01 164.81,149.84 165.02,149.84 165.13,149.96 165.13,150.17 165.12,150.18 165.12,153.21 163.81,154.52 161.4,154.52 160.95,154.07 160.95,152.59 158.98,150.62 158.98,148.42 157.97,147.4 157.97,145.37 158.41,144.93 158.41,131.53 157.2,130.31 157.2,129.7 158.45,128.44 158.45,121.39 158.3,121.24 158.3,120.61 v2(158.44,120.47)
  BOTTOM w0.089: UV2.42 158.49,118.79 158.46,118.82 158.46,119.26 158.32,119.41 158.32,120.35 v2(158.44,120.47)
SW3_DP1_P3_C: length 1.1
  TOP w0.089: C443.1 164.96,152.34 164.96,152.63 R2178.2
SW3_DP1_P3_R: length 5.9
  TOP w0.089: v2(164.21,157.63) 164.33,157.52 164.33,156.98 164.95,156.35 v4(164.95,155.28) 164.95,154.1 R2178.1
  BOTTOM w0.089: JDOCK1.28 164.25,157.06 164.33,157.14 164.33,157.51 v2(164.21,157.63)
SW3_DP2_AUXN: length 38.4
  IN3 w0.114: v2(152.51,118.05) 152.56,118 152.56,117.74 152.51,117.69 152.51,116.99 153.32,116.17 153.32,114.05 153.08,113.81 153.08,111.78 154.02,110.84 154.02,109.99 154.39,109.63 154.39,107.68 155.47,106.59 155.47,103.25 155.3,103.08 155.3,101.81 153.65,100.16 153.65,99 153.32,98.67 153.32,95.42 152.87,94.98 152.87,94.81 153.01,94.67 153.35,94.67 153.47,94.55 153.47,94.38 153.35,94.25 v2(153.2,94.25)
  IN4 w0.102: v2(153.2,94.25) 153.2,94.48 153.08,94.61 152.89,94.61 152.76,94.48 152.76,94.15 152.67,94.06 152.51,94.06 151.18,92.73 150.09,92.73 149.6,93.22 149.6,93.46 149.71,93.58 149.78,93.58 149.78,93.61 149.8,93.61 149.8,93.6 v2(149.78,93.6)
  BOTTOM w0.089: UV2.29 152.94,117.09 152.71,117.32 152.71,117.38 152.62,117.47 152.56,117.47 152.47,117.56 152.47,117.62 152.67,117.83 152.67,117.95 152.57,118.05 v2(152.51,118.05) ; U631.27 149.71,94.06 149.71,94.06 149.71,93.81 149.78,93.75 149.78,93.61 149.8,93.61 149.8,93.6 v2(149.78,93.6) ; U631.22 151.71,94.39 152.1,94 152.71,94 152.8,94.09 152.8,94.39 152.89,94.48 153.13,94.48 153.2,94.41 v2(153.2,94.25)
SW3_DP2_AUXP: length 38.4
  IN3 w0.114: v2(151.99,117.75) 152.14,117.6 152.14,116.83 152.95,116.02 152.95,114.21 152.71,113.96 152.71,111.63 153.65,110.69 153.65,109.84 154.02,109.47 154.02,107.53 155.1,106.44 155.1,103.4 154.93,103.23 154.93,101.96 153.28,100.31 153.28,99.16 152.95,98.83 152.95,95.58 152.51,95.13 152.51,94.3 152.92,93.89 152.94,93.89 v2(153.2,93.62)
  IN4 w0.102: v2(153.2,93.62) 153.18,93.64 153.18,93.7 153.08,93.8 152.91,93.8 152.82,93.71 152.66,93.71 151.32,92.37 149.94,92.37 149.24,93.07 149.24,93.58 v2(149.14,93.68)
  BOTTOM w0.089: v2(153.2,93.62) 153.17,93.66 v4(152.48,93.66) 151.96,93.66 151.31,94.31 U631.23 ; U631.28 149.31,93.85 v2(149.14,93.68) ; UV2.28 152.92,116.69 152.16,117.44 152.16,117.57 v2(151.99,117.75)
SW3_DP2_HPD: length 37.5
  BOTTOM w0.102: UV2.38 156.89,118.65 156.52,119.02 156.52,120.49 156.98,120.96 161.72,120.96 162.41,120.27 162.41,120 162.95,119.46 163.39,119.46 165.1,117.75 165.1,117.32 v1(165.82,116.61) 166.31,116.11 166.31,112.29 163.95,109.93 163.95,107.96 160.19,104.2 158.84,104.2 158.56,103.93 157.62,103.93 157.15,103.46 157.03,103.46 156.65,103.07 154.21,103.07 153.83,102.69 153.64,102.69 153.25,102.3 U631.3
SW3_DP2_N0: length 20.1
  TOP w0.089: v2(158.26,104.41) 157.3,104.41 156.4,105.31 156.4,110.28 v4(156.95,110.83) 157.43,111.31 157.43,113.54 157.18,113.8 157.18,115.13 156.94,115.37 v2(156.94,119.22)
  BOTTOM w0.089: v2(158.26,104.41) 158.12,104.55 157.27,104.55 157.07,104.35 156.7,104.35 C1463.1 ; UV2.39 157.29,118.87 v2(156.94,119.22)
SW3_DP2_N0_C: length 3.9
  BOTTOM w0.089: U631.2 153.32,102.7 153.67,103.06 153.67,103.26 v4(153.95,103.54) 154.18,103.77 154.18,104.2 154.33,104.35 155.22,104.35 C1463.2
SW3_DP2_N1: length 34.9
  TOP w0.089: v2(155.36,122.92) 155.26,122.83 155.26,122.7 155.39,122.58 155.58,122.58 155.77,122.77 155.85,122.77 156.8,121.82 156.8,120.34 157.3,119.83 157.44,119.83 157.55,119.72 157.89,119.72 158.04,119.58 158.04,118.89 157.94,118.8 157.94,116.53 159.49,114.98 159.49,113.94 161.01,112.42 161.01,108.97 159.94,107.89 159.94,105.37 160.35,104.95 160.35,102.93 160.19,102.76 159.55,102.76 159.36,102.95 159.36,103.69 159.48,103.8 159.65,103.8 159.77,103.69 v2(159.77,103.47)
  BOTTOM w0.089: UV2.36 156.09,118.69 155.95,118.83 155.95,119.66 155.95,119.8 155.66,120.1 155.66,120.93 156.04,121.31 156.04,122.58 155.86,122.75 155.77,122.75 155.64,122.62 155.47,122.62 155.35,122.74 155.35,122.91 v2(155.36,122.92) ; C1458.1 158.41,102.24 159.14,102.24 v4(159.46,102.56) 159.71,102.81 159.71,103.4 v2(159.77,103.47)
SW3_DP2_N1_C: length 4.9
  BOTTOM w0.089: C1458.2 156.93,102.26 155.39,102.26 154.67,101.53 153.54,101.53 153.51,101.5 U631.5
SW3_DP2_N2: length 29.4
  TOP w0.089: v2(154.98,119.17) 155.05,119.23 155.58,119.23 155.93,118.88 155.93,116.84 155.22,116.12 154.52,116.12 153.67,115.27 153.67,111.85 v4(154.93,110.59) 155.47,110.05 155.47,104.84 156.51,103.8 156.51,102.21 157.8,100.92 159.02,100.92 159.38,101.28 v2(159.38,101.34)
  BOTTOM w0.089: v2(159.38,101.34) 159.25,101.21 159.25,101.06 158.9,100.71 156.78,100.71 156.76,100.68 156.4,100.68 C1464.1 ; UV2.34 155.29,118.73 155.34,118.78 155.45,118.78 155.49,118.83 155.49,119.34 155.38,119.45 155.1,119.45 154.98,119.34 v2(154.98,119.17)
SW3_DP2_N2_C: length 2.8
  BOTTOM w0.089: C1464.2 155.17,100.91 155,100.91 154.79,100.7 U631.7
SW3_DP2_N3: length 28.9
  TOP w0.089: v2(158.76,99.51) 158.73,99.48 157.78,99.48 157.13,100.13 156.43,100.13 155.47,101.1 155.47,103.07 154.26,104.27 v4(154.26,108.71) 154.26,109.92 152.73,111.45 152.73,114.82 151.2,116.34 151.2,118.11 152.03,118.93 152.41,118.93 152.58,119.1 v2(152.58,119.98)
  BOTTOM w0.089: v2(152.58,119.98) 152.58,119.68 153.21,119.05 153.62,119.05 154.09,118.58 UV2.31 ; C1459.1 158.13,99.34 158.4,99.6 158.69,99.6 158.76,99.53 v2(158.76,99.51)
SW3_DP2_N3_C: length 4.7
  BOTTOM w0.089: C1459.2 156.96,99.56 156.72,99.56 156.57,99.41 154.89,99.41 154.74,99.56 v4(154.23,99.56) 153.6,99.56 153.54,99.5 U631.10
SW3_DP2_P0: length 20
  TOP w0.089: v2(158.26,105) 158.08,105.18 157.93,105.18 157.85,105.1 157.85,104.81 157.8,104.76 157.45,104.76 156.75,105.46 156.75,110.14 157.78,111.17 157.78,113.69 157.52,113.94 157.52,115.27 157.28,115.51 157.28,118.98 v2(157.54,119.23)
  BOTTOM w0.089: v2(158.26,105) 158.16,104.9 v4(157.54,104.9) 157.13,104.9 156.92,104.69 156.68,104.69 C1460.1 ; UV2.40 157.69,118.68 157.79,118.78 157.79,118.98 v2(157.54,119.23)
SW3_DP2_P0_C: length 3.8
  BOTTOM w0.089: U631.1 153.24,103.1 153.33,103.2 153.33,103.4 153.84,103.91 153.84,104.34 154.19,104.69 v4(154.54,104.69) 155.24,104.69 C1460.2
SW3_DP2_P1: length 34.9
  TOP w0.089: v2(158.96,103.47) 158.96,102.87 159.41,102.42 160.33,102.42 160.7,102.79 160.7,105.09 160.28,105.51 160.28,107.75 161.36,108.82 161.36,112.56 159.83,114.08 159.83,115.12 158.28,116.67 158.28,118.65 158.38,118.75 158.38,119.72 158.03,120.07 158.02,120.07 157.69,120.07 157.58,120.18 157.45,120.18 157.14,120.48 157.14,121.96 v2(155.77,123.33)
  BOTTOM w0.089: UV2.37 156.49,118.71 156.29,118.9 156.29,119.52 156.29,119.95 156,120.24 156,120.78 v4(156.16,120.94) 156.38,121.17 156.38,122.72 v2(155.77,123.33) ; C1457.1 158.41,102.59 159,102.59 159.36,102.95 159.36,103.51 159.25,103.63 159.08,103.63 158.96,103.51 v2(158.96,103.47)
SW3_DP2_P1_C: length 4.8
  BOTTOM w0.089: U631.4 153.51,101.9 153.54,101.87 154.53,101.87 155.25,102.6 v4(156.16,102.6) 156.96,102.6 C1457.2
SW3_DP2_P2: length 29.5
  TOP w0.089: v2(158.78,101.42) 158.73,101.48 158.73,101.68 158.61,101.8 158.45,101.8 158.34,101.68 158.34,101.37 158.23,101.26 157.94,101.26 156.86,102.35 156.86,103.94 155.81,104.99 v4(155.81,106.92) 155.81,110.19 154.01,111.99 154.01,115.13 154.66,115.78 155.36,115.78 156.28,116.69 156.28,119.02 155.72,119.58 155.16,119.58 155.01,119.73 v2(155.01,119.84)
  BOTTOM w0.089: v2(155.01,119.84) 155.19,119.67 155.47,119.67 155.69,119.44 UV2.35 ; C1461.1 156.48,101.65 156.7,101.65 156.82,101.52 156.82,101.15 156.93,101.05 158.75,101.05 158.91,101.2 158.91,101.3 v2(158.78,101.42)
SW3_DP2_P2_C: length 2.9
  BOTTOM w0.089: C1461.2 155.17,101.25 154.85,101.25 154.65,101.05 v4(154.28,101.05) 153.43,101.05 153.37,101.1 U631.6
SW3_DP2_P3: length 28.9
  TOP w0.089: v2(158.76,100.1) 158.48,99.82 157.92,99.82 157.27,100.48 156.98,100.48 156.98,100.48 156.57,100.48 155.81,101.24 155.81,103.21 v4(155.02,104) 154.6,104.41 154.6,110.07 153.07,111.6 153.07,114.96 151.55,116.49 151.55,117.96 152.17,118.59 152.55,118.59 152.93,118.96 152.93,119.44 153.05,119.57 153.3,119.57 153.42,119.69 153.42,119.86 153.3,119.98 v2(153.17,119.98)
  BOTTOM w0.089: v2(158.76,100.1) 158.76,100.07 158.64,99.94 158.38,99.94 C1462.1 ; v2(153.17,119.98) 153.17,119.95 153.08,119.85 153.08,119.7 153.38,119.4 153.76,119.4 154.49,118.67 UV2.32
SW3_DP2_P3_C: length 4.7
  BOTTOM w0.089: C1462.2 156.93,99.91 156.58,99.91 156.43,99.75 v4(155.78,99.75) 155.03,99.75 154.88,99.91 152.8,99.91 U631.9
SW4_DP_AUXN: length 113.8
  TOP w0.089: R381.1 97.64,92.17 v2(98.25,91.56) ; v2(58.58,55.89) 58.57,55.89 58.48,55.79 58.48,55.54 58.07,55.14 57.41,55.14 57.12,54.85 JIO2.131
  IN4 w0.102: v2(58.58,55.89) 58.48,55.79 58.17,55.79 58.12,55.84 58.12,56.07 58.34,56.29 61.52,56.29 62.87,57.64 63.5,57.64 92.37,86.51 92.37,88.54 96.08,92.25 97.88,92.25 98.01,92.12 98.01,92 97.91,91.9 97.91,91.82 98.16,91.56 v2(98.25,91.56)
  BOTTOM w0.089: v2(98.25,91.56) 98.25,91.54 98.63,91.16 v4(100.85,91.16) 104.19,91.16 106.1,93.06 107.68,93.06 108.27,93.64 113.78,93.64 114.28,93.15 128.6,93.15 129.37,93.92 141.62,93.92 142.83,95.13 146.96,95.13 147.33,95.5 U631.31
SW4_DP_AUXP: length 112.9
  TOP w0.089: v2(57.71,55.97) 58.08,55.97 58.13,55.91 58.13,55.68 57.93,55.48 57.27,55.48 56.98,55.19 56.81,55.19 56.76,55.24 56.76,55.3 56.71,55.35 JIO2.133
  IN4 w0.102: v2(57.71,55.97) 57.76,56.02 57.76,56.22 58.2,56.65 61.38,56.65 62.72,58 63.36,58 92.02,86.65 92.02,88.69 95.93,92.6 98.04,92.6 98.34,92.3 v2(98.67,91.98)
  BOTTOM w0.089: v2(98.67,91.98) 98.74,91.98 98.84,91.88 98.84,91.79 98.7,91.65 98.7,91.58 98.77,91.5 v4(102.51,91.5) 104.05,91.5 105.95,93.4 107.54,93.4 108.13,93.99 113.92,93.99 114.42,93.49 128.46,93.49 129.23,94.27 141.48,94.27 142.69,95.47 146.82,95.47 147.25,95.9 U631.32
SW4_DP_HPD: length 154
  TOP w0.102: v2(54.14,44.34) 53.65,43.85 JIO2.88
  IN1 w0.109: v2(153.33,89.36) 152.53,88.56 144.86,88.56 144.24,89.19 144.24,95.19 145.7,96.65 147.1,96.65 147.44,97 147.44,99.75 146.91,100.28 v2(146.91,100.61)
  IN2 w0.127: v2(153.33,89.36) 151.17,87.21 139.97,87.21 137.34,89.83 129.84,89.83 129.53,90.14 123.16,90.14 122.98,89.96 109.91,89.96 108.42,88.48 107.03,88.48 105.55,87 100.98,87 100.57,87 89.35,75.78 89.35,63.38 77.49,51.52 73.56,51.52 71.05,49 69.3,49 67,46.71 64.32,46.71 62.95,45.33 62.15,45.33 61.38,44.57 54.37,44.57 v2(54.14,44.34)
  BOTTOM w0.102: v2(146.91,100.61) 147,100.7 U631.44
SW4_DP_N0: length 120.3
  TOP w0.089: v2(58.62,61.78) 58.54,61.7 58.54,61.26 58.26,60.98 57.47,60.98 57.42,60.93 56.93,60.93 56.86,60.85 JIO2.155
  IN4 w0.102: v2(58.62,61.78) 58.48,61.64 58.26,61.64 58.2,61.7 58.2,62.3 59.03,63.14 63.25,63.14 63.25,63.14 63.54,63.14 88.17,87.76 88.17,91.34 88.36,91.53 88.36,91.53 93.87,97.05 102.64,97.05 104.23,98.64 104.99,99.4 105.15,99.4 105.31,99.23 105.55,99.23 105.66,99.33 105.66,99.48 v2(105.42,99.72)
  BOTTOM w0.089: v2(105.42,99.72) 105.57,99.57 105.57,99.05 106.52,98.1 v4(112.66,98.1) 134.57,98.1 136.89,100.41 136.89,100.7 136.88,100.7 136.88,103.48 138.93,105.53 142.8,105.53 145.6,102.74 145.6,102.27 146.76,101.1 U631.45
SW4_DP_N1: length 120.1
  TOP w0.089: v2(58.61,60.27) 58.61,60.28 58.54,60.2 58.54,59.85 58.17,59.48 57.38,59.48 57.25,59.35 JIO2.149
  IN4 w0.102: v2(58.61,60.27) 58.6,60.26 58.25,60.26 58.18,60.32 58.18,60.59 58.27,60.68 59.3,60.68 59.72,61.09 62.86,61.09 89.13,87.36 89.13,90.94 94.03,95.84 100.89,95.84 101.34,95.39 101.34,95.31 101.15,95.12 101.15,94.94 101.27,94.82 101.44,94.82 v2(101.52,94.89)
  BOTTOM w0.089: U631.42 147.23,99.9 147.18,99.85 145.83,99.85 144.44,101.24 144.44,102.32 142.5,104.26 138.87,104.26 137.67,103.07 137.67,100.09 137.67,99.8 136.56,98.69 136.56,98.58 135.14,97.16 v4(109.02,97.16) 105.44,97.16 102.7,94.42 102.1,94.42 101.8,94.72 101.8,94.72 101.63,94.89 v2(101.52,94.89)
SW4_DP_N2: length 120.2
  TOP w0.089: v2(58.62,58.85) 58.56,58.8 58.56,58.5 58.16,58.1 57.32,58.1 57.15,57.93 56.8,57.93 56.72,57.85 JIO2.143
  IN4 w0.102: v2(100.44,93.81) 100.32,93.92 100.32,94 100.44,94.11 100.44,94.22 99.83,94.83 94.38,94.83 90.25,90.69 90.25,87.12 62.91,59.77 62.27,59.77 61.79,59.29 58.25,59.29 58.12,59.16 58.12,58.86 58.25,58.73 58.5,58.73 v2(58.62,58.85)
  BOTTOM w0.089: U631.39 145.41,98.7 143.48,100.64 143.48,101.89 142.25,103.12 139.19,103.12 138.56,102.49 138.56,99.26 135.53,96.22 v4(107.61,96.22) 105.87,96.22 102.99,93.34 100.91,93.34 v2(100.44,93.81)
SW4_DP_N3: length 113.6
  TOP w0.089: v2(58.44,57.32) 58.37,57.26 58.37,56.99 57.96,56.57 57.46,56.57 57.36,56.47 56.87,56.47 56.75,56.35 JIO2.137
  IN4 w0.102: v2(99.34,92.62) 99.12,92.62 99.01,92.73 99.01,92.9 99.15,93.03 99.15,93.13 98.93,93.35 95.47,93.35 91.36,89.24 91.36,86.86 63.1,58.61 62.47,58.61 61.62,57.76 58.27,57.76 58.03,57.52 58.03,57.31 58.08,57.26 58.37,57.26 v2(58.44,57.32)
  BOTTOM w0.089: U631.36 143.65,97.5 141.1,94.95 129.07,94.95 128.21,94.09 115.59,94.09 114.72,94.95 108.25,94.95 107.29,94 105.71,94 105.57,93.86 104.85,93.86 v4(103.82,92.84) 103.14,92.16 99.8,92.16 v2(99.34,92.62)
SW4_DP_P0: length 120.3
  TOP w0.089: JIO2.157 56.82,61.35 56.9,61.27 57.28,61.27 57.33,61.32 58.12,61.32 58.2,61.4 58.2,61.83 58.08,61.95 57.91,61.95 57.79,61.83 v2(57.79,61.79)
  IN4 w0.102: v2(57.79,61.79) 57.84,61.84 57.84,62.45 58.89,63.49 63.4,63.49 87.81,87.91 87.81,91.49 88,91.68 93.73,97.4 102.5,97.4 103.98,98.89 105.28,100.19 105.95,100.19 v2(106.04,100.1)
  BOTTOM w0.089: v2(106.04,100.1) 105.96,100.1 105.81,99.94 105.81,99.84 105.91,99.74 105.91,99.19 106.66,98.45 v4(114.06,98.45) 134.43,98.45 136.54,100.56 136.54,103.63 138.79,105.87 142.95,105.87 145.94,102.88 145.94,102.41 146.9,101.45 147.05,101.45 147.11,101.5 U631.46
SW4_DP_P1: length 120.1
  TOP w0.089: v2(57.76,60.28) 57.85,60.37 58.07,60.37 58.2,60.24 58.2,59.99 58.03,59.82 57.24,59.82 57.11,59.69 56.85,59.69 56.8,59.75 56.8,59.8 56.75,59.85 JIO2.151
  IN4 w0.102: v2(57.76,60.28) 57.83,60.35 57.83,60.73 58.12,61.03 59.15,61.03 59.57,61.45 62.72,61.45 88.78,87.51 88.78,91.09 93.89,96.2 101.03,96.2 v2(101.93,95.3)
  BOTTOM w0.089: v2(101.93,95.3) 101.97,95.34 102.14,95.34 102.25,95.22 102.25,95.06 102.14,94.94 102.14,94.86 102.24,94.76 102.55,94.76 105.3,97.51 v4(110.78,97.51) 135,97.51 136.22,98.73 136.22,98.83 137.33,99.95 137.33,103.21 138.73,104.6 142.64,104.6 144.78,102.46 144.78,101.38 145.97,100.2 147.06,100.2 147.16,100.3 U631.43
SW4_DP_P2: length 120.3
  TOP w0.089: v2(57.66,58.86) 57.69,58.88 58.16,58.88 58.22,58.82 58.22,58.65 58.02,58.44 57.18,58.44 57.01,58.27 56.82,58.27 56.75,58.35 JIO2.145
  IN4 w0.102: v2(100.86,94.3) 99.98,95.18 94.24,95.18 89.89,90.84 89.89,87.26 62.76,60.13 62.13,60.13 61.64,59.65 58.1,59.65 57.76,59.31 57.76,58.96 v2(57.66,58.86)
  BOTTOM w0.089: U631.40 147.11,99.1 147.05,99.05 145.55,99.05 143.82,100.78 143.82,102.04 142.39,103.46 139.04,103.46 138.22,102.64 138.22,99.4 135.39,96.57 v4(106.21,96.57) 105.73,96.57 102.85,93.68 101.05,93.68 100.91,93.82 100.91,93.92 101.02,94.04 101.02,94.14 v2(100.86,94.3)
SW4_DP_P3: length 113.7
  TOP w0.089: v2(57.62,57.36) 57.76,57.5 57.98,57.5 58.03,57.45 58.03,57.13 57.82,56.91 57.32,56.91 57.22,56.81 56.75,56.81 56.71,56.85 JIO2.139
  IN4 w0.102: v2(99.75,93.04) 99.08,93.71 95.32,93.71 91,89.38 91,87 62.96,58.96 62.32,58.96 61.48,58.11 58.12,58.11 57.68,57.67 57.68,57.41 v2(57.62,57.36)
  BOTTOM w0.089: U631.37 147.24,97.9 147.18,97.85 143.51,97.85 140.96,95.3 128.93,95.3 128.07,94.43 115.73,94.43 114.87,95.3 108.1,95.3 107.15,94.34 105.57,94.34 105.43,94.2 104.7,94.2 103,92.5 v4(101.11,92.5) 99.94,92.5 99.81,92.63 99.81,92.7 99.93,92.82 99.93,92.93 99.83,93.04 v2(99.75,93.04)
SW5_DP_AUXN: length 151.1
  TOP w0.089: JIO2.101 56.86,47.35 56.93,47.43 58.05,47.43 60.94,50.32 60.94,52.68 60.81,52.8 60.81,54.26 v2(60.93,54.38)
  IN4 w0.102: v2(97.03,90.32) 97.22,90.51 97.22,90.59 97.02,90.79 96.08,90.79 93.45,88.16 93.45,86.22 63.9,56.67 63.27,56.67 61.92,55.33 61.19,55.33 60.85,54.99 60.85,54.46 v2(60.93,54.38)
  BOTTOM w0.089: U636.31 172.18,91.78 172.64,91.32 172.64,90.09 168.05,85.5 166.91,85.5 166.36,84.96 157.94,84.96 157.62,85.28 157.17,85.28 156.85,84.96 145.74,84.96 144.08,86.62 143.19,86.62 141.69,88.12 141.69,92.04 140.74,92.98 129.76,92.98 128.85,92.07 110.62,92.07 110.38,91.83 109.36,91.83 109.32,91.78 106.15,91.78 104.3,89.94 v4(99.07,89.94) 97.5,89.94 97.11,90.32 v2(97.03,90.32)
SW5_DP_AUXP: length 151.2
  TOP w0.089: v2(60.35,54.38) 60.47,54.26 60.47,52.66 60.6,52.53 60.6,50.46 57.91,47.77 56.93,47.77 56.86,47.85 JIO2.103
  IN4 w0.102: v2(60.35,54.38) 60.49,54.52 60.49,55.13 61.05,55.68 61.78,55.68 63.12,57.03 63.76,57.03 93.1,86.37 93.1,88.31 95.93,91.14 97.17,91.14 97.35,90.97 v2(97.56,90.97)
  BOTTOM w0.089: U636.32 171.78,91.7 172.29,91.18 172.29,90.23 167.91,85.85 166.77,85.85 166.22,85.3 158.08,85.3 157.76,85.62 157.02,85.62 156.71,85.3 145.88,85.3 144.23,86.96 143.33,86.96 142.03,88.26 142.03,92.18 140.89,93.33 129.62,93.33 128.71,92.41 110.48,92.41 110.24,92.17 109.22,92.17 109.18,92.13 106.01,92.13 104.16,90.28 v4(103.67,90.28) 97.67,90.28 97.16,90.79 97.16,90.93 97.29,91.05 97.47,91.05 v2(97.56,90.97)
SW5_DP_HPD: length 148.5
  TOP w0.102: v2(53.47,43.35) JIO2.86
  IN2 w0.127: v2(53.47,43.35) 53.47,43.48 53.76,43.77 54.5,43.77 54.57,43.71 55.41,43.71 56.11,43.01 61.83,43.01 62.53,43.71 64.27,43.71 66.1,45.54 66.55,45.54 69.51,48.5 71.26,48.5 73.77,51.01 77.7,51.01 89.86,63.17 89.86,75.57 100.78,86.49 105.77,86.49 107.24,87.97 108.63,87.97 110.12,89.45 123.19,89.45 123.31,89.57 129.38,89.57 129.63,89.33 137.13,89.33 139.79,86.66 144.23,86.66 144.98,85.91 151.06,85.91 158.33,93.19 160.99,93.19 161.26,92.92 161.68,92.92 162.48,92.12 164.22,92.12 164.6,92.5 166.04,92.5 166.98,91.57 v2(166.98,91.26)
  BOTTOM w0.102: U636.44 v2(166.98,91.26)
SW5_DP_N0: length 136.3
  TOP w0.089: JIO2.125 56.84,53.35 56.9,53.41 56.9,53.47 56.94,53.51 58.05,53.51 58.34,53.8 59.04,53.8 59.53,53.31 59.53,52.1 59.59,52.04 59.59,51.33 59.53,51.26 59.22,51.26 v2(59.19,51.3)
  IN4 w0.102: v2(59.19,51.3) 59.4,51.09 59.4,50.8 59.93,50.27 60.47,50.27 61.93,50.27 103.41,91.75 111.46,91.75 111.83,92.12 111.97,92.12 111.98,92.12 112.58,92.12 113.33,92.87 142,92.87 143.18,91.69 v2(143.18,91.51)
  BOTTOM w0.089: v2(143.18,91.51) 143.26,91.59 143.93,91.59 144.78,92.43 147.19,92.43 147.85,91.78 v4(150.44,91.78) 151.38,91.78 151.44,91.84 154.71,91.84 156.62,89.92 161.38,89.92 161.51,89.8 165.9,89.8 166.55,90.44 166.55,91.52 166.58,91.55 U636.45
SW5_DP_N1: length 138.9
  TOP w0.089: v2(58.56,52.86) 58.55,52.85 58.55,52.4 58.22,52.08 57.43,52.08 57.21,51.85 JIO2.119
  IN4 w0.102: v2(58.56,52.86) 58.42,52.86 58.3,52.98 58.3,53.14 58.43,53.27 61.42,53.27 62.91,54.76 63.35,54.76 103.83,95.23 107.53,95.23 107.9,94.86 115.51,94.86 115.55,94.83 143.95,94.83 145.72,93.05 145.72,91.68 146.11,91.29 146.74,91.29 146.84,91.19 146.84,91.03 v2(146.66,90.85)
  BOTTOM w0.089: U636.42 167.78,91.44 167.75,91.41 167.75,91.04 167.72,91.02 167.72,90.95 167.49,90.72 167.49,90.02 v4(166.9,89.43) 166.33,88.86 162.95,88.86 162.22,88.13 149.1,88.13 148.57,88.67 148.57,90.51 148.25,90.83 147.47,90.83 147.33,90.96 146.73,90.96 146.66,90.9 v2(146.66,90.85)
SW5_DP_N2: length 140.9
  TOP w0.089: v2(58.46,51.37) 58.46,50.97 58.03,50.54 57.45,50.54 57.26,50.35 JIO2.113
  IN4 w0.102: v2(58.46,51.37) 58.3,51.53 58.3,51.7 58.49,51.89 58.96,51.89 59.25,52.18 62.36,52.18 103.45,93.26 110.55,93.26 111.12,93.83 143.56,93.83 144.19,93.21 144.19,91.86 144.68,91.37 145.17,91.37 145.29,91.24 145.29,91.08 145.17,90.95 v2(145.07,90.95)
  BOTTOM w0.089: v2(145.07,90.95) 145.13,91.02 145.52,91.02 145.72,90.81 v4(145.72,88.73) 145.72,87.87 146.41,87.18 146.84,87.18 162.77,87.18 163.49,87.9 166.79,87.9 168.43,89.54 168.43,90.33 168.66,90.56 168.66,90.56 168.98,90.88 U636.39
SW5_DP_N3: length 144.8
  TOP w0.089: v2(58.54,49.83) 58.49,49.77 58.49,49.19 58.2,48.9 57.25,48.9 57.19,48.85 JIO2.107
  IN4 w0.102: v2(58.54,49.83) 58.21,49.49 58.21,49.42 58.4,49.23 61.75,49.23 103.66,91.14 105.9,91.14 106.23,90.81 112.13,90.81 113.58,92.26 140.02,92.26 140.31,91.97 140.64,91.97 140.93,92.26 141.55,92.26 143.31,90.51 143.63,90.51 143.7,90.58 143.7,90.83 v2(143.62,90.91)
  BOTTOM w0.089: v2(143.62,90.91) 143.55,90.85 143.17,90.85 142.63,90.31 142.63,88.55 143.62,87.56 144.47,87.56 146.12,85.91 156.46,85.91 156.79,86.24 158.03,86.24 158.36,85.91 164.78,85.91 165.45,85.91 166.5,86.96 167.22,86.96 v4(169.47,89.21) 169.87,89.62 169.87,90.33 170.18,90.64 U636.36
SW5_DP_P0: length 136.3
  TOP w0.089: v2(59.99,51.33) 59.94,51.39 59.94,52.18 59.87,52.24 59.87,53.45 59.18,54.14 58.2,54.14 57.91,53.85 JIO2.127
  IN4 w0.102: v2(59.99,51.33) 59.76,51.09 59.76,50.94 60.07,50.63 60.32,50.63 61.78,50.63 103.26,92.11 111.31,92.11 111.68,92.48 112.12,92.48 112.43,92.48 113.18,93.23 142.15,93.23 143.34,92.03 143.49,92.03 143.55,92.1 v2(143.55,92.41)
  BOTTOM w0.089: U636.46 166.18,91.59 166.21,91.56 166.21,90.58 165.76,90.14 161.65,90.14 161.52,90.27 156.77,90.27 154.85,92.18 151.3,92.18 151.23,92.12 v4(149,92.12) 147.99,92.12 147.34,92.78 144.64,92.78 143.79,91.93 143.36,91.93 143.23,92.06 143.23,92.29 143.36,92.41 v2(143.55,92.41)
SW5_DP_P1: length 138.8
  TOP w0.089: JIO2.121 56.68,52.35 56.84,52.19 57.06,52.19 57.29,52.42 58.08,52.42 58.21,52.55 58.21,52.66 58.02,52.85 v2(57.65,52.85)
  IN4 w0.102: v2(146.66,91.71) 146.6,91.65 146.25,91.65 146.08,91.82 146.08,93.2 144.1,95.18 115.7,95.18 115.66,95.22 108.04,95.22 107.67,95.59 103.68,95.59 63.2,55.11 62.76,55.11 61.27,53.63 58.28,53.63 57.94,53.29 57.94,52.97 57.83,52.85 v2(57.65,52.85)
  BOTTOM w0.089: U636.43 167.38,91.44 167.41,91.41 167.41,91.19 167.38,91.16 167.38,91.09 167.15,90.86 167.15,90.16 166.18,89.2 v4(163.18,89.2) 162.8,89.2 162.08,88.48 149.24,88.48 148.91,88.81 148.91,90.65 148.39,91.17 147.62,91.17 147.48,91.31 146.58,91.31 146.46,91.43 146.46,91.59 146.58,91.71 v2(146.66,91.71)
SW5_DP_P2: length 140.9
  TOP w0.089: v2(57.66,51.35) 57.78,51.48 57.97,51.48 58.06,51.39 58.06,51.05 57.89,50.88 57.3,50.88 57.11,50.69 56.89,50.69 56.73,50.85 JIO2.115
  IN4 w0.102: v2(145.05,91.78) 145,91.73 144.82,91.73 144.54,92.01 144.54,93.35 143.7,94.19 110.97,94.19 110.4,93.62 103.3,93.62 62.21,52.53 59.1,52.53 58.81,52.25 58.34,52.25 57.94,51.85 57.94,51.52 57.78,51.35 v2(57.66,51.35)
  BOTTOM w0.089: U636.40 168.58,91.44 168.64,91.38 168.64,91.02 168.52,90.9 168.09,90.47 168.09,89.68 166.65,88.25 163.35,88.25 162.63,87.52 146.69,87.52 146.69,87.52 146.55,87.52 146.07,88.01 146.07,90.95 v4(145.89,91.13) 145.66,91.36 144.97,91.36 144.9,91.43 144.9,91.63 v2(145.05,91.78)
SW5_DP_P3: length 144.7
  TOP w0.089: JIO2.109 56.69,49.35 56.85,49.19 57.05,49.19 57.1,49.25 58.06,49.25 58.14,49.34 58.14,49.79 58.02,49.92 57.79,49.92 v2(57.7,49.83)
  IN4 w0.102: v2(57.7,49.83) 57.85,49.68 57.85,49.28 58.25,48.88 61.9,48.88 103.81,90.79 105.75,90.79 106.08,90.46 112.28,90.46 113.73,91.9 139.87,91.9 140.16,91.61 140.78,91.61 141.08,91.9 141.41,91.9 143.16,90.15 143.57,90.15 v2(143.62,90.1)
  BOTTOM w0.089: U636.37 169.78,91.44 169.84,91.38 169.84,90.78 169.52,90.47 169.52,89.76 167.07,87.31 166.36,87.31 165.3,86.25 164.78,86.25 158.5,86.25 158.17,86.58 156.65,86.58 156.32,86.25 146.26,86.25 144.62,87.9 143.76,87.9 142.97,88.69 v4(142.97,89.32) 142.97,90.16 143.31,90.51 144.2,90.51 144.31,90.39 144.31,90.22 144.2,90.1 v2(143.62,90.1)
SW_1.2V:
  vias: v1(63.89,20.67) v2(65.32,21.67) v2(65.32,21.04) v2(65.32,20.4) v2(65.96,22.31) v2(65.96,21.67) v2(65.96,21.04) v2(65.96,20.4) v2(66.53,21.99) v2(66.53,21.36) v2(66.53,20.72) v2(66.51,20.09) v2(67.14,20.09) v2(67.16,21.36) v2(67.16,20.72)
SW_1PH: length 64.7
  TOP w0.254: PR1102.2 264.19,45.22 v2(264.6,45.64)
  IN3 w0.254: v2(264.6,45.64) 264.03,45.64 262.87,46.8 262.87,48.74 259.82,51.79 259.82,55.32 258.54,56.6 251.9,56.6 246.43,62.07 246.43,62.38 246.43,70.73 245.07,72.09 237.18,72.09 236.87,72.4 235.78,72.4 232.68,75.5 225.76,75.5 225.28,75.01 225.28,73.08 v2(225.34,73.02)
  BOTTOM w0.254: v2(225.34,73.02) PL1700.2
SW_+1VSP:
  vias: v1(93.4,123.16) v2(94.39,123.01) v2(94.77,122.47) v2(95,123.03) v2(95.43,122.5) v2(95.69,123.03) v2(96.09,122.5) v2(96.35,123.03) v2(96.8,122.52) v2(97.11,123.03) v2(97.49,122.52)
SW_+V0.95SP:
  vias: v2(323.95,19.93)
SW_EDRAMP: length 2.8
  TOP w0.102: 77.28,8.91 77.28,8.38 v1(78.86,6.8)
SWV_CLK: length 44
  TOP w0.102: U8.14 251.01,98.34 v2(251.37,97.99) ; v2(256.98,84.42) 256.98,83.99 257.81,83.15 v1(257.81,82) 257.81,72.56 263.48,66.89 263.48,64.3 263.76,64.02 263.76,63.08 262.13,61.46
  IN1 w0.109: v2(251.37,97.99) 251.37,95.26 252.18,94.45 252.49,94.14 252.49,91.74 253.65,90.58 253.65,87.35 256.38,84.61 256.79,84.61 v2(256.98,84.42)
SWV_IO: length 45.2
  TOP w0.102: U8.13 251.81,98.01 v2(252.58,97.24) ; 256.47,85.77 256.7,86 v2(256.96,86) ; 256.47,85.77 v1(256.47,85.77) ; 256.47,85.77 256.33,85.63 256.33,83.9 257.47,82.76 257.47,72.25 260.33,69.4 260.33,63.33 259.38,62.38 259.38,61.93 259.95,61.36 260.62,61.36 JDEG3.5
  IN1 w0.109: v2(256.96,86) 256.03,86 254.64,87.39 254.64,94.53 253.09,96.08 253.09,96.98 252.84,97.24 v2(252.58,97.24)
SYS_LED_MASK#: length 300.9
  TOP w0.102: Q327.2 228.29,124.59 228.78,124.59 229.02,124.35 229.02,124.04 v2(229.53,123.53) ; R775.2 176.66,106.93 v2(176,107.59) 175.94,107.65 175.94,108.54 176.64,109.24 176.64,110.84 176.33,111.15 v2(176.32,111.15) ; Q325.5 Q325.2 241,115.36 240.66,115.02 v2(238.99,115.02) ; Q74.2 304.7,7.45 304.91,7.67 v2(304.91,8.31) ; v2(307.42,11.42) 307.23,11.62 U58.1 306.81,12.36 305.58,13.58 303.62,13.58 299.96,17.24 299.96,17.89 299.65,18.21 299.65,20.2 298.05,21.8 298.05,23.59 297.82,23.82 297.82,25.57 298.3,26.06 298.3,30.5 v2(296.78,32.02)
  IN1 w0.109: v2(304.91,8.31) 304.91,10.26 306.07,11.42 v2(307.42,11.42)
  IN2 w0.127: v2(210.99,142.83) 210.99,143.66 210.63,144.01 207.28,144.01 205.86,142.59 201.95,142.59 200.12,144.42 197.79,144.42 194.79,147.42 191.33,147.42 190.77,147.98 186.65,147.98 184.93,149.69 172.07,149.69 v2(171.62,149.25) ; v2(229.53,123.53) 229.53,123.8 228.73,124.61 228.7,124.61 227.88,125.43 227.88,130.15 224.09,133.94 215.94,133.94 v2(215.56,133.56)
  IN3 w0.127: v2(296.78,32.02) 296.07,32.02 295.05,33.04 292.42,33.04 288.42,37.04 287.15,37.04 285.44,38.75 285.44,40.33 273.49,52.28 273.09,52.28 272.84,52.53 270.32,55.05 259.81,65.56 259.81,69.12 255.76,73.17 255.76,86.48 255.29,86.95 v2(255.29,88.37) ; v2(171.62,149.25) 171.62,148.83 172,148.45 172,145.91 171.99,145.9 171.99,145.37 172.06,145.3 172.06,144.88 173.25,143.69 173.25,136.12 174.18,135.18 174.18,133.31 174.1,133.22 174.1,132.35 173.56,131.82 173.56,127.82 174.02,127.36 174.02,124.84 173.66,124.48 173.66,121.55 176.08,119.14 176.08,116.14 176.58,115.64 176.58,114.51 176.52,114.46 176.52,111.61 176.32,111.4 v2(176.32,111.15)
  IN4 w0.109: v2(255.29,88.37) 255.29,88.44 251.2,92.53 251.2,93.37 251,93.57 251,93.91 251,93.91 251,94.69 248.71,96.98 246.81,96.98 245.65,95.82 243.85,95.82 242.82,96.85 242.82,97.12 242.34,97.61 242.34,99.08 242.74,99.49 242.74,101.8 242.31,102.23 242.31,105.45 241.69,106.07 241.05,106.07 240.77,105.79 240.09,105.79 237.9,107.97 237.9,111.15 239.42,112.67 239.42,114.59 v2(238.99,115.02) 238.8,115.21 238.8,117.32 238.17,117.95 238.17,120.14 234.58,123.74 229.74,123.74 v2(229.53,123.53)
  BOTTOM w0.102: v2(210.99,142.83) 210.99,141.41 v1(210.8,141.22) 210.8,139.91 212.13,138.58 212.13,135.4 212.45,135.08 214.04,135.08 v2(215.56,133.56) ; U46.B48 176.79,106.18 176.79,106.68 176.61,106.86 176.61,106.98 v2(176,107.59)
SYS_PWROK_R: length 176.1
  TOP w0.102: v2(163.05,109.05) 163.37,109.05 166.76,112.44 166.76,113.37 167.59,114.19 168.24,114.19 168.39,114.35 168.39,119.67 167.68,120.38 167.68,120.58 164.29,123.97 160.81,123.97 RC128.2 ; v2(155.32,7.16) 155.86,6.62 JXDP1.47 ; v2(150.48,12.21) 150.48,15.43 CC36.1 RC5.2 151.35,17.18 RC129.2 149.61,18.68 144.74,23.54 144.74,66.95 139.49,72.2 139.49,77.08 141.52,79.11 141.86,79.11 144.78,82.03 144.78,83.76 142.73,85.82 142.73,86.47 141.42,87.78 140.82,87.78 139.23,89.36 139.23,91.12 v2(139.62,91.5)
  IN1 w0.089: v2(141.64,107.91) 141.76,107.79 141.76,107.16
  IN1 w0.109: 141.76,107.16 143.44,105.48 143.44,98.76 143.41,98.72 143.38,98.72 141.43,96.76 141.43,95.99 141.14,95.7 141.14,92.16 140.48,91.5 v2(139.62,91.5)
  BOTTOM w0.089: v2(141.64,107.91) 141.76,107.79
  BOTTOM w0.102: v2(155.32,7.16) 155.45,7.29 155.45,9.39 158.12,12.06 158.12,13.35 157.08,14.38 152.65,14.38 v2(150.48,12.21) ; 141.76,107.79 145.03,107.79 145.27,108.03 v1(146.11,108.03) 149.84,108.03 150.41,107.46 150.41,107.07 151.24,106.24 159.29,106.24 162.09,109.05 v2(163.05,109.05)
SYS_RESET#: length 126
  TOP w0.089: v2(138.08,122.69) 137.24,122.69 137.2,122.65 136.43,122.65 136.33,122.56 136.33,122.13 135.19,120.99 UH1.AW1
  TOP w0.102: UC3.4 142.89,123.45 142.72,123.28 142.24,123.28 RH66.2 141.64,123.87 141.04,123.87 139.74,122.58 138.19,122.58 v2(138.08,122.69)
  IN4 w0.089: v2(138.08,122.69) 138.19,122.58 139.78,122.58 140.29,122.07 141.76,122.07
  IN4 w0.109: v2(218.23,116.51) 217.78,116.97 216.04,116.97 214.63,118.38 214.63,120.75 213.78,121.59 209.25,121.59 207.37,119.72 200.91,119.72 200.74,119.89 195.91,119.89 195.77,120.02 195.77,120.47 196.18,120.87 196.18,122.23 195.74,122.67 194.27,122.67 191.97,120.38 189.06,120.38 188.64,120.79 180.74,120.79 179.82,119.88 178.81,119.88 178.67,119.74 173.3,119.74 172.78,120.25 171.33,120.25 170.88,119.8 167.89,119.8 167.09,120.61 166.73,120.61 166.01,121.32 165.51,121.32 164.63,122.2 162.37,122.2 162.23,122.06 152.5,122.06 152.29,121.85 151.45,121.85 151.05,122.25 147.8,122.25 147.21,121.66 144.43,121.66 144.35,121.58 143.77,121.58 143.28,122.07 141.76,122.07
  BOTTOM w0.102: v2(218.23,116.51) 218.06,116.34 218.06,116.25 217.82,116.02 217.76,116.02 217.63,115.88 217.63,115.76 217.59,115.72 217.59,115.4 217.85,115.15 217.85,114.89 218.15,114.59 218.55,114.59 219.3,113.83 219.3,110.32 219.39,110.23 221.83,107.79 221.83,106.5 221.26,105.93 221.26,105.07 220.88,104.69 220.88,101.8 v1(220.48,101.39) 220.48,100.38 219.37,99.27 219.37,98 220.48,96.89 JAPS1.13
SYSPWR_PRES: length 8.2
  TOP w0.102: v2(201.76,117.27) 201.76,117.51 201.63,117.64 201.63,117.64 v1(200.22,119.05) 199.95,119.32 199.95,121.49 200.4,121.93 v2(200.41,121.93)
  BOTTOM w0.102: v2(201.76,117.27) 201.76,117.27 201.76,117.27 201.76,117.27 201.76,117.24 201.76,117.24 201.76,117.15 201.75,117.15 U51.A59 ; R876.1 R874.1 200.88,122.4 v2(200.41,121.93)
TB_STAT#: length 206.3
  TOP w0.203: PR757.1 271.81,29.78 272.28,30.25 PU700.16
  TOP w0.254: PR757.1 271.96,28.99 272.2,29.23 v2(272.44,29.23) ; PQ707.2 v2(268.23,23.63)
  IN2 w0.127: v2(216.55,116.56) 216.55,117.29 215.11,118.73 212.97,118.73 212,117.76 211.36,117.76 211.14,117.54 209.94,117.54 209.91,117.57 205.41,117.57 204.69,116.85 198.83,116.85 198.51,117.18 198.51,117.39 197.66,118.23 195.87,118.23 195.3,118.81 194.65,118.81 193.82,117.98 192.56,117.98 191.42,116.83 189.44,116.83 188.26,115.65 186.23,115.65 186.13,115.75 185.19,115.75 183.6,114.16 183.6,114.01 183.27,113.68 182.46,113.68 182.44,113.66 181.78,113.66 v2(181.61,113.83) ; v2(216.78,94.44) 216.78,91.62 218.88,89.51 218.88,89.04 218.88,88.49 221.45,85.92 221.45,85.65 222.62,84.49 225.77,84.49 227.33,82.93 240.25,82.93 244.16,79.02 244.16,78.25 246.82,75.59 249.46,75.59 255.82,69.23 255.82,67.19 257.81,65.2 257.81,63.47 276.5,44.78 279.1,44.78 282.83,41.04 288.33,41.04 289.81,39.56 v2(289.81,38.93)
  IN3 w0.127: v2(268.23,23.63) 268.61,23.63 270.73,25.75 270.73,27.52 v2(272.44,29.23)
  BOTTOM w0.102: v2(289.81,38.93) 289.46,38.93 288.78,38.25 288.78,31.2 286.17,28.59 273.08,28.59 v2(272.44,29.23) ; v2(216.78,94.44) 216.61,94.62 216.61,96.9 216.03,97.48 216.03,98.44 216.5,98.91 216.5,100.1 216.94,100.53 216.94,100.91 217.23,101.2 217.42,101.2 v1(217.92,101.71) 218.2,101.99 218.2,102.91 218.51,103.21 218.52,103.22 218.52,104.64 218.83,104.95 218.83,106.43 219.03,106.63 219.03,106.97 218.79,107.21 218.38,107.21 218.03,107.56 217.46,107.56 216.29,108.73 216.29,110.49 216.25,110.53 216.25,116.25 v2(216.55,116.56) ; U46.B15 182.3,115.08 182,114.78 182,114.34 181.91,114.25 181.91,114.17 181.61,113.87 v2(181.61,113.83)
TBT_CIO_PLUG_EVENT#: length 119.9
  TOP w0.089: v2(116.16,109.53) 115.96,109.74 115.79,109.74 115.39,110.15 UH1.U41
  TOP w0.102: v2(109.41,107.97) 109.01,108.37 107.59,108.37 107.36,108.61 RH341.2 ; JIO2.94 53.41,45.35 v2(53.54,45.22)
  IN1 w0.109: v2(106.65,92.53) 106.41,92.53 104.75,90.88 104.75,89.65 v2(105.77,88.63)
  IN2 w0.089: 112.37,108.03 113.96,108.03 114.98,109.05 115.68,109.05 v2(116.16,109.53)
  IN2 w0.127: v2(106.65,92.53) 106.65,93.42 107.38,94.15 107.38,96.81 104.75,99.44 104.75,101.74 105.13,102.13 105.13,103.52 104.37,104.29 104.37,105.19 104.02,105.55 104.02,107.68 105.51,109.18 106.62,109.18 106.78,109.18 108.49,107.46 109.04,107.46 109.41,107.84 v2(109.41,107.97) 109.48,108.03 112.37,108.03 ; v2(105.77,88.63) 104.29,88.63 103.94,88.98 101.48,88.98 88.59,76.09 88.59,63.7 77.17,52.28 73.25,52.28 72.5,51.53 69.8,51.53 65.94,47.67 61.14,47.67 59.84,46.38 56.56,46.38 55.67,45.49 54.52,45.49 54.36,45.65 53.97,45.65 v2(53.54,45.22)
TBT_FORCE_PWR: length 105.2
  TOP w0.089: UH1.P43 114.26,108.64 114.26,108.24 114.32,108.17 114.32,107.96 114.26,107.9 114.26,107.82 114.02,107.59 114.02,107.34 113.83,107.14 113.45,107.14 112.69,106.38 112.69,106.07 112.37,105.75
  TOP w0.102: JIO2.98 53.17,46.35 v2(53.64,46.82) ; v2(103.64,102.97) 103.87,103.21 105.33,103.21 107.69,105.57 108.92,105.57 112.2,105.57 112.37,105.75
  IN2 w0.127: v2(53.64,46.82) 53.83,47.01 54.36,47.01 54.48,47.14 55.07,47.14 56.9,48.97 65.08,48.97 69.06,52.95 71.85,52.95 72.45,53.55 75.55,53.55 87.32,65.32 87.32,77.14 100.62,90.44 104.25,90.44 105.29,91.49 105.29,94.07 105.65,94.43 105.65,96.63 103.26,99.02 103.26,102.6 v2(103.64,102.97)
TBT_PWR_EN: length 218.2
  TOP w0.102: v2(185.49,111.54) 185.11,111.92 185.11,112.32 185.34,112.55 185.59,112.55 185.66,112.62 186.3,112.62 187.11,113.43 187.39,113.43 187.82,113.86 187.82,115.6 186.91,116.5 186.47,116.5 185.83,117.14 185.83,124.15 184.26,125.72 v2(184.26,126.64) ; v2(53.47,42.35) JIO2.82
  IN1 w0.109: v2(161.01,90.67) 160.48,91.21 160.12,91.21 158.35,92.98 157.88,92.98 157.08,93.78 157.08,99 158.59,100.52 161.09,100.52 162.66,102.09 166.7,102.09 167.83,103.22 167.83,105.8 169.43,107.4 169.69,107.4 171.95,109.66 171.95,113.55 172.22,113.81 172.9,113.81 173.97,114.88 173.97,115.86 173.26,116.58 173.26,117.52 173.58,117.85 174.69,117.85 174.89,118.04 174.89,118.77 176.2,120.09 176.2,122.77 177.08,123.65 179.65,123.65 179.9,123.9 180.22,124.23 180.22,124.8 180.9,125.47 182.15,125.47 182.94,126.26 182.94,126.8 183.21,127.07 183.84,127.07 184.26,126.66 v2(184.26,126.64)
  IN2 w0.127: v2(161.01,90.67) 160.84,90.49 156.36,90.49 151.27,85.41 144.77,85.41 144.02,86.15 139.35,86.15 137.77,87.73 132.38,87.73 132.07,88.03 127.87,88.03 126.95,88.95 111.28,88.95 109.78,87.45 107.44,87.45 105.98,85.99 105.2,85.99 104.57,85.35 100.72,85.35 90.62,75.25 90.62,62.85 78.01,50.25 74.17,50.25 71.66,47.73 71.04,47.73 64.64,41.33 57.66,41.33 57.38,41.61 56.07,41.61 54.8,42.88 54,42.88 v2(53.47,42.35)
  BOTTOM w0.102: U46.A23 185.47,111.51 v2(185.49,111.54)
TCABLE_ID: length 209.6
  TOP w0.102: JIO2.77 58.07,41.35 59.29,42.57 59.29,43.2 58.88,43.61 v2(58.88,43.77)
  IN2 w0.127: v2(199.21,93.16) 199.21,93.16 199.21,93.16 198.91,93.45 196.93,93.45 196.36,94.03 195.62,94.03 195.39,93.8 195.05,93.8 194.54,94.3 191.45,94.3 189.84,95.91 185.42,95.91 184.43,96.9 181.36,96.9 181.22,96.76 180.88,96.76 179.89,97.75 177.3,97.75 176.5,96.95 176.04,96.95 175.24,97.75 172.96,97.75 171.97,98.73 171.09,98.73 170.77,99.05 168.52,99.05 168.13,98.66 168.13,96.18 166.65,94.7 165.25,94.7 163.72,93.17 161.37,93.17 161.1,93.44 158.22,93.44 150.95,86.17 145.08,86.17 144.34,86.92 139.9,86.92 137.23,89.58 129.73,89.58 129.43,89.89 123.27,89.89 123.09,89.71 110.01,89.71 108.53,88.22 107.13,88.22 105.66,86.75 100.89,86.75 100.68,86.75 89.6,75.67 89.6,63.28 77.59,51.26 73.67,51.26 71.16,48.75 69.4,48.75 66.44,45.79 65.99,45.79 64.17,43.97 62.43,43.97 61.93,43.48 59.17,43.48 v2(58.88,43.77)
  IN3 w0.127: v2(203.07,94.93) 203.07,95.11 203.42,95.46 203.42,96.47 203.12,96.77 203.12,101.29 203.45,101.62 203.45,102.83 202.33,103.95 202.33,105.41 202.7,105.78 202.7,109.68 202.11,110.27 202.11,111.03 202.74,111.65 v2(203.51,111.65)
  BOTTOM w0.102: v2(199.21,93.16) 199.21,93.16 199.42,93.37 201.53,93.37 v1(202.07,93.92) 202.07,93.93 v2(203.07,94.93) ; U51.B8 204.84,111.61 204.53,111.92 203.77,111.92 203.51,111.65 v2(203.51,111.65)
TDOCK_BATLOW#: length 177.2
  TOP w0.102: JIO2.69 v1(57.66,39.35) 58.68,39.35 v2(59.1,39.77)
  IN2 w0.127: v2(177.75,94.78) 177.82,94.78 178.15,95.12 178.5,95.12 178.74,94.87 178.74,93.36 178.67,93.28 178.67,92.39 174.94,88.67 155.97,88.67 151.69,84.39 144.35,84.39 143.6,85.14 138.92,85.14 138.45,85.61 137.12,85.61 136.36,86.37 132.3,86.37 131.65,87.02 125.96,87.02 124.88,85.93 123.95,85.93 123.12,86.76 117.39,86.76 117.02,87.13 111.26,87.13 110.51,86.38 107.83,86.38 106.43,84.97 105.62,84.97 104.96,84.31 102.61,84.31 101.04,82.74 99.54,82.74 91.64,74.83 91.64,62.43 78.44,49.23 74.59,49.23 72.2,46.84 72.2,45.83 70.7,44.32 69.66,44.32 69.41,44.07 69.41,43.03 66.92,40.54 66.73,40.54 66.5,40.32 60.64,40.32 60.16,39.83 59.16,39.83 v2(59.1,39.77)
  IN3 w0.127: v2(177.75,94.78) 178.15,95.19 178.15,100.69 177.25,101.59 177.25,103.4 177.11,103.53 177.11,107.33 177.12,107.35 177.12,108.18 176.08,109.22 v2(176.08,109.29)
  BOTTOM w0.102: U46.B58 174.78,109.7 175.67,109.7 v2(176.08,109.29)
TDOCK_PWR_BTN#: length 261.7
  TOP w0.102: JIO2.60 53.6,36.85 v2(54.08,37.33) ; v2(218.62,106.8) 217.82,106.8 217.66,106.96 216.5,106.96 216.13,106.59 216.13,106.13 215.75,105.75 215.75,104.83 214.84,103.92 214.84,100.45 216.29,99 216.29,98.23 218.6,95.92 218.6,93.32 217.06,91.78 211.92,91.78 211.75,91.95 210.16,91.95 209.77,91.56 206.75,91.56 206.42,91.23 206.42,90.05 206.95,89.52 v2(207.25,89.52)
  IN2 w0.127: v2(54.08,37.33) 54.74,36.66 60.12,36.66 60.53,37.08 67.5,37.08 69.52,39.1 70.23,39.1 71.19,40.05 71.19,40.88 73.95,43.63 78.13,43.63 95.18,60.68 95.18,71.98 97.4,74.2 97.4,75.12 98.24,75.97 98.49,75.97 100.28,77.76 102.5,77.76 106.55,81.81 108.1,81.81 108.24,81.95 118.67,81.95 119.65,82.93 122.48,82.93 123.09,82.32 125.26,82.32 127.27,84.32 130.47,84.32 132.5,82.29 134.03,82.29 134.36,82.62 137.34,82.62 142.86,77.1 146.04,77.1 149.99,81.05 152.77,81.05 154.65,82.93 155.62,82.93 157.04,84.35 159.24,84.35 160.38,83.21 165.59,83.21 166.16,82.63 168.7,82.63 169.84,83.77 173.85,83.77 174.29,83.33 177.4,83.33 177.65,83.08 181.11,83.08 182.94,84.91 v2(182.94,85.21)
  IN3 w0.127: v2(206.43,120.97) 206.43,119.76 205.63,118.95 205.63,117.71 203.13,115.21 203.13,114.74 202.7,114.3 v2(202.7,114.05)
  IN4 w0.109: v2(218.62,106.8) 216.48,108.94 215.71,108.94 215.47,109.18 215.47,110.17 216.14,110.84 216.14,112.76 215.56,113.33 214.75,113.33 214.67,113.25 213.19,113.25 212.43,114.02 210.03,114.02 209.75,113.75 209,113.75 207.83,114.92 204.66,114.92 204.43,114.69 204.34,114.69 204.3,114.64 203.39,114.64 203.36,114.67 203.07,114.67 202.83,114.43 202.83,114.19 v2(202.7,114.05)
  BOTTOM w0.102: U51.B63 202,114.93 202.7,114.23 v2(202.7,114.05) ; R870.2 206.19,120.73 v2(206.43,120.97) ; v2(182.94,85.21) 182.99,85.27 188.09,85.27 190.42,87.6 204.78,87.6 v1(205.67,88.49) 206.7,89.52 v2(207.25,89.52)
THERMATRIP2#: length 16.5
  IN3 w0.127: v2(195.75,104.92) 195.75,104.62 197.09,103.28 197.09,100.19 199.09,98.19 199.09,96.88 v2(199.15,96.82)
  BOTTOM w0.102: v2(195.75,104.92) 195.75,106.08 196.18,106.51 U51.B34 ; Q28.1 198.61,98.64 R396.2 199.32,97.11 199.32,96.98 v2(199.15,96.82) 198.78,96.45 C327.1 v1(198.78,95.15)
THERMATRIP3#: length 119.7
  TOP w0.089: 167.92,67.81 169.42,67.81 v2(169.87,67.37) 170.26,66.97 171.45,66.97 172.03,67.55 172.03,68.07 R11.2
  TOP w0.102: 167.92,67.81 167.2,67.81 167.04,67.97 164.8,67.97 Q4.1
  IN2 w0.127: v2(214.55,112.29) 212.79,112.29 211.61,113.47 210.4,113.47 209.72,112.79 208.83,112.79 207.65,113.97 207.16,113.97 206.67,114.46 v2(206.67,114.51)
  IN3 w0.127: v2(217.26,103.8) 217.16,103.8 216.89,104.06 216.89,105.96 216.53,106.33 216.53,106.81 216.85,107.14 216.85,108 216.09,108.76 215.38,108.76 213.84,110.29 213.84,111.37 214.56,112.08 214.56,112.28 v2(214.55,112.29)
  BOTTOM w0.089: 167.92,67.37 v2(169.87,67.37)
  BOTTOM w0.102: v2(217.26,103.8) 217.16,103.8 216.46,103.11 216.46,102.78 215.28,101.6 215.28,101.17 214.88,100.77 214.88,99.58 214.41,99.11 214.41,98.22 213.15,96.96 213.15,96.67 213.15,92.92 212.61,92.37 209.9,92.37 209.31,91.78 207.69,91.78 203.92,88.01 188.77,88.01 188.13,87.37 188.13,86.76 187.19,85.82 182.37,85.82 181.91,85.36 181.91,84.73 179.45,82.26 174.68,82.26 172.95,80.54 164.99,80.54 162.63,78.18 162.63,75.94 162.89,75.67 162.89,75.23 162.16,74.5 162.16,73.74 162.54,73.36 162.54,71.2 166.31,67.43 v1(167.3,67.43) 167.86,67.43 167.92,67.37 ; U51.A2 206.52,114.36 v2(206.67,114.51)
THSEL_STRAP: length 5.8
  TOP w0.102: v2(199.47,107.46) 199.48,107.46 199.47,107.45 199.47,106.99 v1(198.64,106.16) 198.04,105.56 198.04,104.67 v2(198.29,104.41)
  BOTTOM w0.102: R1069.1 198.04,103.77 198.35,104.09 198.35,104.35 v2(198.29,104.41) ; U51.B29 199,106.9 199.48,107.39 199.48,107.46 v2(199.47,107.46)
TOUCH_SCREEN_DET#: length 32.7
  TOP w0.089: v2(123.54,125.14) 123.85,124.83 123.85,124.36 123.57,124.08 123.57,123.57 UH1.BD24
  TOP w0.102: JTS1.5 138.3,131.81 138.68,132.19 139.83,132.19 140.33,132.69 140.33,133.15 v2(140.56,133.38) 140.73,133.56 R382.2
  IN1 w0.089: v2(123.54,125.14) 123.85,124.83 123.85,124.49 124.24,124.09 124.77,124.09 125.51,124.83 125.51,125.13 126.58,126.2 126.75,126.2
  IN1 w0.109: v2(140.56,133.38) 140.11,132.94 140.11,132.8 139.54,132.22 135.93,132.22 133.48,129.77 133.48,127.27 132.17,125.96 131.02,125.96 129.19,127.79 127.69,127.79 127.14,127.24 127.14,126.59 126.75,126.2
  BOTTOM w0.089: v1(122.89,125.42) 123.17,125.14 v2(123.54,125.14)
TOUCH_SCREEN_PD#: length 56.1
  TOP w0.089: 112.37,114.57 113.39,114.57 113.64,114.33 UH1.AE44
  TOP w0.102: R426.2 140.79,134.45 v2(140.62,134.28) 139.97,133.63 139.97,132.66 139.73,132.42 137.55,132.42 137.3,132.17 JTS1.4 ; v2(111.37,115.37) 112.17,114.57 112.37,114.57
  IN1 w0.109: v2(140.62,134.28) 140.62,134.91 140.36,135.18 135.39,135.18 134.42,136.15 132.7,136.15 132.27,135.72 132.27,132.98 129.28,129.99 129.28,128.87 128.66,128.26 127.27,128.26 126.72,127.72 124.38,127.72 123.99,127.34 118.28,127.34 116.56,125.62 115.52,125.62 114.89,125 114.89,124.53 114.48,124.12 113.42,124.12 111.31,122.02 v2(111.31,121.69)
  IN4 w0.109: v2(111.31,121.69) 111.31,120.7 110.52,119.91 110.52,119.45 110.15,119.08 110.15,118.24 111.37,117.03 v2(111.37,115.37)
TOUCHPAD_INTR#: length 269.6
  TOP w0.089: UH1.BC23 124.1,122.51 123.77,122.18 v2(123.77,120.93)
  TOP w0.102: v2(293.6,33.95) 293.01,33.35 JKBTP1.5
  IN2 w0.089: v2(123.77,120.93) 123.77,122.13 124.98,123.34 125.9,123.34 127.42,124.86 127.42,125.88 127.3,126.01 127.3,126.2
  IN2 w0.127: v2(246.84,88.9) 246.88,88.9 246.88,88.91 242.29,93.49 242.29,97.3 235.87,103.73 235.87,107.58 232.64,110.81 232.64,116.56 231.41,117.8 231.41,118.12 229.22,120.31 229.22,122.52 229.95,123.25 229.95,124.57 229.25,125.27 229.25,130.96 228.67,131.54 228.67,132.98 226.82,134.83 215.25,134.83 215,134.58 205.9,134.58 204.5,133.18 198.8,133.18 197.84,134.13 195.08,134.13 193.58,132.63 190.12,132.63 189.42,131.93 187.98,131.93 186.63,133.28 184.1,133.28 183.31,132.49 181.01,132.49 180.77,132.73 180.77,132.85 179.62,133.99 173.65,133.99 172.58,132.93 168.76,132.93 167.57,134.11 167.41,134.11 167.04,134.48 165.79,134.48 164.83,135.43 161.74,135.43 159.48,137.69 156.61,137.69 156.4,137.69 155.09,139 153.85,139 152.66,137.81 152.45,137.81 152.45,137.82 151.11,137.82 150.52,137.23 147.27,137.23 146.39,137.23 145.79,136.63 142.1,136.63 140.07,134.61 135.5,134.61 132.36,131.47 130.6,131.47 129.42,130.29 129.42,129.4 127.3,127.28 127.3,126.2
  BOTTOM w0.102: v2(246.84,88.9) 246.8,88.86 246.8,81.74 249.79,78.76 249.79,67.68 248.39,66.28 248.39,61.54 251.41,58.53 256.16,58.53 256.58,58.95 260.4,58.95 260.77,58.57 264.94,54.41 264.94,54.22 264.94,54.22 264.94,53.38 v1(270.47,47.84) 274.81,43.5 280.56,43.5 282.65,41.42 292.5,41.42 292.98,40.94 292.98,38.18 294.01,37.16 294.01,34.35 v2(293.6,33.95)
TP_LAN_JTAG_TCK: length 2.5
  TOP w0.102: R546.2 v2(253.21,105.58) 252.93,105.87 U31.35
TP_LAN_JTAG_TDI: length 4.2
  TOP w0.102: U31.32 251.73,106.49 251.44,106.2 251.44,105.32 251.77,104.99 T142.1
TP_LAN_JTAG_TDO: length 1.1
  TOP w0.102: U31.34 252.53,106.07 252.54,106.06 T143.1
TP_LAN_JTAG_TMS: length 2.4
  TOP w0.102: U31.33 252.13,106.42 251.91,106.2 v2(251.91,106.07) 251.91,105.43 R545.2
TP_SKL_E30: length 11
  TOP w0.089: CPU1.E30 193.19,62.11 v2(192.92,61.84)
  IN2 w0.089: v2(190.37,68.52) 191.77,68.52 192.32,67.97 192.32,65.43 192.92,64.82 v2(192.92,61.84)
  BOTTOM w0.089: RC179.1 190.24,69.09 189.75,68.59 189.75,68.24 T17.1 190.05,68.19 v2(190.37,68.52)
TP_SKL_F30: length 12.8
  TOP w0.089: CPU1.F30 193.29,61.46 v2(192.94,61.11)
  IN2 w0.089: v2(190.38,67.96) 190.77,67.57 190.77,65.45 191.62,64.6 192.13,64.6 192.51,64.22 192.51,61.43 192.82,61.11 v2(192.94,61.11)
  BOTTOM w0.089: RC178.1 189.51,68.7 188.73,67.93 T16.1 189.77,67.35 v2(190.38,67.96)
TPM_GPIO4: length 5.9
  TOP w0.102: RZ80.2 190.64,130.77 191.09,130.33 191.09,129.81 v1(190.92,129.64) 190.71,129.43 190.11,129.43 189.47,128.8 v2(188.3,128.8)
  BOTTOM w0.102: U637.13 188.54,129.05 v2(188.3,128.8)
TPM_LPM#: length 6.9
  TOP w0.102: RZ82.1 194.01,122.35 v1(194.12,122.45) 194.25,122.59 194.25,123.22 194.69,123.66 QZ2.1 194.29,124.59 192.75,124.59 192.51,124.83 v2(192.51,125.34)
  BOTTOM w0.102: U637.3 192.5,125.35 v2(192.51,125.34)
TPM_PIRQ#: length 123.9
  TOP w0.089: UH1.AN38 116.77,118.33 v2(117.11,118.77)
  TOP w0.102: RZ69.2 v1(190.04,132.76) 190.04,132.67 v2(190.5,132.21)
  IN1 w0.109: v2(190.1,136.79) 190.29,136.6 190.29,134.64 190.61,134.32 190.61,132.31 v2(190.5,132.21)
  IN2 w0.127: v2(190.1,136.79) 189.45,137.43 187.75,137.43 186.83,138.35 181.63,138.35 181.5,138.22 174.22,138.22 174.02,138.42 171.23,138.42 170.76,138.89 168.46,138.89 167.84,138.27 164.43,138.27 161.97,140.74 157.95,140.74 157.03,141.65 148.35,141.65 147.77,142.24 142.83,142.24 142.56,142.51 136.84,142.51 133.54,139.21 128.34,139.21 125.57,136.44 121.75,136.44 120.08,134.78 117.78,134.78 116.82,133.81 116.05,133.81 115.29,134.58 111.41,134.58 110.77,133.94 110.77,132.22 106.15,127.6 106.15,122.63 106.79,121.99 106.79,119.93 107.22,119.49 107.22,118.77 107.4,118.59 108.03,118.59 108.31,118.87 108.31,119.2 108.54,119.43 109.58,119.43 109.91,119.1 109.91,118.46 110.42,117.95 112.15,117.95 112.5,118.31 116.65,118.31 v2(117.11,118.77)
  BOTTOM w0.102: U637.18 v2(190.5,132.21)
TRIN_DOCK_DET: length 189.8
  TOP w0.102: JIO2.79 56.6,41.85 v2(57.26,42.5) ; v2(170.41,116.53) 170.31,116.43 170.31,113.61 168.44,111.74 167.99,111.74 167.5,111.26 167.5,110.42 168.88,109.05 168.88,106.9 167.81,105.82 167.81,103.65 167.47,103.31 v2(167.34,103.31)
  IN1 w0.089: 118.55,99.28 118.55,100.16 117.4,101.3 113.11,101.3 112.37,102.04
  IN1 w0.109: 118.55,99.28 118.55,95.07 116.76,93.28 115.99,93.28 114.38,91.67 114.38,91.02 113.35,89.98 108.59,89.98 104.67,86.06 v2(104.28,86.06) ; 112.37,102.04 112.06,102.36 112.06,102.88 112.05,102.89 112.05,102.9 v2(112.06,102.89)
  IN2 w0.089: 141.76,105.68 138.41,105.68 135.48,102.75 124.11,102.75 123.85,102.5 123.75,102.39 113.63,102.39 112.88,103.14 112.37,103.14
  IN2 w0.127: v2(57.26,42.5) 57.9,41.85 60.3,41.85 60.74,42.29 61.95,42.29 62.53,42.86 63.57,42.86 63.76,42.67 65.23,42.67 66.95,44.38 66.97,44.38 67.21,44.63 67.21,44.65 68.88,46.31 68.88,47.51 69.61,48.24 71.37,48.24 73.88,50.76 77.8,50.76 90.11,63.07 90.11,75.46 100.53,85.88 104.11,85.88 v2(104.28,86.06) ; v2(112.06,102.89) 112.31,103.14 112.37,103.14 ; v2(167.34,103.31) 167.11,103.31 166.83,103.58 166.83,104.34 165.55,105.62 164.89,105.62 164.32,106.19 163.17,106.19 161.78,107.59 157.14,107.59 155.74,106.19 146.98,106.19 146.47,105.68 141.76,105.68
  BOTTOM w0.102: v2(170.41,116.53) 170.41,115.98 170.93,115.46 171.34,115.46 171.73,115.07 171.73,112.86 172.49,112.1 v1(172.79,112.1) 173.31,112.1 173.39,112.01 U46.A59
TRIP_+1VSP: length 1.8
  TOP w0.254: PU800.2 101.34,128.66 101.4,128.72 101.4,129.13 v2(101.48,129.2)
  BOTTOM w0.254: v2(101.48,129.2) 102.06,128.62 PR802.2
TSENSE_3PH_A: length 5.7
  TOP w0.102: v1(250.14,49.25) 250.6,49.25 251.37,48.48 PR1165.1
  TOP w0.203: v2(252.44,48.03) 253.07,48.03 253.53,47.57 PU1100.14
  TOP w0.254: v2(252.44,48.03) 252.31,48.15 PR1165.1
  BOTTOM w0.254: v2(252.44,48.03) 252.31,48.15 PR1165.1
TSENSE_3PH_B: length 7.7
  TOP w0.203: v2(251.87,42.76) 252.05,42.57 v1(252.38,42.57) 252.82,42.57 253.42,43.17 PU1100.25
  BOTTOM w0.254: PR1166.1 251.8,42.69 v2(251.87,42.76) 251.97,42.65 252.73,42.65 253.9,41.49 256.04,41.49 PC1129.1
TSENSE_PSYS: length 26.3
  TOP w0.203: PU1100.24 253.25,43.57 252.82,43.14 v2(252.37,43.14)
  TOP w0.254: v2(264.47,38.37) 265.14,37.71 265.14,34.5 266.03,33.61 266.95,33.61 PR744.1 267.65,34.31 PR730.1
  IN3 w0.254: v2(252.37,43.14) 259.58,43.14 264.41,38.31 v2(264.47,38.37)
  BOTTOM w0.254: v2(252.37,43.14) 252.88,43.14 v1(253.14,42.88) 253.52,42.5 253.88,42.5 253.91,42.48 253.91,42.48 PR1153.1
UG_3V:
  vias: v1(353.35,28.35) v2(340.75,24.86) v2(340.75,24.23) v2(352.99,28.84) v2(353.58,28.84)
UG_5V:
  vias: v1(345.54,41.74) v2(345.27,40.28) v2(345.27,39.64) v2(352.01,32.85) v2(352.2,33.42)
