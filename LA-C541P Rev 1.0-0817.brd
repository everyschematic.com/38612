# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP2_MUX_PI0: length 2.9
  TOP w0.102: v2(150.83,104.67) 150.88,104.72 150.88,104.96 R148.1 R152.1
  BOTTOM w0.102: U631.56 150.51,104.32 150.83,104.64 v2(150.83,104.67)
DP2_MUX_REXT: length 4.1
  TOP w0.102: v2(146,96.06) 146.55,95.51 147.2,95.51 R97.2
  BOTTOM w0.102: v2(146,96.06) 146,96.07 146.6,96.67 147.14,96.67 147.17,96.7 U631.34
DP3_MUX_CEXT: length 2.9
  TOP w0.102: C100.2 164.42,92.27 v2(165.54,91.16)
  BOTTOM w0.102: U636.47 165.78,91.6 165.55,91.38 165.55,91.17 v2(165.54,91.16)
DP3_MUX_IN1_AEQ#: length 1.9
  BOTTOM w0.102: R159.1 162.48,96.04 U636.59
DP3_MUX_IN1_PEQ: length 3.5
  TOP w0.102: v1(163.25,92.5) 163.15,92.61 v2(162.74,92.61) R156.1
  BOTTOM w0.102: R153.1 162.7,92.57 v2(162.74,92.61) 162.74,92.96 163.02,93.24 U636.52
DP3_MUX_IN2_AEQ#: length 1.9
  BOTTOM w0.102: R161.1 162.28,95.64 U636.58
DP3_MUX_IN2_PEQ: length 5.2
  TOP w0.102: v2(162.76,91.61) 162.72,91.65 R157.1
  BOTTOM w0.102: R154.1 162.1,90.9 162.33,90.68 v1(162.51,90.68) 162.8,90.68 162.92,90.8 162.92,91.45 v2(162.76,91.61) 163.16,92.02 163.16,92.65 163.34,92.84 U636.51
DP3_MUX_PC0: length 3.2
  TOP w0.102: R155.1 R105.1 169.06,91.29 v2(169.38,90.98)
  BOTTOM w0.102: U636.38 v2(169.38,90.98)
DP3_MUX_PC1: length 7.2
  TOP w0.102: v1(161.55,96.44) 162.09,95.89 162.97,95.89 163.3,95.57 163.3,94.79 162.89,94.38 v2(162.73,94.38) 162.54,94.19 162.54,93.81 162.29,93.56 R160.1
  BOTTOM w0.102: U636.55 162.79,94.44 v2(162.73,94.38) 162.54,94.19 162.54,93.81 162.25,93.52 R107.1
DP3_MUX_PI0: length 4.1
  TOP w0.102: v2(162.86,94.96) 162.86,95.31 162.72,95.45 v1(162.51,95.45) 162.21,95.45 162.1,95.34 R158.1
  BOTTOM w0.102: U636.56 163.24,94.84 163.11,94.96 v2(162.86,94.96) 162.59,94.96 R162.1
DP3_MUX_REXT: length 4
  TOP w0.102: R106.2 172.25,91.45 172.25,90.97 v2(171.81,90.53)
  BOTTOM w0.102: U636.34 170.98,91.28 171.06,91.19 171.06,90.95 171.48,90.53 v2(171.81,90.53)
DPC_CA_DET: length 52.7
  TOP w0.102: v2(158.86,119.08) 158.86,119.08 RV45.2 159.31,118.33 160.19,119.21 160.19,119.78 159.94,120.04 159.74,120.04 158.86,120.92 158.86,121.68 v1(158.44,122.1) 156.95,123.6 156.95,126.71 153.74,129.92 153.74,131.63 153.9,131.8 153.9,132.33 154.15,132.58 154.26,132.68 155.35,132.68 155.66,132.99 156.26,132.99 158.91,135.64 v2(158.91,136.05)
  BOTTOM w0.102: UV2.43 158.89,118.99 158.86,119.02 158.86,119.08 v2(158.86,119.08) ; JDOCK1.6 158.75,155.09 158.98,154.85 158.98,154.33 158.5,153.84 158.18,153.84 157.67,153.34 157.67,150.41 157.4,150.13 157.4,145.82 157.71,145.5 160.95,145.5 161.33,145.12 161.33,137.24 159.68,135.59 159.36,135.59 v2(158.91,136.05)
DPC_CA_DET_IN: length 38.6
  BOTTOM w0.102: Q353.2 152.66,123.34 153.08,122.92 153.08,121.88 152.76,121.56 C1344.1 151.5,121.56 150.76,120.81 150.76,120.4 150.7,120.34 150.7,120.04 150.4,119.75 150.4,119.05 149.95,118.6 149.04,118.6 147.17,116.73 147.17,115.68 147.11,115.61 147.11,110.64 149.2,108.54 150.01,108.54 150.92,107.64 150.92,107.25 151.44,106.73 v1(158.22,106.73) 159.09,106.73 161.71,109.35 161.71,111.4 160.49,112.63 UV2.4
DPC_CA_DET_Q: length 36.3
  TOP w0.102: v2(151.74,111.46) 151.74,111.91 149.52,114.13 149.52,114.54 v2(147.9,116.16) ; v2(146.75,116.1) 146.75,118.61 146.22,119.15 146.22,121.31 v2(146.98,122.07)
  IN2 w0.127: v2(146.75,116.1) 146.79,116.1 146.92,116.23 147.83,116.23 v2(147.9,116.16)
  BOTTOM w0.102: Q353.3 152.33,122.69 151.49,123.53 151.49,123.97 151.08,124.38 149.12,124.38 R2189.2 146.98,122.24 v2(146.98,122.07) 147.17,121.88 v1(147.17,121.33) Q364.2 ; 149.71,113.3 150.23,112.78 Q355.5 ; 149.71,113.3 150.23,113.82 Q355.2 ; 149.71,113.3 149.14,112.73 149.14,111.4 148.65,110.9 148.65,109.77 148.92,109.49 149.78,109.49 v2(151.74,111.46) ; v2(146.75,116.1) 146.75,116.76 147.17,117.18 Q364.5
DPD_CA_DET: length 60.7
  TOP w0.102: v2(163.04,131.16) 163.04,131.16 163.51,131.63 v1(165.13,131.63) 169.21,131.63 170.41,132.83 v2(170.41,133.37) ; R492.2 158.29,148.4 158.63,148.74 158.63,149.21 v2(157.95,149.9)
  IN3 w0.127: v2(170.41,133.37) 171.21,134.17 171.21,138.55 172.83,140.16 v2(172.83,143.52)
  BOTTOM w0.102: v2(163.04,131.16) 163.04,131.16 163.36,131.48 163.36,143.47 163.24,143.59 163.24,145.56 162.73,146.07 159.3,146.07 158.75,146.62 JDOCK1.5 158.75,149.09 v2(157.95,149.9) ; U629.48 181.19,139.64 182.1,140.55 182.1,141.75 181.91,141.94 179.98,141.94 178.73,143.19 178.73,143.79 178.48,144.04 177.33,144.04 177.08,144.29 174.1,144.29 173.27,143.47 172.88,143.47 v2(172.83,143.52) ; v2(170.41,133.37) 170.35,133.31 Q347.2
DPD_CA_DET_Q: length 21.1
  IN2 w0.127: v2(170.41,140.62) 169.92,141.12 166.09,141.12 165.69,140.71 v2(165.69,140.53)
  BOTTOM w0.102: Q365.2 170.67,141.18 170.41,140.93 v2(170.41,140.62) 170.67,140.37 Q365.5 ; 167.24,138.32 165.23,138.32 ; 165.23,138.32 164.82,138.73 164.82,139.66 165.69,140.52 v2(165.69,140.53) ; 165.23,138.32 165.04,138.32 164.84,138.12 164.84,136.16 166.96,134.04 166.96,133.71 167.16,133.51 168.06,133.51 168.07,133.5 168.3,133.5 168.65,133.15 R721.2 169.32,133.05 Q347.3
DRON: length 96.7
  TOP w0.203: PU1402.2 234.08,37.71 v2(234.37,38.01) ; PU1100.17 253.02,46.37 v2(252.88,46.5) ; PU1400.2 234.1,16.96 234.33,17.19 v2(234.33,17.34) ; PU1401.2 234.1,27.55 v2(234.43,27.88)
  IN1 w0.254: v2(235.42,69.2) 235.58,69.04 238.86,69.04 239.39,68.51 239.39,66.83 240.96,65.26 240.96,60.28 240.21,59.53 v2(240.21,58.54) 240.94,57.81 240.94,49.89 240.22,49.16 v2(240.22,48.22) 241.1,47.34 241.1,39.83 240.14,38.87 v2(240.14,37.83) 242.09,37.83 242.64,38.37 250.72,38.37 252.06,39.71 252.06,40.72 253.2,41.87 253.2,46.18 v2(252.88,46.5) ; v2(234.43,27.88) 234.98,27.33 234.98,17.78 234.54,17.34 v2(234.33,17.34)
  IN2 w0.254: v2(234.43,27.88) 234.58,27.88 235.6,28.91 235.6,35.94 234.37,37.17 v2(234.37,38.01) 236.8,38.01 237.58,37.23 238.68,37.23 238.95,36.95 240.03,36.95 240.29,37.21 240.29,37.68 v2(240.14,37.83)
  BOTTOM w0.203: v2(240.14,37.83) 240.12,37.84 PU1202.2 ; v2(235.42,69.2) 235.42,68.75 234.83,68.16 234,68.16 233.73,68.42 PU1700.2 ; PU1201.2 240.07,48.37 v2(240.22,48.22) ; PU1200.2 240.07,58.68 v2(240.21,58.54)
DSCHRG_MOSFET_GC: length 141
  TOP w0.102: PR1004.2 251.73,15.13 v1(253.22,15.13) 254.49,15.13 255.31,14.31 v2(255.31,13.99)
  TOP w0.254: v2(327.56,55.14) 327.61,55.19 PU1001.29
  IN1 w0.254: v2(327.56,55.14) 329.52,53.18 329.52,49.98 326.09,46.55 326.09,43.07 323.68,40.66 323.68,38.07 324.78,36.96 324.78,32.91 324.68,32.81 324.68,29.62 326.01,28.29 326.01,27.04 328.42,24.63 331.56,24.63 333.31,22.89 333.31,20.84 331.96,19.5 331.96,15.35 327.81,11.2 315.33,11.2 310.63,15.9 300.14,15.9 297.79,18.24 284.08,18.24 283.09,17.25 262.21,17.25 258.95,13.99 v2(255.31,13.99)
EC5048_TX: length 27.8
  TOP w0.102: v2(176.16,114.69) 176.16,115.75 175.08,116.83 175.08,117.59 174.82,117.85 173.38,117.85 172.59,117.07 172.59,115.18 173.13,114.65 173.13,112.26 172.34,111.48 172.24,111.48 v1(171.82,111.06) 171.82,110.59 171.93,110.48 171.93,109.41 171.76,109.24 171.76,108.11 171.13,107.48 171.13,106.64 170.76,106.27 170.76,105.2 171.52,104.44 172.57,104.44 173.62,103.39 v2(173.62,102.67)
  BOTTOM w0.102: v2(176.16,114.69) 175.8,115.04 U46.B2 ; R862.2 176.15,102.15 174.14,102.15 v2(173.62,102.67)
EC5048_TX_R: length 13.1
  BOTTOM w0.102: R849.2 180.04,95.82 180.04,99.97 180.69,100.62 180.69,100.97 180.66,101 JDEG2.9 180.66,102.39 180.42,102.64 179.42,102.64 v1(178.78,101.99) 178.35,101.57 R863.1 R862.1
EC_32KHZ_ECE5048: length 44.6
  TOP w0.102: v2(203.92,113.98) 203.92,113.44 203.63,113.15 202.44,113.15 202.17,112.88 201.67,112.38 201.67,109.07 202.05,108.68 202.96,108.68 203.16,108.89 203.53,108.89 204,109.37 204.53,109.37 205.4,108.5 205.4,107.57 205.11,107.29 v1(205.11,106.67) 205.11,105.98 205.84,105.24 205.84,105.17 v2(206.02,104.99)
  IN4 w0.109: v2(206.02,104.99) 205.92,104.89 205.92,104.6 204.15,102.83 203.56,102.83 203.43,102.7 203.43,101.57 203.1,101.24 198.7,101.24 197.6,102.33 197.6,102.74 196.78,103.57 196.55,103.57 195.98,104.14 187.24,104.14 186.91,104.47 185.04,104.47 184.59,104.93 183.79,104.93 v2(183.66,105.06)
  BOTTOM w0.102: U46.B35 183.3,105.92 183.31,105.92 183.68,105.55 183.68,105.08 v2(183.66,105.06) ; U51.B2 204.67,114.61 204.62,114.66 204.28,114.66 204.1,114.49 204.09,114.49 203.92,114.31 v2(203.92,113.98)
EC_FPM_EN: length 195.5
  TOP w0.102: JUSH1.22 73.03,35.3 73.89,36.16 75.65,36.16 77.4,37.92 77.4,71.94 93.4,87.94 98.2,87.94 99.93,89.68 100.48,89.68 104.36,93.56 107.29,93.56 108,92.85 v2(108,92.78)
  IN1 w0.109: v2(172.49,112.67) 172.49,112.67 172.19,112.37 172.19,109.56 169.79,107.16 169.53,107.16 168.07,105.7 168.07,103.13 166.8,101.85 166.6,101.85 164.23,101.85 163.87,101.49 v2(162.73,101.49)
  IN2 w0.127: v2(172.49,112.67) 172.54,112.72 176.75,112.72 177.47,112.01 183.48,112.01 185.26,113.79 186.33,113.79 189.04,111.08 190.61,111.08 190.89,111.37 192.16,111.37 192.75,111.95 192.75,113.85 193.67,114.77 194.43,114.77 195.99,113.22 200.41,113.22 v2(201.16,113.97) ; v2(162.73,101.49) 161.27,102.95 156.72,102.95 155.36,101.59 150.37,101.59 147.75,98.98 146.63,98.98 144.1,96.44 136.74,96.44 136.11,97.07 134.91,97.07 132.34,94.51 110.89,94.51 110.06,93.68 108.9,93.68 v2(108,92.78)
  BOTTOM w0.102: v2(201.16,113.97) 201.16,113.9 201.36,114.1 201.36,114.9 201.5,115.04 U51.B62
EDP_AUXN: length 115
  TOP w0.089: 189.89,64.45 189.97,64.37 190.25,64.37 190.34,64.28 190.34,64.16 190.25,64.06 CPU1.B26
  TOP w0.101: v2(191.03,69.14) 190.84,68.94 190.71,68.94 190.58,69.07 190.58,69.21 190.73,69.36 190.73,69.44 190.67,69.51 190.35,69.51 v4(190.07,69.24) 189.93,69.09 189.93,66.32 189.78,66.18 189.78,65.19 189.89,65.08 189.89,64.45
  IN3 w0.089: v2(191.03,69.14) 190.93,69.25 190.59,69.25 190.37,69.47 190.37,70.88 190.35,70.89 190.35,70.91
  IN3 w0.127: 190.35,70.91 190.35,71.01 188.64,72.72 188.64,74.63 184,79.27 182.18,79.27 181.73,79.73 167.41,79.73 165.38,81.76 165.38,82.6 161.44,86.54 161.44,89.53 161.04,89.93 160.47,89.93 160.08,90.32 158.44,90.32 156.89,91.87 156.89,97.94 157.97,99.02 157.97,101.66 158.25,101.94 158.25,103.77 158.95,104.47 159.05,104.47 159.39,104.81 159.39,105.16 159.24,105.3 159.24,107.16 160.89,108.81 160.89,110.57 160.44,111.02 160.12,111.02 159.43,111.71 159.43,112.48 156.89,115.02 156.89,117.71 156.27,118.33 156.27,119.26 156.27,121.94 156.38,122.05 156.38,126.15 153.84,128.7 149.55,128.7 146.6,131.66 143.86,131.66 143.36,132.16 142.96,132.16 142.73,132.39 v2(142.73,133.25)
  BOTTOM w0.102: C555.1 141.67,132.08 141.67,131.71 141.77,131.6 142.18,131.6 143.1,132.53 143.1,132.74 143.04,132.8 142.57,132.8 142.5,132.87 142.5,133.03 142.72,133.25 v2(142.73,133.25)
EDP_AUXN_C: length 5.3
  BOTTOM w0.102: U630.27 143.23,136.78 143.11,136.9 142.96,136.9 142.8,136.75 142.63,136.34 142.63,135.99 142.03,135.39 142.03,134.68 v4(141.86,134.51) 141.65,134.3 141.65,133.43 141.74,133.34 142.02,133.34 C555.2
EDP_AUXP: length 115
  TOP w0.101: v2(191.03,69.73) 190.26,69.73 189.71,69.18 189.71,66.41 189.57,66.27 189.57,65.1 189.69,64.98 189.69,63.91 CPU1.C26
  IN3 w0.089: v2(191.03,69.73) 191.03,69.64 190.85,69.46 190.68,69.46 190.58,69.56 190.58,70.88 190.6,70.89 190.6,70.91
  IN3 w0.127: v2(143.32,133.25) 143.32,133.03 143.26,132.98 143.08,132.98 142.98,132.88 142.98,132.49 143.06,132.41 143.47,132.41 143.97,131.91 146.7,131.91 149.66,128.95 153.94,128.95 156.63,126.26 156.63,121.95 156.52,121.83 156.52,119.34 156.52,119.34 156.52,118.43 157.14,117.81 157.14,115.13 159.68,112.58 159.68,111.81 160.22,111.27 160.54,111.27 161.14,110.68 161.14,108.7 159.49,107.06 159.49,105.41 159.64,105.26 159.64,104.71 159.16,104.22 159.06,104.22 158.5,103.66 158.5,101.83 158.22,101.56 158.22,98.92 157.14,97.83 157.14,91.97 158.54,90.56 160.18,90.56 160.57,90.18 161.15,90.18 161.69,89.64 161.69,86.64 165.63,82.7 165.63,81.87 167.51,79.98 181.83,79.98 182.29,79.52 184.1,79.52 188.89,74.73 188.89,72.83 190.6,71.12 190.6,70.91
  BOTTOM w0.102: C558.1 141.19,132.49 141.46,132.23 141.46,131.62 141.68,131.39 v4(142.02,131.39) 142.27,131.39 143.32,132.44 v2(143.32,133.25)
EDP_AUXP_C: length 5.2
  BOTTOM w0.102: U630.28 143.23,137.18 143.17,137.12 142.87,137.12 142.62,136.87 142.41,136.38 142.41,136.08 v4(142.15,135.81) 141.81,135.48 141.81,134.77 141.43,134.39 141.43,133.65 C558.2
EDP_COMP: length 9.9
  TOP w0.254: CPU1.D37 197.68,62.73 v2(197.78,62.8)
  TOP w0.508: RC1.2 203.78,65.09 v2(204.23,65.55)
  IN2 w0.508: v2(197.78,62.8) 198.26,62.31 201.25,62.31 204.23,65.3 v2(204.23,65.55)
EDP_IN1_AEQ#: length 4.5
  BOTTOM w0.102: v1(154.28,132.8) 155.03,132.8 R140.1 154.92,133.54 154.65,133.54 153.41,134.78 U630.59
EDP_IN1_PEQ: length 6.1
  TOP w0.102: v2(154.75,138.58) 154.89,138.72 154.89,139.21 v1(154.77,139.33) 154.6,139.5 154.6,140.23 R137.1
  BOTTOM w0.102: R127.1 154.97,138.58 v2(154.75,138.58) 154.28,138.58 153.28,137.58 U630.52
EDP_IN2_AEQ#: length 3.1
  BOTTOM w0.102: U630.58 153.56,135.18 v1(154.09,134.65) 154.6,134.13 R142.1
EDP_IN2_PEQ: length 6.5
  TOP w0.102: v2(155.2,140.22) 155.2,140.58 v1(154.89,140.89) R138.1
  BOTTOM w0.102: v2(155.2,140.22) 155.35,140.06 R133.1 154.47,139.21 153.24,137.98 U630.51
EDP_MUX_PC0: length 7.1
  TOP w0.102: v2(147.93,140.86) 147.93,142.26 v1(147.81,142.39) 147.65,142.54 147.12,142.54 146.78,142.2 146.18,142.2 R100.1 R136.1
  BOTTOM w0.102: v2(147.93,140.86) 147.36,140.29 147.36,139.59 147.21,139.44 U630.38
EDP_MUX_PC1: length 6.7
  TOP w0.102: R141.1 154.35,139.53 154.35,137.94 154.66,137.62 v2(154.66,136.67)
  BOTTOM w0.102: U630.55 154.37,136.38 v2(154.66,136.67) 155.05,136.67 155.22,136.49 R109.1
EDP_MUX_PI0: length 6.4
  TOP w0.102: R139.1 153.87,139.05 v1(153.87,137.89) 153.87,137.72 154.22,137.37 154.22,136.4 154.62,136 v2(154.62,135.97)
  BOTTOM w0.102: R143.1 155.35,135.25 v2(154.62,135.97) 154.62,135.98 U630.56
EDP_TXN0: length 97.7
  TOP w0.089: v2(192.15,62.44) 192.47,62.11 CPU1.E29
  IN3 w0.089: 188.68,70.59 189.25,70.02 189.25,66.33 189.59,66 189.59,65.91 189.59,65.1 190.31,64.38 190.45,64.38 190.93,63.89 190.93,63.38 191.14,63.17 191.74,62.58 192.01,62.58 v2(192.15,62.44)
  IN3 w0.127: v2(152.99,126.68) 153.16,126.51 153.16,126.22 153.23,126.15 153.23,125.65 152.78,125.2 152.78,123.55 154.28,122.05 154.28,118.03 155.49,116.83 155.49,113.59 155.81,113.26 155.81,111.74 156.32,111.24 156.32,108.18 156.89,107.61 156.89,102.5 156.61,102.22 156.61,99.95 155.49,98.83 155.49,88.95 156.73,87.71 158.28,87.71 163.05,82.95 163.05,81.36 166.48,77.93 172.76,77.93 173.58,77.11 183.68,77.11 185.28,75.52 185.28,72.69 186.95,71.01 188.07,71.01 188.5,70.59 188.68,70.59
  BOTTOM w0.102: C563.1 153.29,129.73 v4(153.29,127.71) 153.29,127.33 153.18,127.21 153.18,126.88 v2(152.99,126.68)
EDP_TXN0_C: length 3.8
  BOTTOM w0.102: C563.2 153.27,131.26 153.27,131.54 152.99,131.82 152.52,131.82 151.74,132.6 151.74,133.05 151.61,133.19 U630.2
EDP_TXN1: length 98.4
  TOP w0.089: v2(191.35,61.84) 191.63,62.11 CPU1.E28
  IN3 w0.089: 186.19,70.73 186.2,70.72 186.23,70.72 186.27,70.68 186.83,70.12 188.15,70.12 188.64,69.64 188.64,66 189,65.64 189,64.89 189.85,64.04 189.85,62.26 190.28,61.83 190.8,61.83 191.22,62.25 191.51,62.25 191.57,62.2 191.57,62.01 191.4,61.84 v2(191.35,61.84)
  IN3 w0.127: v2(151.71,126.34) 151.88,126.16 151.88,125.39 152.05,125.22 152.05,122.69 153.59,121.15 153.59,117.52 153.97,117.14 153.97,113.72 153.71,113.47 153.71,112.03 153.95,111.8 155.55,110.19 155.55,107.49 156.1,106.94 156.1,102.99 155.93,102.82 155.93,100.41 154.67,99.15 154.67,92.8 153.84,91.97 153.84,89.39 156.2,87.03 157.31,87.03 162.16,82.18 162.16,81.13 167.13,76.16 183.64,76.16 184.58,75.23 184.58,72.34 186.19,70.73
  BOTTOM w0.102: C567.1 151.64,128.27 151.98,127.93 151.98,126.6 151.71,126.34 v2(151.71,126.34)
EDP_TXN1_C: length 5.4
  BOTTOM w0.102: U630.5 150.41,133.02 150.5,132.93 150.5,132.45 151.06,131.9 151.31,131.9 151.95,131.26 v4(151.95,130.26) 151.95,129.5 C567.2
EDP_TXN2: length 104.5
  TOP w0.089: CPU1.B29 192.46,64.14 192.35,64.14 192.05,64.44 192.05,64.94 192.26,65.15 192.26,67.79 191.75,68.3 v4(191.75,68.52) 191.75,68.83 191.95,69.03 192.39,69.03 v2(192.54,69.18)
  IN3 w0.127: v2(192.54,69.18) 192.21,69.18 192.13,69.26 192.13,70.6 190.3,72.44 190.3,73.31 190.49,73.51 190.49,75.66 189.95,76.2 188.49,76.2 186.52,78.16 186.52,79.45 185.44,80.53 182.67,80.53 182.55,80.66 168.74,80.66 162.47,86.93 162.47,89.85 162.07,90.26 162.07,90.6 161.09,91.58 159.55,91.58 159.23,91.27 158.84,91.27 157.96,92.15 157.96,97.58 159.49,99.11 159.49,99.3 160.21,100.02 160.21,102.58 160.44,102.81 160.44,104.21 160.89,104.66 160.89,107.49 161.9,108.5 161.9,111.38 159.3,113.98 159.3,115.52 158.25,116.58 158.25,119.47 158.03,119.69 157.88,119.84 157.88,119.84 157.81,119.9 157.53,119.9 157.23,120.21 157.23,120.31 157.23,121.58 157.4,121.75 157.4,126.46 154.17,129.69 153.24,129.69 152.67,130.25 150.66,130.25 150.38,129.98 v2(150.38,129.38)
  BOTTOM w0.102: C571.1 150.51,129.72 150.51,129.51 150.39,129.38 v2(150.38,129.38)
EDP_TXN2_C: length 3.2
  BOTTOM w0.102: U630.7 149.61,132.9 149.69,132.82 149.69,132.34 150.5,131.53 150.5,131.29 C571.2
EDP_TXN3: length 102
  TOP w0.089: CPU1.B28 191.79,64.03 191.79,63.77 191.7,63.69 191.54,63.69 191.45,63.78 191.45,64.99 191.25,65.18 191.25,66.04 191.33,66.11 191.52,66.11 191.66,65.97 191.71,65.97 191.81,65.87 v2(191.81,65.75)
  IN3 w0.089: 189.76,70.54 189.76,66.99 191,65.75 v2(191.81,65.75)
  IN3 w0.127: 189.76,70.54 189.65,70.65 189.64,70.65 187.94,72.34 187.94,74.28 184.41,77.81 182.18,77.81 180.95,79.05 166.5,79.05 164.7,80.86 164.7,82.32 158.6,88.41 157.11,88.41 156.19,89.32 156.19,98.45 157.29,99.55 157.29,101.94 157.57,102.22 157.57,108.11 157.14,108.54 157.14,108.69 157.13,108.7 157.13,109.25 157.14,109.26 157.14,113.59 156.19,114.53 156.19,117.26 156.19,117.36 155.43,118.12 155.43,121.87 154.54,122.77 154.54,125.03 154.47,125.1 154.47,126.85 153.38,127.94 152.06,127.94 151.64,127.53 150.76,127.53 149.56,126.32 148.92,126.32 148.63,126.6 148.63,126.93 v2(148.51,127.05)
  BOTTOM w0.102: C572.1 149.18,127.94 149.18,127.8 149.12,127.74 148.97,127.74 148.68,127.45 148.68,127.21 v2(148.51,127.05)
EDP_TXN3_C: length 5
  BOTTOM w0.102: C572.2 149.18,129.52 149.18,131.41 148.5,132.09 148.5,132.93 148.41,133.02 U630.10
EDP_TXP0: length 97.7
  TOP w0.089: CPU1.D29 192.52,62.76 v2(192.15,63.14)
  IN3 w0.089: 188.53,70.91 188.6,70.84 188.76,70.84 188.91,70.68 188.91,70.65 189.46,70.1 189.46,66.42 189.8,66.08 189.8,65.82 189.8,65.82 189.8,65.19 190.4,64.59 190.53,64.59 191.15,63.98 191.15,63.47 191.81,62.8 192.15,62.8 192.24,62.9 192.24,63.04 v2(192.15,63.14)
  IN3 w0.127: v2(153.57,126.68) 153.57,126.64 153.41,126.47 153.41,126.32 153.48,126.25 153.48,125.55 153.03,125.09 153.03,123.65 154.53,122.15 154.53,118.14 155.74,116.93 155.74,113.69 156.06,113.37 156.06,111.84 156.56,111.34 156.56,108.29 157.14,107.72 157.14,102.4 156.86,102.12 156.86,99.84 155.74,98.72 155.74,89.05 156.83,87.96 158.39,87.96 163.3,83.05 163.3,81.46 166.58,78.18 172.87,78.18 173.69,77.36 183.78,77.36 185.53,75.62 185.53,72.79 187.05,71.26 188.17,71.26 188.53,70.91
  BOTTOM w0.102: v2(153.57,126.68) 153.4,126.85 153.4,127.12 153.51,127.24 v4(153.51,129) 153.51,129.7 C561.1
EDP_TXP0_C: length 3.8
  BOTTOM w0.102: C561.2 153.48,131.35 153.48,131.63 v4(153.23,131.88) 153.08,132.04 152.61,132.04 151.96,132.69 151.96,132.97 152.01,133.02 U630.1
EDP_TXP1: length 98.4
  TOP w0.089: CPU1.F28 191.76,61.46 v2(192.14,61.84)
  IN3 w0.089: v2(192.14,61.84) 192.04,61.84 191.78,62.09 191.78,62.28 191.6,62.46 191.13,62.46 190.71,62.04 190.37,62.04 190.06,62.35 190.06,64.13 189.21,64.98 189.21,65.72 188.85,66.08 188.85,69.72 188.24,70.33 186.91,70.33 186.37,70.88 186.37,70.91
  IN3 w0.127: 186.37,70.91 184.83,72.45 184.83,75.33 183.75,76.41 167.24,76.41 162.41,81.24 162.41,82.29 157.42,87.28 156.3,87.28 154.09,89.5 154.09,91.86 154.92,92.7 154.92,99.05 156.18,100.31 156.18,102.72 156.35,102.89 156.35,107.04 155.8,107.59 155.8,110.3 153.96,112.14 153.96,113.36 154.22,113.62 154.22,117.25 153.84,117.62 153.84,121.25 152.3,122.79 152.3,125.32 152.13,125.49 152.13,126.18 152.29,126.34 v2(152.29,126.34)
  BOTTOM w0.102: C565.1 152.53,128.27 152.19,127.94 152.19,126.42 152.28,126.34 v2(152.29,126.34)
EDP_TXP1_C: length 5.4
  BOTTOM w0.102: C565.2 152.16,129.56 152.16,131.35 v4(151.64,131.87) 151.4,132.11 151.15,132.11 150.72,132.54 150.72,132.93 150.81,133.02 U630.4
EDP_TXP2: length 104.5
  TOP w0.089: CPU1.A29 192.65,64.71 192.76,64.6 192.76,64.41 192.7,64.34 192.43,64.34 192.25,64.52 192.25,64.86 192.46,65.07 v4(192.46,67.2) 192.46,67.87 191.95,68.38 191.95,68.74 192.03,68.82 192.32,68.82 v2(192.54,68.59)
  IN3 w0.127: v2(192.54,68.59) 192.54,68.73 192.48,68.79 192.39,68.79 192.25,68.93 192.11,68.93 191.88,69.16 191.88,70.5 190.05,72.33 190.05,73.41 190.24,73.61 190.24,75.55 189.84,75.95 188.38,75.95 186.28,78.06 186.28,79.34 185.34,80.28 182.57,80.28 182.44,80.41 168.64,80.41 162.22,86.82 162.22,89.75 161.82,90.15 161.82,90.5 160.98,91.33 159.65,91.33 159.34,91.02 158.74,91.02 157.71,92.05 157.71,97.68 159.24,99.21 159.24,99.4 159.97,100.13 159.97,102.68 160.19,102.91 160.19,104.32 160.64,104.76 160.64,107.59 161.65,108.61 161.65,111.28 159.05,113.88 159.05,115.42 158,116.47 158,119.37 157.78,119.59 157.77,119.59 157.71,119.65 157.43,119.65 156.98,120.1 156.98,120.41 156.98,121.68 157.15,121.85 157.15,126.36 154.06,129.44 153.14,129.44 152.57,130 150.76,130 150.66,129.9 150.66,129.7 150.79,129.57 150.79,129.53 150.94,129.38 v2(150.97,129.38)
  BOTTOM w0.102: v2(150.97,129.38) 150.73,129.62 150.73,129.71 C569.1
EDP_TXP2_C: length 3.2
  BOTTOM w0.102: U630.6 150.01,132.94 149.9,132.83 149.9,132.43 v4(150.32,132.02) 150.72,131.62 150.72,131.32 C569.2
EDP_TXP3: length 102
  TOP w0.089: v2(191.81,66.33) 191.79,66.31 191.24,66.31 191.05,66.12 191.05,65.1 191.25,64.9 191.25,63.7 191.47,63.48 191.69,63.48 CPU1.C28
  IN3 w0.089: v2(191.81,66.33) 191.81,66.18 191.73,66.1 191.58,66.1 191.44,65.96 191.09,65.96 189.97,67.08 189.97,70.42 189.99,70.44 189.99,70.63 189.94,70.68 189.94,70.71 189.76,70.9 189.74,70.9 189.73,70.91
  IN3 w0.127: 189.73,70.91 188.19,72.44 188.19,74.38 184.51,78.06 182.29,78.06 181.05,79.3 166.61,79.3 164.95,80.96 164.95,82.42 158.71,88.66 157.21,88.66 156.44,89.43 156.44,98.35 157.54,99.44 157.54,101.84 157.82,102.12 157.82,108.22 157.39,108.64 157.39,108.79 157.38,108.8 157.38,109.15 157.39,109.15 157.39,113.69 156.44,114.64 156.44,117.16 156.44,117.47 155.68,118.23 155.68,121.97 154.79,122.87 154.79,125.13 154.72,125.2 154.72,126.95 153.48,128.19 151.95,128.19 151.54,127.78 150.66,127.78 150.51,127.63 149.45,126.57 149.02,126.57 148.88,126.71 148.88,126.83 v2(149.1,127.05)
  BOTTOM w0.102: v2(149.1,127.05) 148.96,127.19 148.96,127.42 149.06,127.52 149.21,127.52 149.39,127.71 149.39,127.94 C570.1
EDP_TXP3_C: length 5
  BOTTOM w0.102: U630.9 148.81,133.02 148.72,132.93 148.72,132.18 v4(149.01,131.89) 149.39,131.5 149.39,129.53 C570.2
EDRAM_OPIO_RCOMP: length 12.9
  TOP w0.254: CPU1.BR25 188.76,24.33 188.76,23.78 188.49,23.51 v1(188.49,21.91) 188.49,20.59 189.42,19.66 189.79,19.66 189.93,19.63 191.73,19.63 194.96,16.41 RC228.2
EDRAM_OPIO_RCOMP_ED2: length 13.9
  TOP w0.254: CPU1.BP25 189.54,25.01 189.54,23.69 189.48,23.63 189.48,22.43 189.22,22.17 189.22,20.63 189.64,20.21 v1(190.63,20.21) 191.73,20.21 193.83,18.11 194.33,18.11 195.04,17.4 195.36,17.4 196.16,16.6 RC229.2
EN_+1VSP: length 3.7
  TOP w0.254: PC800.1 100.89,129.43 v2(100.89,129.1) 100.89,128.34 PU800.3
  BOTTOM w0.254: PR809.2 PR804.2 100.58,129.42 v2(100.89,129.1)
EN_DK_PWRBAR: length 2.7
  TOP w0.254: PR1028.1 PR1027.1 337.75,55.39 v2(337.73,55.41) 337.5,55.19 PU1001.17
EN_DOCK_PWR_BAR: length 244.2
  TOP w0.254: v2(339.94,55.52) 339.81,55.39 PR1027.2
  IN2 w0.127: v2(181.62,107.59) 181.62,107 182.23,106.39 184.09,106.39 185.98,104.49 186.86,104.49 187.57,103.78 190.28,103.78 191.11,102.94 191.11,102.41 192.3,101.23 193.13,101.23 194.33,100.03 196.13,100.03 196.26,99.9 199.91,99.9 200.45,99.36 201.33,99.36 202.3,98.39 203.3,98.39 203.34,98.36 203.9,98.36 205.19,97.07 207.45,97.07 210,94.52 210,92.7 212.07,90.63 212.65,90.63 213.47,89.81 213.47,87.06 215.43,85.09 218.27,85.09 221.6,81.76 222.83,81.76 223.72,80.87 237.97,80.87 241.33,77.51 241.83,77.51 242.72,76.63 242.72,75.91 244.3,74.33 245.2,74.33 245.98,73.55 248.36,73.55 250.8,71.11 250.8,65.95 250.23,65.38 250.23,61.33 252.22,59.35 259.06,59.35 275.66,42.75 278.25,42.75 281.99,39.01 285.36,39.01 289.09,35.28 289.62,35.28 291.58,33.32 291.58,30.61 293.64,28.56 297.03,28.56 297.73,27.86 304.11,27.86 304.87,27.1 310.46,27.1 312.3,28.94 312.3,29.76 312.69,30.16 314.12,30.16 314.13,30.15 314.14,30.16 315.17,29.13 320.94,29.13 321.45,28.62 322.33,28.62 323.65,27.3 323.65,26.79 324.13,26.31 325.68,26.31 327.1,27.73 329.04,27.73 330.55,29.24 330.55,30.13 335.47,35.06 335.47,39.72 335.04,40.15 335.04,43.02 334.65,43.41 334.65,47.75 335.19,48.28 336.27,48.28 337.54,49.55 341.1,49.55 343.28,51.73 343.28,55.63 340.5,58.41 340.15,58.41 339.46,57.73 339.46,56 v2(339.94,55.52)
  BOTTOM w0.102: v2(181.62,107.59) 181.62,107.49 181.59,107.46 181.59,107.01 182.3,106.3 U46.B37
EN_EDRAMP: length 6.1
  TOP w0.102: v1(72.9,3.37) 72.9,5.15 73.22,5.47 PC507.1
  TOP w0.254: PR507.1 74.3,5.47 PR510.1 74.28,5.47 PC507.1 73.4,5.88 73.97,6.45 PU500.5
EN_EOPIOP: length 5.9
  TOP w0.102: PC1806.1 58.44,5.3 58.81,4.94 v1(58.81,3.41)
  TOP w0.254: PU1800.5 56.85,6.16 56.43,5.74 PR1807.1 PR1809.1 PC1806.1
EN_I2S_NB_CODEC#: length 197.9
  TOP w0.102: v2(322.15,30.2) 320.7,30.2 320.11,30.79 320.11,34.26 319.98,34.39 319.67,34.39 318.61,35.44 318.61,35.78 v1(318.43,35.96) 317.09,37.3 JIO1.45
  IN2 w0.127: v2(322.15,30.2) 322.13,30.22 314.79,30.22 314.35,30.67 309.22,30.67 309.14,30.59 307.41,30.59 306.49,29.67 305.86,29.67 304.97,28.79 304.27,28.79 303.99,29.06 296.69,29.06 292.23,33.52 292.23,34.76 290.62,36.37 288.71,36.37 285.57,39.52 282.2,39.52 278.46,43.25 275.87,43.25 259.27,59.85 252.43,59.85 250.74,61.54 250.74,65.17 251.31,65.74 251.31,71.58 250.21,72.68 248.83,74.06 246.19,74.06 245.41,74.84 244.51,74.84 243.23,76.13 243.23,76.84 241.99,78.08 241.56,78.08 238.26,81.38 223.93,81.38 223.04,82.27 221.81,82.27 218.48,85.6 215.64,85.6 213.97,87.27 213.97,90.03 212.86,91.14 212.31,91.14 211.09,92.36 211.09,95.15 209.32,96.92 208.39,96.92 206.44,98.86 203.55,98.86 203.52,98.9 202.51,98.9 201.54,99.87 200.66,99.87 200.12,100.4 196.47,100.4 196.34,100.54 194.54,100.54 193.34,101.73 192.63,101.73 191.7,102.67 191.7,103.08 190.45,104.33 189.37,104.33 188.6,105.1 186.53,105.1 186.19,105.45 186.19,105.47 185.37,106.29 184.93,106.29 184.58,106.64 182.57,106.64 v2(182.22,106.99)
  BOTTOM w0.102: v2(182.22,106.99) 182.49,106.72 182.66,106.72 182.8,106.58 U46.B36
EN_INVPWR: length 242.8
  IN1 w0.109: v2(113.43,136.81) 113.43,136.7 114.47,135.66 125.96,135.66 126.28,135.97 131.49,135.97 133.07,137.56 134.34,137.56 136.02,135.88 142.39,135.88 143.4,136.9 146,136.9 146.84,137.73 150.36,137.73 158.18,145.56 159.53,145.56 160.71,146.74 160.71,147.73 161.55,148.57 161.55,149.61 161.95,150.01 161.95,153.19 163.03,154.27 165.66,154.27 166.54,155.15 168.41,155.15 169.22,154.34 176.94,154.34 v2(177.27,154.68)
  IN2 w0.127: v2(211.75,147.57) 210.99,146.81 203.83,146.81 203.43,147.2 199.03,147.2 195.18,151.05 193.48,151.05 191.24,153.29 187.94,153.29 184.41,156.83 182.07,156.83 181.42,156.18 178.29,156.18 177.27,155.16 v2(177.27,154.68)
  IN3 w0.127: v2(211.75,147.57) 211.75,147.47 216.2,143.02 222.87,143.02 232.58,133.31 232.58,129.22 233.21,128.59 233.27,128.59 234.79,127.08 237.22,127.08 241.1,123.2 241.1,117.66 241.51,117.25 241.51,108.81 245.19,105.13 246.88,105.13 247.6,104.41 247.6,103.47 245.22,101.09 244.33,101.09 243.53,101.88 240.91,101.88 v2(240.39,101.36)
  IN4 w0.109: v2(204.67,100.56) 204.67,100.63 206.2,102.16 206.2,103.45 206.86,104.11 215.55,104.11 216.24,104.8 219.28,104.8 219.5,105.02 219.77,105.02 220.51,105.02 221.08,104.44 222.8,104.44 224.43,102.81 225.8,102.81 226.33,102.28 237.97,102.28 238.89,101.36 v2(240.39,101.36)
  BOTTOM w0.102: U51.A25 200.25,105.31 200.45,105.11 200.45,104.14 200.89,103.7 200.89,102.89 200.84,102.84 200.84,101.82 201.6,101.06 v1(203.08,101.06) 204.17,101.06 v2(204.67,100.56) 204.89,100.34 RP7.6 ; v2(113.43,136.81) 113.43,135.31 Q22.2
EN_PIC_LDO: length 180.8
  TOP w0.102: JIO2.61 58.38,37.35 58.84,37.82 v2(58.84,37.87) ; v2(107.86,99.44) 107.98,99.31 107.98,96.09 108.81,95.26 110.9,95.26 111.85,94.32 113.58,94.32 115.04,92.86 v2(115.04,91.33)
  IN2 w0.127: v2(107.86,99.44) 110.49,96.81 133.16,96.81 135.06,98.71 144.33,98.71 145.47,99.85 145.47,100.86 146.39,101.78 147.39,101.78 149.34,103.72 150.11,103.72 150.11,103.72 155.29,103.72 157.56,105.99 160.11,105.99 164.27,101.84 165.52,101.84 166.07,102.38 167.94,102.38 168.61,103.06 170.16,103.06 170.26,103.15 173.6,103.15 173.97,103.53 174.73,103.53 175.15,103.11 175.94,103.11 176.34,102.7 176.96,102.7 177.25,102.98 177.25,103.68 176.33,104.59 v2(176.04,104.59)
  IN4 w0.109: v2(115.04,91.33) 115.04,90.32 113.9,89.17 108.56,89.17 95.48,76.09 95.48,68.16 69.7,42.37 68.13,42.37 63.81,38.06 59.03,38.06 v2(58.84,37.87)
  BOTTOM w0.102: U46.A47 176.05,104.6 v2(176.04,104.59)
ENVDD_PCH: length 196.9
  TOP w0.089: UH1.W42 114.67,111.31 115.11,110.87 v2(115.49,110.87)
  IN2 w0.089: v2(115.49,110.87) 115.53,110.87 115.92,111.27 120.1,111.27 120.48,110.89 120.48,110.15 120.89,109.74 127.91,109.74 128.23,110.07 134.6,110.07 136.22,108.45 139.27,108.45 140.22,107.49 141.76,107.49
  IN2 w0.127: 141.76,107.49 142.12,107.49 142.32,107.69 144.16,107.69 144.89,108.41 150.28,108.41 150.79,107.91 152.25,107.91 154.51,110.17 163.83,110.17 165.4,108.61 165.4,108.1 166.82,106.68 168.79,106.68 169.37,107.26 169.37,108.89 172.62,112.13 176.79,112.13 177.17,111.75 183.59,111.75 185.29,113.46 186.31,113.46 188.94,110.83 190.88,110.83 191.15,111.1 192.26,111.1 193.66,112.5 193.9,112.5 194.01,112.61 195.76,112.61 196.9,111.47 197.24,111.47 197.38,111.61 202.52,111.61 203.23,112.33 204.11,112.33 204.18,112.26 206.3,112.26 v2(206.67,111.89)
  IN4 w0.089: v2(115.49,110.87) 114.24,110.87 113.53,111.58 112.37,111.58
  IN4 w0.109: 112.37,111.58 110.56,111.58 110.04,111.06 110.04,110.64 110.04,110.64 110.04,110.49 108.21,108.66 104.85,108.66 103.82,107.62 103.82,104 104.4,103.42 104.4,102.68 102.62,100.9 100.66,100.9 99.85,101.72 99.85,104.64 96.83,107.66 96.83,113.16 94.83,115.16 91.93,115.16 90.19,116.89 90.19,123.67 98.18,131.65 98.18,135.7 101.97,139.5 103.47,139.5 104.18,140.21 106.6,140.21 109.39,143 110.83,143 v2(111.17,143.34)
  BOTTOM w0.102: D92.2 114.57,147.27 114,146.71 112.69,146.71 112.48,146.49 112.16,146.49 111.74,146.07 111.74,143.91 v2(111.17,143.34) ; U51.A7 206.65,111.86 v2(206.67,111.89)
EQ0_A_UN8: length 3.4
  TOP w0.102: v1(30.18,32.05) RN106.1 RN108.2 29.79,29.88 UN8.23
EQ0_A_UN9: length 4.8
  TOP w0.102: UN9.23 40.25,29.95 40.52,30.22 40.52,30.75 v1(40.9,31.13) 41.33,31.57 41.33,32.25 41.46,32.38 RN121.2 RN125.1
EQ0_B_UN8: length 4.2
  TOP w0.102: UN8.11 24.25,28.38 23.93,28.7 22.92,28.7 v1(22.66,28.45) 22.41,28.19 RN114.2 RN60.1
EQ0_B_UN9: length 2.4
  TOP w0.102: UN9.11 34.64,28.45 34.55,28.37 RN129.2 RN55.1
EQ1_A_UN8: length 2.3
  TOP w0.102: RN107.1 RN109.2 30.18,29.38 UN8.22
EQ1_A_UN9: length 4
  TOP w0.102: UN9.22 40.28,29.45 40.51,29.68 v1(40.77,29.68) 41.04,29.94 41.04,30.59 41.46,31.01 RN126.1 RN122.2
EQ1_B_UN8: length 5.2
  TOP w0.102: RN51.1 30.59,25.45 30.46,25.57 v1(30.46,25.78) 30.46,26.51 RN115.2 29.7,27.27 29.7,28.52 29.34,28.88 UN8.21
EQ1_B_UN9: length 7.3
  TOP w0.102: UN9.21 40.34,28.95 40.67,29.28 40.95,29.28 41.41,29.74 41.41,30.2 41.76,30.55 42.9,30.55 43.46,29.99 RN57.1 44.61,29.99 RN130.2 45.22,29.89 v1(45.63,29.48)
EQ2_A_UN8: length 3.9
  TOP w0.102: RN104.2 RN105.1 28.81,25.34 28.86,25.39 v1(28.86,25.8) 28.86,26.44 28.76,26.53 UN8.19
EQ2_A_UN9: length 3.3
  TOP w0.102: RN123.2 RN124.1 41.71,28.62 40.92,27.83 v1(40.77,27.83) 40.65,27.95 UN9.19
EQ2_B_UN8: length 7.2
  TOP w0.102: v2(24.82,26.77) 24.46,26.41 24.24,26.41 23.65,25.83 23.02,25.83 22.53,25.34 RN110.2 RN111.1 ; UN8.16 v2(26.96,26.26)
  IN2 w0.127: v2(24.82,26.77) 25.33,26.26 v2(26.96,26.26)
EQ2_B_UN9: length 10.1
  TOP w0.102: v2(32.31,24.68) 32.34,24.71 RN128.1 32.52,25.83 32.52,26.59 32.41,26.69 RN127.2 ; UN9.16 v2(37.94,26.33)
  IN1 w0.109: v2(37.94,26.33) 36.67,25.06 34.1,25.06 33.81,25.34 32.67,25.34 32.31,24.99 v2(32.31,24.68)
ERC1: length 2.1
  TOP w0.254: PC1007.1 331.96,49.04 332.7,49.78 PU1001.3
ERC2: length 1.9
  TOP w0.254: PC1009.1 338.28,52.85 v2(337.72,52.85) 337.39,53.19 PU1001.13
ERC3: length 3.5
  TOP w0.102: v1(339.75,51.96) PC1008.1
  TOP w0.254: PC1008.1 337.92,51.96 337.19,52.69 PU1001.12
FAN1_PWM: length 211.8
  TOP w0.102: v2(107.25,100.05) 106.81,100.05 106.02,99.27 103.23,99.27 101.96,100.54 98.72,100.54 97.36,99.18 96.61,99.18 96.18,98.74 ; R28.1 R22.1 R407.2 257.55,87.03 257.2,86.68 255.78,86.68 253.48,88.98 252.14,88.98 250.21,90.91 249.88,90.91 249.3,91.49 248.67,91.49 247.18,90 244.83,90 243.63,88.79 242.2,88.79 238.84,85.44 238.84,81.39 239.17,81.06 239.17,78.57 239.75,77.99 239.75,74.98 v2(239.24,74.46)
  TOP w0.762: JFAN1.3 94.28,96.85 96.18,98.74
  IN2 w0.127: v2(239.24,74.46) 238.11,75.59 237.02,75.59 234.28,78.33 220.83,78.33 219.61,79.55 212.66,79.55 211.52,80.69 208.91,80.69 204.13,85.47 204.13,88.14 203.34,88.93 203.34,92.98 203.1,93.22 202.27,93.22 200.67,94.82 198.77,94.82 198.42,95.18 197.28,95.18 196.68,95.78 191.96,95.78 190.31,97.43 185.87,97.43 184.92,98.38 183.5,98.38 181.46,100.42 181.46,100.56 179.89,102.13 166.18,102.13 165.63,101.58 164.08,101.58 159.92,105.74 157.67,105.74 155.39,103.46 151.03,103.46 148.78,101.21 146.69,101.21 145.79,100.31 145.79,99.76 144.49,98.46 135.17,98.46 133.15,96.44 109.97,96.44 107.42,98.99 107.42,99.89 v2(107.25,100.05)
  BOTTOM w0.102: v1(106.75,100.75) 107.25,100.25 v2(107.25,100.05)
FAN1_PWM_AAC: length 2.6
  TOP w0.102: R28.2 256.57,89.3 v2(255.71,90.17) 255.66,90.21 U8.2
FAN1_PWM_EC: length 78
  TOP w0.102: v2(258.17,91.21) 258.17,91.8 258.03,91.94 R25.2 ; R22.2 256.57,88.35 v2(255.95,88.35) ; v2(227.1,107.55) 227.83,108.28 229.79,108.28 233.93,104.15 237.35,104.15 238.82,102.68 238.91,102.62 239.79,102.62 240.92,101.49 240.92,99.75 v1(241.25,99.42) 241.43,99.25 242.79,99.25 243.25,98.79 243.25,98.29 244.1,97.43 245.03,97.43 245.84,96.62 247.78,96.62 247.91,96.74 249.93,96.74 251.71,94.96 v2(253.2,94.96)
  IN2 w0.127: v2(253.2,94.96) 254.23,93.92 254.23,92.23 255.53,90.93 256.52,90.93 256.79,91.21 v2(258.17,91.21) 256.37,89.4 256.37,88.77 v2(255.95,88.35) ; v2(201.1,104.35) 201.21,104.24 201.68,104.24 202.2,103.72 203.2,103.72 203.51,103.4 206.18,103.4 206.72,102.86 209.88,102.86 210.49,102.25 215.01,102.25 215.59,101.67 217.95,101.67 218.7,102.42 218.7,102.56 219.65,103.51 220.29,103.51 221.92,105.14 222.68,105.14 223.48,105.94 225.49,105.94 v2(227.1,107.55)
  BOTTOM w0.102: v2(201.1,104.35) 201.1,104.37 200.98,104.37 200.68,104.67 200.68,105.15 200.75,105.23 U51.A24
FAN1_PWM_EC_AAC: length 2.5
  TOP w0.102: R25.1 256.31,91.58 v2(255.81,91.58) 255.58,91.81 U8.4
FAN1_TACH_EC: length 58.9
  TOP w0.102: R23.2 240.77,92.93 240.31,92.48 R13.2 240.01,92.48 v1(239.3,93.18) 239,93.49 v2(239,93.6)
  IN1 w0.109: v2(239,93.6) 239,94.19 240.45,95.64 240.45,99.52 237.34,102.64 234.23,102.64 232.47,104.4 232.12,104.4 229.97,106.55 226.94,106.55 225.51,107.97 225.51,109 v2(225.15,109.37)
  IN2 w0.127: v2(225.15,109.37) 225.12,109.33 224.03,109.33 223.7,109.67 220.84,109.67 219.99,108.83 219.99,107.86 219.36,107.22 218.37,107.22 217.83,106.69 217.83,106.02 217.5,105.68 215.38,105.68 215.25,105.81 212.35,105.81 211.61,105.07 211.12,105.07 209.95,106.25 207.97,106.25 207.48,105.75 205.33,105.75 204.93,105.35 204.27,105.35 202.34,107.28 v2(202.25,107.28)
  BOTTOM w0.102: U51.B22 202.5,106.71 202.44,106.77 202.44,106.99 202.25,107.18 v2(202.25,107.28)
FAN1_TACH_EC_AAC: length 3.2
  TOP w0.102: v1(239.73,94.89) 240,95.16 R23.1 241.15,95.16 241.29,95.01 U8.26
FAN1_TACH_FB: length 179.5
  TOP w0.102: 96.66,97.97 98.98,100.29 101.83,100.29 103.17,98.95 106.53,98.95 106.98,99.4 v2(106.98,99.43) ; R13.1 239.64,94 v2(239.46,94) 239.26,94.2 238.67,94.2 237.66,93.19 237.66,92.23 237.88,92.02 237.88,89.61 237.98,89.5 R408.2
  TOP w0.762: 96.66,97.97 94.53,95.84 92.8,95.84 92.56,95.6 JFAN1.2
  IN2 w0.127: v2(106.98,99.43) 106.98,99.02 108.42,97.58 108.42,95.53 108.89,95.06 108.89,94.21 109.16,93.94 109.95,93.94 110.78,94.76 132.24,94.76 135.31,97.84 144.58,97.84 146.67,99.92 148.24,99.92 151.26,102.94 155.63,102.94 156.6,103.91 160.93,103.91 163.9,100.95 167.04,100.95 167.39,101.29 172.14,101.29 172.44,101.59 174.02,101.59 174.52,101.1 175.32,101.1 176.1,101.87 179.79,101.87 181.21,100.45 181.21,100.31 181.21,100.22 183.3,98.13 183.39,98.13 184.81,98.13 185.77,97.18 190.2,97.18 191.85,95.53 196.53,95.53 197.3,94.76 v2(198.23,94.76)
  IN3 w0.127: v2(216.96,98.15) 216.96,97.94 221.49,93.4 229.47,93.4 230.51,94.44 239.02,94.44 v2(239.46,94)
  IN4 w0.109: v2(216.96,98.15) 213.76,98.15 212.4,96.79 207.82,96.79 207.44,96.41 204.83,96.41 203.8,97.45 203.79,97.45 203.74,97.5 198.49,97.5 v2(197.91,96.92)
  BOTTOM w0.102: R30.1 239.74,93.72 v2(239.46,94) ; v2(198.23,94.76) 197.91,95.09 v2(197.91,96.92)
FAN1_TACH_FB_AAC: length 5.9
  TOP w0.102: U8.24 v2(241.53,96.61)
  IN2 w0.127: v2(241.53,96.61) 241.35,96.61 240.64,95.91 240.64,94.74 241.41,93.97 v2(241.41,93.96)
  BOTTOM w0.102: R30.2 241.13,93.37 241.41,93.64 v2(241.41,93.96)
FAN2_PWM: length 62.4
  TOP w0.102: v2(258.22,93.16) 258.04,92.98 R409.2 257.53,93.47 257.56,93.49 R21.1 ; R213.2 269.3,43.57 D90.1 269.47,43.58 270.65,44.77 270.65,47.51 273.18,52.17 273.18,52.93 271.03,55.09 271.03,58.6 268,61.63 266.86,61.63 263.94,64.55 263.94,67.08 258.39,72.63 258.39,83.44 258.16,83.66 258.16,84.23 257.6,84.79 257.6,85.56 258.2,86.16 v1(258.2,86.16) 258.2,89.54 R27.1 257.92,90.57 v2(258.17,90.57)
  IN3 w0.127: v2(258.22,93.16) 257.59,92.53 257.59,91.16 v2(258.17,90.57)
FAN2_PWM_AAC: length 2.5
  TOP w0.102: R27.2 255.82,91.01 U8.3
FAN2_PWM_D: length 10
  TOP w0.102: D90.2 270.91,42.13 R403.2 ; D90.2 270.28,42.58 R213.1 ; D90.2 270.92,43.04 271.14,43.04 v2(271.24,43.14) JFAN2.3
FAN2_PWM_EC: length 67.8
  TOP w0.102: R21.2 R26.2 256.65,94.81 256.16,95.3 v2(255.9,95.3) ; v2(225.96,108.1) 225.98,108.1 225.98,108.22 226.03,108.28 226.23,108.28 226.51,108.56 229.83,108.56 234.02,104.38 237.45,104.38 238.97,102.86 238.98,102.85 239.89,102.85 241.27,101.47 241.65,101.47 v1(242.27,100.85) 242.78,100.34 243.13,100.34 243.48,99.99 243.48,98.38 244.14,97.72 245.06,97.72 245.93,96.85 247.69,96.85 247.81,96.97 251.74,96.97 v2(251.88,97.11)
  IN2 w0.127: v2(201.1,104.95) 201.54,104.95 202.52,103.97 203.3,103.97 203.62,103.66 205.93,103.66 206.26,103.98 212.05,103.98 212.39,103.65 216.27,103.65 216.85,104.22 218.6,104.22 219.38,105 220.23,105 221.9,106.67 221.9,106.97 222.21,107.29 222.67,107.29 223.13,106.83 225.11,106.83 225.77,107.49 225.77,107.89 225.96,108.08 v2(225.96,108.1)
  IN3 w0.127: v2(251.88,97.11) 252.2,96.79 253.18,96.79 254.66,95.31 255.88,95.31 v2(255.9,95.3)
  BOTTOM w0.102: U51.A23 201.25,105.1 v2(201.1,104.95)
FAN2_PWM_EC_AAC: length 3
  TOP w0.102: U8.5 255.58,92.61 255.71,92.74 255.71,93.29 v2(255.79,93.37) 256.29,93.87 R26.1
FAN2_TACH_EC: length 63.8
  TOP w0.102: R12.2 238.76,88.01 238.76,89.55 238.61,89.71 v1(238.61,90.5) 238.61,91.69 238.76,91.84 239.51,91.84 239.76,91.59 R24.2 240.06,91.74 239.63,92.17 239.63,92.4 239.12,92.91 238.54,92.91 v2(238.27,92.64)
  IN1 w0.109: v2(238.27,92.64) 238.27,93.86 240.2,95.79 240.2,99.44 237.24,102.4 234.14,102.4 232.37,104.17 232.02,104.17 229.88,106.31 226.84,106.31 225.2,107.95 225.2,108.16 224.4,108.96 v2(224.4,109.75)
  IN2 w0.127: v2(224.4,109.75) 224.03,109.75 223.86,109.92 220.07,109.92 217.48,107.33 217.12,107.33 216.46,106.68 216.46,106.41 215.99,105.93 215.48,105.93 215.35,106.07 210.67,106.07 209.76,106.98 208.35,106.98 207.48,106.12 205.92,106.12 205.79,106.25 203.74,106.25 202.99,107 202.99,107.17 202.24,107.92 v2(202.24,107.92)
  BOTTOM w0.102: U51.B23 201.85,106.66 201.85,107.52 v2(202.24,107.92)
FAN2_TACH_EC_AAC: length 4
  TOP w0.102: U8.27 242,94.21 241.81,94.03 241.81,93.72 241.4,93.31 v1(241.2,93.31) 241.02,93.13 241.02,92.2 240.97,92.15 R24.1
FAN2_TACH_FB: length 86.5
  TOP w0.102: v2(239.07,92.37) 238.69,92.37 238.24,91.93 238.24,89.7 238.54,89.4 238.54,88.39 R405.2 237.98,87.47 238.48,86.96 R12.1 ; 273.52,56.43 268.04,61.91 266.9,61.91 264.17,64.64 264.17,67.18 258.61,72.73 258.61,83.53 258.39,83.75 258.39,84.25 258.39,84.76 v2(258.04,85.11) ; v2(253.04,94.38) 252.87,94.21 247.59,94.21 244.86,96.95 244.23,96.95 244.17,97 244.17,97 v2(244.17,97)
  TOP w0.254: 273.52,56.43 273.52,52.12 273.5,52.1 272.07,49.48 272.07,48.42 272.46,48.03 273.36,48.03 274.27,48.93 JFAN2.2
  IN1 w0.109: v2(253.04,94.38) 254.12,93.3 254.12,87.54 256.11,85.55 257.6,85.55 v2(258.04,85.11)
  BOTTOM w0.102: v2(244.17,97) 244.17,97 v1(243.65,97.52) 243.41,97.76 241.76,97.76 241.1,97.1 241.1,96.36 238.44,93.7 238.44,93.31 239.07,92.68 v2(239.07,92.37) 239.16,92.29 R29.1
FAN2_TACH_FB_AAC: length 6.1
  TOP w0.102: v2(241.53,95.97) 241.69,95.81 U8.25
  IN2 w0.127: v2(241.63,92.91) 242.04,93.32 242.04,95.46 v2(241.53,95.97)
  BOTTOM w0.102: R29.2 240.84,92.29 241.46,92.91 v2(241.63,92.91)
FB_2.5V: length 4.3
  TOP w0.254: PR404.2 PC402.2 PR405.1 15.05,58.11 15.31,57.85 v1(15.31,57.7) 15.31,57.57 15.05,57.3 15.05,57.02 15.34,56.73 PU400.1
FB_3PH_A: length 7.4
  TOP w0.102: v1(259.27,53.06) 258.86,52.66 PC1115.2
  TOP w0.203: PR1131.1 259.22,49.87 258.03,49.87 257.75,49.59 PU1100.5
  TOP w0.254: PC1115.2 258.85,52.14 PC1113.2 259.71,51.28 PR1130.1 259.74,50.39 PR1131.1
FB_3PH_B: length 7.9
  TOP w0.102: PR1137.1 258.04,34.99 258.13,34.9 v1(258.13,34.65)
  TOP w0.203: PR1136.1 257.18,40.22 257.18,41.22 257.35,41.39 PU1100.34
  TOP w0.254: PR1136.1 258.04,39.36 PC1117.1 258.04,36.75 PC1116.2 258.04,36.7 PR1137.1
FB_3V: length 3.8
  TOP w0.203: v2(347.66,30.51) 347.88,30.74 PU101.4
  TOP w0.254: PR100.2 347.59,30.44 v2(347.66,30.51)
  BOTTOM w0.254: v2(347.66,30.51) 348.22,31.07 PR102.2
FB_5V: length 3.6
  TOP w0.203: PU101.2 348.48,31.54 v2(348.31,31.71)
  BOTTOM w0.102: PR101.1 348.55,33.34 v1(347.72,33.34)
  BOTTOM w0.254: PR101.1 348.63,33.26 PR104.1 348.63,32.02 v2(348.31,31.71)
FB_+1VSP: length 3.7
  TOP w0.254: PR807.1 99.33,130.37 99.33,129.64 v1(99.39,129.58) 99.47,129.5 99.69,129.5 100.03,129.84 PR808.1 100.34,129.81 PU800.4
FB_+V0.95SP: length 7.1
  TOP w0.254: v2(330.48,23.2) 330.66,23.2 PR310.1 331.19,22.69 PR309.2 PR307.1 ; PU300.4 330.01,19.55 330.42,19.96 v2(330.42,20.09)
  IN3 w0.508: v2(330.48,23.2) 330.48,20.15 v2(330.42,20.09)
FFS_INT2: length 171.8
  TOP w0.089: 112.37,118.31 112.5,118.44 113.1,118.44 113.24,118.57 113.71,118.57 113.86,118.42 113.86,118.15 114.02,117.99 114.02,117.64 114.17,117.49 114.47,117.49 114.63,117.65 114.63,117.81 115.01,118.19 UH1.AN41
  TOP w0.102: 112.37,118.31 112.01,117.95 110.6,117.95 109.55,118.99 v2(108.77,118.99) ; v2(10.12,42.39) Q29.2 8.4,42.39 7.07,41.06 R504.2
  TOP w0.254: R504.2 6.58,41.3 v1(6.58,42.57) 6.58,44.53 6.39,44.73 U88.11
  IN1 w0.109: v2(108.77,118.99) 108.16,118.38 108.16,117.65 107.24,116.73 104.47,116.73 v2(103.15,118.05)
  IN2 w0.127: v2(103.15,118.05) 102.93,118.05 102.37,117.5 101.43,117.5 96.63,112.69 96.63,110.43 95.52,109.32 95.52,104.22 89.93,98.63 89.93,88.6 82.75,81.42 82.75,72.67 74.12,64.05 58.4,64.05 56,66.45 54.97,66.45 54.54,66.02 27.94,66.02 24.44,62.52 24.44,54.93 17.79,48.28 13.89,48.28 11.89,46.28 11.89,44.16 v2(10.12,42.39)
FFS_INT2_Q: length 47.7
  TOP w0.102: U639.4 9.25,37.27 R386.2 v1(9.92,38.93) v2(8.95,39.91)
  IN3 w0.127: v2(33.95,20.53) 32.62,19.2 23.82,19.2 22.78,20.25 22.78,22.64 21.95,23.46 20.35,23.46 18.06,25.75 18.06,27.91 17.57,28.4 13.31,28.4 8.55,33.17 8.55,38.31 8.96,38.72 8.96,39.9 v2(8.95,39.91)
  BOTTOM w0.102: v2(33.95,20.53) 33.55,20.13 JSATA2.22
FFS_INT2_QR: length 10.2
  TOP w0.102: 8.29,41.74 8.29,40.98 8.61,40.66 R506.2 9.3,40.25 10.77,38.78 10.77,36.53 10.6,36.35 R386.1 9.23,35.66 U639.3 ; 8.29,41.74 v1(8.3,41.74) ; 8.29,41.74 Q29.3
FIVR_EN_R: length 30.1
  TOP w0.102: v1(150.98,14.56) 150.98,14.8 v2(151.6,15.42) 152.04,14.97 RC126.2 ; JXDP1.45 155.36,6.49 v2(155.36,6.49) ; RC132.1 RC217.2 161.71,13.24 v2(162.48,13.24)
  IN3 w0.127: v2(151.6,15.42) 152.4,16.21 154.14,16.21 154.14,16.22 154.51,16.22 154.52,16.21 155.17,16.21 155.46,15.93 155.46,14.85 156.19,14.12 159.11,14.12 159.99,13.24 v2(162.48,13.24)
  BOTTOM w0.102: v2(162.48,13.24) 161.03,13.24 159.17,11.39 158.08,11.39 155.89,9.2 155.89,7.02 v2(155.36,6.49)
FWP#: length 14.2
  TOP w0.102: v2(203.24,114.26) 203.04,114.46 202.56,114.46 202.23,114.79 202.23,115.53 v1(202.67,115.97) 202.9,116.2 202.9,118.34 201.35,119.89 201.35,122.12 201.62,122.38 v2(202.54,122.38)
  BOTTOM w0.102: U51.B65 203,115.4 203.15,115.25 203.15,114.88 203.18,114.86 203.18,114.32 v2(203.24,114.26) ; R872.2 R879.2 202.63,122.72 202.54,122.63 v2(202.54,122.38)
GC6_FB_EN: length 175.9
  TOP w0.089: UH1.AW27 v2(121.77,120.92)
  TOP w0.102: v2(208.7,82.83) 208.14,83.38 203.5,83.38 202.87,84.01 202.87,86.38 203,86.5 JMXM1.79
  IN3 w0.089: v2(121.77,120.92) 121.33,120.48 121.33,119.73 124.6,116.47 126.93,116.47 127.36,116.03 128.36,116.03 129.24,116.91 132.94,116.91 134.35,115.5 134.35,113.13 135.84,111.65 135.84,108.22 135.38,107.76 135.38,105.08 135.79,104.67 135.79,101.31 134.85,100.38 134.85,99.28 ; 167.04,64.49 168.58,64.49 168.83,64.73 176.68,64.73 177.23,64.18 179.62,64.18 180.43,63.37 180.43,62.24 180.93,61.74 180.93,61.35 181.76,60.52 186.63,60.52 187.19,59.96 191.9,59.96 191.95,59.91 192.73,59.91 193.06,59.58 197.46,59.58 198.87,60.99 199.9,60.99
  IN3 w0.127: 134.85,99.28 134.85,98.72 132.99,96.85 132.99,93.57 131.64,92.22 131.64,91.18 134.4,88.42 134.4,88.25 139.49,83.15 139.49,72.93 147.94,64.49 167.04,64.49 ; 199.9,60.99 203.51,60.99 208.53,66.01 208.53,66.14 v2(208.51,66.15)
  BOTTOM w0.102: v2(208.51,66.15) 208.51,67.71 209.87,69.07 209.87,69.64 214.06,73.83 214.06,76.41 212.39,78.08 212.39,78.64 v1(209.23,81.8) 209.23,82.29 v2(208.7,82.83)
GC6_THM_ON: length 78.5
  TOP w0.102: RH342.1 v2(108.81,110.64)
  IN2 w0.089: 141.76,106.26 135.93,106.26 134.09,108.1 129.2,108.1 127.93,109.37 125.9,109.37 125.45,108.92 122.66,108.92 121.9,108.16 121.45,108.16 121.14,108.48 121.14,108.73 119.49,110.38 113.58,110.38 112.75,111.21 112.37,111.21
  IN2 w0.127: v2(172.27,105.61) 171.62,106.26 170.29,106.26 169.78,105.75 168.44,105.75 168.02,106.17 166.44,106.17 164.76,107.84 164.76,108.22 163.36,109.62 157.52,109.62 154.66,106.76 146.16,106.76 145.65,106.26 141.76,106.26 ; 112.37,111.21 109.38,111.21 v2(108.81,110.64)
  BOTTOM w0.102: v2(172.27,105.61) 173.78,104.1 174.08,104.1 175.08,103.1 175.08,102.94 v1(175.32,102.71) 175.55,102.94 U46.A48
GPIO_PSID_SELECT: length 258.9
  TOP w0.102: v2(24.29,21.43) 24.12,21.6 23.49,21.6 v1(23.26,21.82) 22.08,23.01 20.38,23.01 18.37,21 18.24,21 15.56,18.32 15.07,18.32 14.77,18.63 PU1.6
  IN2 w0.127: v2(178.46,116.97) 178.46,116.96 178.06,116.57 176.53,116.57 175.73,117.37 175.38,117.37 175.13,117.13 175.13,116.78 175.32,116.6 175.32,115.99 173.27,113.95 171.16,113.95 170.64,113.43 170.64,110.88 168.3,108.54 166.92,108.54 166.73,108.35 v2(166.73,107.72) ; v2(162.69,98.55) 162.5,98.55 161.52,99.52 159.55,99.52 158.87,98.84 157.6,98.84 154.16,95.4 148.96,95.4 148.05,94.49 136.5,94.49 136.09,94.08 134.61,94.08 133.13,92.6 113.74,92.6 113.08,91.94 113.08,91.51 112.39,90.83 109.53,90.83 107.76,89.05 104.35,89.05 104.16,89.24 101.78,89.24 101.57,89.24 101.57,89.24 101.37,89.24 88.33,76.2 88.33,63.8 77.07,52.53 73.14,52.53 72.39,51.79 69.7,51.79 65.89,47.98 61.08,47.98 60.49,47.38 56.81,47.38 55.17,45.74 54.63,45.74 54.46,45.91 52.07,45.91 51.26,46.72 41.84,46.72 40.85,47.71 34.95,47.71 31.63,44.4 31.63,38.98 38.41,32.2 38.41,31.85 38,31.44 36.86,31.44 36.25,30.83 36.25,25.75 35.36,24.86 35.36,23.49 37.14,21.71 37.8,21.71 38.69,20.82 38.69,18.99 38.16,18.46 26.12,18.46 24.29,20.29 v2(24.29,21.43)
  BOTTOM w0.102: v2(162.69,98.55) 161.98,99.26 161.98,102.74 162.65,103.4 163.75,103.4 164.48,104.13 164.48,104.14 164.72,104.38 164.72,104.38 165.3,104.96 165.3,106.29 v2(166.73,107.72) ; v2(178.46,116.97) 178.05,116.57 U46.A6
GPIOL0: length 4.6
  TOP w0.102: R3741.1 174.27,110.89 175.7,110.89 v1(175.86,110.73) 176,110.59 176,110.14 v2(176.01,110.14)
  BOTTOM w0.102: v2(176.01,110.14) 176,110.14 176,110.13 175.37,110.76 U46.B60
GPP_A14: length 8.3
  TOP w0.089: v2(126.18,122.36) 126.37,122.55 UH1.BC18
  BOTTOM w0.089: 125.94,126.2 126.02,126.13 126.02,124.53 126.18,124.37 v1(126.18,123.31) v2(126.18,122.36)
  BOTTOM w0.102: RH95.1 125.84,129.07 125.84,126.3 125.94,126.2
GPP_B23: length 19.5
  TOP w0.089: UH1.AT27 122.39,119.75 v2(122.83,120.19)
  TOP w0.102: RH347.1 RH353.2 113.44,129.16 113.35,129.08 QH5.3 113.35,127.41 v2(114.13,126.64)
  IN4 w0.089: v2(122.83,120.19) 122.71,120.19 122.36,120.54 122.36,121.66 121.95,122.07 121.06,122.07 120.71,122.42 120.17,122.42 119.16,123.44 118.55,123.44 118.22,123.77 118.22,124.2 117.39,125.03 116.04,125.03 115.45,125.62 115.4,125.62
  IN4 w0.109: 115.4,125.62 114.2,125.62 114.02,125.8 114.02,126.54 v2(114.13,126.64)
GPP_B23_Q: length 3.8
  TOP w0.102: QH5.1 112.7,130.65 112.53,130.83 RH353.1 RH329.1 111.64,130.47 111.28,130.12 v1(110.77,130.12)
GPP_C5: length 12.2
  TOP w0.089: UH1.BA40 v2(115.78,121.46)
  BOTTOM w0.089: v2(115.78,121.46) 115.46,121.78 114.86,121.78 114.62,121.54 114.62,121.26 114.24,120.89 114.06,120.89 113.67,121.28 112.37,121.28
  BOTTOM w0.102: 112.37,121.28 111.08,121.28 110.72,121.64 110.3,121.64 108.62,123.32 v1(108.45,123.32) 107.87,123.32 107.58,123.61 106.82,123.61 106.35,124.07 RH78.2
GPP_C8: length 2.6
  TOP w0.089: UH1.BA41 v2(115.07,121.37)
  BOTTOM w0.089: RH207.2 114.33,120.11 114.1,120.34 114.1,120.55 114.26,120.71 114.32,120.71 114.98,121.37 v2(115.07,121.37)
GPP_D14: length 8.4
  TOP w0.089: UH1.AK44 113.57,116.6 113.23,116.26 112.37,116.26
  TOP w0.102: RC76.1 108.61,116.69 v1(108.75,116.54) 109.38,116.54 109.66,116.26 112.37,116.26
GPP_D16: length 9
  TOP w0.089: 112.37,116.03 113.27,116.03 113.51,116.27 113.82,116.27 114.11,115.99 UH1.AJ43
  TOP w0.102: RC75.1 106.08,116.26 v1(106.66,116.26) 106.76,116.16 109.44,116.16 109.57,116.03 112.37,116.03
