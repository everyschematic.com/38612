# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WWAN_PWR_EN: length 4.7
  TOP w0.102: RZ3.2 322.22,25.64 v1(322.36,25.78) 322.47,25.89 322.47,26.21 v2(322.66,26.4)
  BOTTOM w0.102: JNGFF2.6 321.8,24.68 322.16,25.04 322.16,25.91 v2(322.66,26.4)
WWAN_RADIO_DIS#: length 201.2
  TOP w0.102: v2(319.7,33.81) 319.82,33.69 319.82,29.96 319.33,29.47 319.33,27.54 319.08,27.29 v1(319.08,26.54) 319.79,26.54 DZ1.1
  IN2 w0.127: v2(319.7,33.81) 319.38,33.5 319.38,32.92 318.73,32.27 315.43,32.27 314.75,32.95 312.48,32.95 311.66,32.14 309.24,32.14 308.25,33.13 303.25,33.13 301.45,31.33 298.07,31.33 294.7,34.69 294.7,35.35 291.53,38.51 289.64,38.51 289.39,38.76 289.39,39.62 288.23,40.79 282.73,40.79 278.99,44.52 276.4,44.52 257.56,63.36 257.56,65.09 255.57,67.08 255.57,69.12 249.36,75.33 246.72,75.33 243.91,78.14 243.91,78.89 240.12,82.67 227.22,82.67 225.66,84.23 222.51,84.23 221.2,85.54 221.2,85.81 216.2,90.82 216.2,93.09 209.3,99.98 209.3,100 208.54,100.77 207.93,100.77 207.3,100.15 204.07,100.15 204.04,100.17 203.04,100.17 202.07,101.14 201.59,101.14 201.4,101.33 201.21,101.33 201,101.33 200.6,101.72 200.6,102.23 200.42,102.41 198.87,102.41 198.82,102.46 197.35,102.46 196.79,101.9 195.07,101.9 194.82,102.14 194.82,102.99 193.38,104.43 192.25,104.43 192.01,104.68 192.01,104.78 189.53,107.26 186.37,107.26 185.66,107.96 185.34,107.96 183.58,109.72 175.92,109.72 175.89,109.7 174.3,109.7 173.25,108.64 v2(172.18,108.64)
  BOTTOM w0.102: U46.A53 172.55,109.01 v2(172.18,108.64) 171.59,108.64 RE14.2
WWAN_RADIO_DIS#_R: length 4.2
  TOP w0.102: v2(322.51,27.12) 322.21,26.82 DZ1.2
  BOTTOM w0.102: JNGFF2.8 321.68,25.18 321.91,25.4 321.91,26.52 v2(322.51,27.12)
WWAN_WAKE#: length 197.6
  TOP w0.102: v2(179.92,107.48) 180.2,107.48 180.34,107.34 v1(180.34,107.18) R773.2
  IN2 w0.127: v2(179.92,107.48) 180,107.48 180.55,108.03 181.95,108.03 182.29,108.38 182.85,108.38 182.85,108.38 183.57,108.38 185.14,106.8 185.75,106.8 186.25,106.29 188.12,106.29 189.57,104.85 190.76,104.85 191.94,103.67 193.06,103.67 194.03,102.71 194.03,101.86 194.84,101.05 196.55,101.05 196.69,100.91 200.33,100.91 200.87,100.38 201.75,100.38 202.72,99.41 203.73,99.41 203.76,99.37 206.65,99.37 208.6,97.43 209.53,97.43 211.6,95.36 211.6,92.57 212.52,91.65 213.07,91.65 215.26,89.46 215.26,88.3 216.36,87.21 217.7,87.21 220.37,84.54 221.13,84.54 222.89,82.77 223.25,82.77 224.14,81.89 239.55,81.89 240.53,80.91 240.53,80.3 241.13,79.7 241.74,79.7 242.2,79.24 242.2,78.59 243.74,77.05 243.74,76.34 244.72,75.35 245.62,75.35 246.4,74.57 249.04,74.57 250.72,72.9 254.8,68.81 254.8,66.77 255.58,65.99 256.79,64.78 256.79,63.05 276.08,43.76 278.67,43.76 282.41,40.02 282.89,40.02 282.89,40.03 285.78,40.03 288.93,36.88 290.83,36.88 292.74,34.97 292.74,33.86 293.94,32.66 294.83,32.66 297.66,29.83 301.03,29.83 303.57,32.37 307.93,32.37 309.12,31.17 316.81,31.17 317.18,31.54 318.96,31.54 v2(319.19,31.77)
  BOTTOM w0.102: v2(179.92,107.48) 179.85,107.48 179.4,107.03 179.4,106.55 179.3,106.45 U46.B43 ; JNGFF2.15 324.14,28.93 322.98,27.77 319.64,27.77 319.39,28.03 319.39,31.58 v2(319.19,31.77)
XCLK_RBIAS: length 4.1
  TOP w0.089: RH171.2 137.82,102.51 137.53,102.51 135.72,104.32 134.99,104.32 UH1.E1
XDP_DBRESET#: length 154.9
  TOP w0.102: v2(163.1,74.18) 163.05,74.18 162.58,73.71 162.58,72.78 158.28,68.48 158.28,66.3 157.72,65.74 156.57,65.74 147.96,57.14 147.96,34.1 RC316.1 162.68,17.87 161.92,17.11 CC35.1 160.99,17.11 v1(160.62,16.74) 160.44,16.57 160.44,15.61 160.65,15.41 160.84,15.41 160.99,15.26 160.99,12.8 159.82,11.63 156.19,11.63 155.86,11.31 JXDP1.48 ; UC3.1 144.19,125.24 144,125.05 142.72,125.05 142.3,124.64 RH66.1 141.36,124.64 139.74,123.02 v2(139.26,123.02)
  IN3 w0.089: 141.76,104.52 140.97,105.31 140.97,106.11 139.01,108.07 139.01,111.8 140.96,113.76 140.96,115.8 141.18,116.02 141.18,117.77 139.81,119.15 139.81,121.94 139.26,122.49 139.26,123.02 v2(139.26,123.02)
  IN3 w0.127: v2(163.1,74.18) 162.71,74.18 161.49,75.39 156.97,75.39 151.52,80.85 150.65,80.85 143.23,88.26 143.23,88.74 142.26,89.71 142.26,96.81 144,98.55 144,102.28 141.76,104.52
XDP_OBS0: length 39.4
  TOP w0.089: v2(189.95,22.04) 190.49,22.58 190.49,23.89 190.42,23.96 190.42,24.42 CPU1.BR27
  TOP w0.102: v2(185.21,7.24) 186.03,6.42 186.03,5.46 184.82,4.25 177.23,4.25 176.5,4.97 171.45,4.97 v1(171.13,5.29) 170.76,5.67 RC312.1
  IN4 w0.089: 187.94,17.89 189.27,19.23 189.27,21.37 v2(189.95,22.04)
  IN4 w0.109: v2(185.21,7.24) 185.21,7.3 185.74,7.82 185.8,7.82 186.89,8.91 186.89,16.85 187.94,17.89
XDP_OBS0_R: length 23.2
  TOP w0.102: JXDP1.21 149.36,6.33 v2(149.39,6.36) ; RC312.2 165.95,5.67 v1(165.59,6.03) 164.74,6.88 160.1,6.88 v2(159.86,6.64)
  IN3 w0.127: v2(159.86,6.64) 159.52,6.64 158.97,7.2 157.42,7.2 156.43,8.19 153.1,8.19 152.37,7.45 150.41,7.45 150.36,7.4 150.35,7.4 150.1,7.15 150.1,7.07 v2(149.39,6.36)
XDP_OBS1: length 38.7
  TOP w0.089: CPU1.BT27 190.68,24.03 190.68,21.5 190.46,21.28
  TOP w0.102: 190.46,21.28 v2(189.95,20.77) ; RC313.1 170.43,4.78 171.31,3.89 v1(172.78,3.89) 184.96,3.89 186.49,5.42 186.49,6.54 185.91,7.12 v2(185.91,7.41)
  IN4 w0.089: v2(189.95,20.77) 189.95,19.55 189.11,18.72 189.1,18.72 188.27,17.89
  IN4 w0.109: v2(185.91,7.41) 187.18,8.68 187.18,16.8 188.27,17.89
XDP_OBS1_R: length 26.7
  TOP w0.102: v2(160.79,6.35) 162.35,4.78 v1(163.99,4.78) RC313.2 ; v2(149.39,6.96) 149.4,6.95 149.49,6.95 149.86,6.57 JXDP1.23
  IN3 w0.127: v2(149.39,6.96) 148.92,7.42 148.92,9.06 149.11,9.25 157.73,9.25 159.63,7.35 159.78,7.35 v2(160.79,6.35)
XDP_PRSNT_PIN1: length 12.7
  TOP w0.102: JXDP1.1 144.36,5.63 143.02,6.97 143.02,12.19 144.28,13.45 v1(144.55,13.45) 144.88,13.79 RC121.1 RC122.1
XTAL24_IN_R: length 10.1
  TOP w0.089: CH13.1 140.28,99.58 YH2.3 ; UH1.A6 132.76,101.99 132.76,101.9 134.31,100.35 136.25,100.35 137.15,99.45 137.15,99.28
  TOP w0.102: CH13.1 138.52,99.12 138.52,98.97 138.22,98.67 RH153.2 137.64,99.12 v1(137.2,99.12) 137.15,99.17 137.15,99.28
XTAL24_OUT_R: length 5.2
  TOP w0.089: 141.76,100.42 CH14.1 138.08,101.31 RH152.2
  TOP w0.102: 141.76,100.42 141.78,100.42 YH2.1
XTAL24_OUT_R1: length 7.3
  TOP w0.089: UH1.A5 132.96,101.94 134.36,100.54 136.44,100.54 137.4,99.58 137.75,99.58
  TOP w0.102: RH152.1 138.09,100.4 RH153.1 137.75,99.58
XTALI: length 7.6
  TOP w0.102: U31.10 249.73,113.38 249.07,114.04 249.07,114.51 249.8,115.24 249.8,115.73 v1(250.19,116.12) 250.88,116.81 250.96,116.81 C471.1 251.38,117.25 251.38,118.5 Y3.1
XTALO: length 2.7
  TOP w0.102: R1144.2 250.42,114.99 v1(249.7,114.27) 250.13,113.84 U31.9
XTALO_R: length 6.5
  TOP w0.102: Y3.3 251.99,119.78 251.99,117.71 252.25,117.44 C470.1 252.25,116.66 v1(251.92,116.32) 251.91,116.32 251.34,115.75 R1144.1
Z2805: length 3.4
  TOP w0.102: v1(240.39,138.45) 241.33,138.45 R574.1
  TOP w0.508: T156.22 241.3,137.56 241.34,137.6 R574.1
Z2806: length 3.7
  TOP w0.102: R573.1 248.51,138.83 v1(247.76,138.83)
  TOP w0.508: R573.1 248.92,138.41 T156.16
Z2807: length 3.5
  TOP w0.102: R572.1 243.1,138.44 v1(243.49,138.83)
  TOP w0.508: T156.21 242.57,138.41 R572.1
Z2808: length 3.6
  TOP w0.102: v1(251.25,138.64) 251.05,138.44 R571.1
  TOP w0.508: T156.15 250.19,138.41 R571.1
Z4012: length 3.8
  BOTTOM w0.254: PD1.2 45.2,28.03 45.78,27.45 v1(46.18,27.45) 47.07,27.45 PR1.2
Z4304: length 9.6
  TOP w0.102: PBATT1.7 258.53,4.22 255.24,4.22 253.59,5.88 PR3.4
Z4305: length 8
  TOP w0.102: PBATT1.6 257.11,3.64 255.5,3.64 253.09,6.06 PR3.3
Z4306: length 6.4
  TOP w0.102: PBATT1.5 252.59,6.16 PR3.2
N265433: length 3.2
  TOP w0.102: PQ8.1 14.95,26.3 15.2,26.55 v1(15.42,26.55) 15.68,26.55 15.9,26.33 PQ8.2
N16717680: length 36.9
  TOP w0.508: PQ8.4 16.85,23.14 17.2,23.49 v2(18.24,23.49)
  IN1 w0.508: v2(18.24,23.49) 18.24,26.79 19.59,28.14 20.98,28.14 23.14,30.3 23.14,34.79 24.24,35.88 30.38,35.88 35.03,40.53 35.03,41.83 v2(38.72,45.52)
N16751240: length 420.8
  TOP w0.254: v2(335.39,47.53) 335.11,47.8 PR700.2 ; v2(37.52,39.16) 37.12,38.76 35.92,38.76 35.54,38.37 35.54,36.53 35.16,36.15 33.76,36.15 33.41,36.51 PR766.2
  IN2 w0.127: v2(335.39,47.53) 335.69,47.22 335.69,45.93 336.7,44.92 336.7,30.93 337.01,30.62 337.01,25.71 335.71,24.4 332.58,24.4 330.66,26.32 328.88,26.32 327.58,25.01 318.74,25.01 318.41,24.69 316.23,24.69 313.66,22.11 309.63,22.11 307.36,24.38 303.04,24.38 302.33,23.67 292.52,23.67 287.98,28.21 280.31,28.21 278.15,30.38 278.15,32.06 278.34,32.25 278.34,36.55 276.72,38.17 276.72,39.04 275.73,40.03 272.81,40.03 268.86,43.98 268.86,45.76 258.04,56.58 251.07,56.58 247.44,60.22 247.44,67.72 243.97,71.19 240.78,71.19 237.5,74.47 236.53,74.47 233.69,77.3 220.08,77.3 219.94,77.44 215.34,77.44 211.35,73.45 209.91,73.45 209.25,74.1 209.25,77.64 203.41,83.48 185.24,83.48 182.99,81.24 176.57,81.24 175.81,80.47 155.43,80.47 153.74,78.79 153.57,78.79 150.24,75.46 142.13,75.46 137,80.59 120.42,80.59 118.49,78.66 111.54,78.66 110.12,77.24 106.11,77.24 104.65,75.78 101.05,75.78 99.84,74.57 99.84,74.13 97.21,71.5 97.21,60.13 70.58,33.5 66.16,33.5 65.32,32.66 53.86,32.66 51.01,35.52 51.01,41.89 48.7,44.2 38.44,44.2 37.52,43.28 v2(37.52,39.16)
  BOTTOM w0.254: PQ701.4 38.15,39.17 38.02,39.3 37.66,39.3 v2(37.52,39.16)
N16759370: length 10.3
  BOTTOM w0.102: v1(34.65,26.16) 34.89,26.4 PR709.2
  BOTTOM w0.254: PR709.2 34.89,27.66 34.59,27.96 33.38,27.96 33.11,27.69 PR712.2 PR714.2 32.25,27.87 32.62,28.24 32.62,28.91 32.96,29.26 PQ706.2 33.63,30.45 34.33,30.45 PQ703.2
N16952683: length 10.3
  BOTTOM w0.102: v1(202.8,97.56) 202.99,97.75 R399.1 201.92,98.75 201.4,99.27 199.81,99.27 199.24,99.84 197.56,99.84 Q370.3 197.41,98.89 197.78,98.89 198.3,98.37 R435.2
N16952696: length 2.9
  BOTTOM w0.102: R399.2 202.43,99.66 v1(202.09,99.33) 201.53,99.88 Q28.2
N17075286: length 2.6
  BOTTOM w0.102: Q343.1 167.6,138.97 168.25,138.32 v1(168.25,138.25) 168.25,137.12 R129.1
N17075290: length 3.9
  BOTTOM w0.102: R132.1 168.19,136.17 v2(166.51,136.17) 166.18,136.17 165.34,137.01 Q343.4
N17075402: length 5
  TOP w0.102: v1(8.71,23.8) 10,22.51 PQ2.3 10.59,21.63 10.71,21.52 PR9.1 PR7.2
N17205976: length 9.8
  BOTTOM w0.102: R864.2 187.91,93.33 v1(187.05,94.19) 186.73,94.51 186.73,96.35 185.65,97.43 185.65,100.29 184.66,101.28 JDEG2.1
N17319754: length 6.2
  TOP w0.102: PQ1003.4 254.91,13.48 PC1004.1 253.63,13.09 251.94,13.09 v1(251.64,13.39) 251.64,14.14 PR1004.1
N17649391: length 9.8
  TOP w0.102: PBATT1.3 251.62,3.13 251.62,8.21 250.86,8.96 v1(250.86,9.27) 250.86,10.15 251.26,10.54 PD3.3
N17684555:
  vias: v1(285.6,3.7)
N17708032: length 4
  TOP w0.102: v1(248.51,14.66) 248.3,14.46 248.3,13.3 PR33.2
  TOP w0.254: PR33.2 PC5.1 247.18,13.04 247.18,12.77 247.4,12.56 PQ1.2
N17708061: length 6.1
  TOP w0.102: PD5.2 v1(244.67,7.89)
  TOP w0.254: PQ1.1 249.48,10.6 246.77,7.89 PD5.2
N17794318: length 236.1
  IN2 w0.127: v2(189.91,81.43) 191.44,82.96 193.26,82.96 193.28,82.98 203.18,82.98 208.75,77.42 208.75,73.89 209.7,72.94 211.56,72.94 214.53,75.91 219.41,75.91 220.04,76.54 232.84,76.54 236.21,73.17 238.95,70.43 243.65,70.43 246.47,67.6 246.47,60.1 250.76,55.82 255.09,55.82 260.96,49.96 263.58,49.96 268.1,45.44 268.1,42.15 v2(267.69,41.74)
  IN3 w0.127: v2(174.6,102.84) 174.6,102.3 174.12,101.82 174.12,100.51 173.71,100.1 173.71,99.42 174.73,98.4 174.73,94.13 174.92,93.94 174.92,90.83 176.37,89.38 176.89,88.86 176.89,85.83 176.71,85.66 176.71,84.78 177.86,83.63 183.46,83.63 183.97,83.12 188.21,83.12 v2(189.91,81.43)
  BOTTOM w0.102: v2(174.6,102.84) 174.56,102.84 172.9,104.49 169.65,104.49 169.46,104.68 169.46,104.99 169.78,105.3 169.78,107.28 168.81,108.25 168.81,109.38 167.17,111.02 167.17,116.86 168.23,117.91 168.23,119.28 168.8,119.85 168.8,120.87 168.24,121.43 168.24,122.52 168.98,123.26 168.98,125.66 168.57,126.07 167.43,126.07 166.67,126.83 166.67,128.35 165.11,129.91 162.57,129.91 158.22,134.26 158.22,136.23 158.45,136.46 159.85,136.46 160.51,137.12 160.51,141.43 158.13,143.81 142.15,143.81 141.64,143.3 129.42,143.3 129.06,143.65 127.57,143.65 v1(127.54,143.68) 127.23,143.38 PQ1001.4 127.17,142.2 125.67,142.2 PC1001.2 125.3,143.23 PR1002.2 ; v2(267.69,41.74) 268.44,41.74 PR1033.2
N18381813: length 3.7
  BOTTOM w0.102: Q347.6 171,135.15 170.92,135.22 v2(170.53,135.22) 170.35,135.04 Q347.5 169.78,134.01 R722.2
N19516037: length 2.7
  BOTTOM w0.102: RZ35.1 189.42,133.89 188.97,134.34 188.97,134.88 v1(189.05,134.96) 189.05,134.97 189.46,134.97 189.64,134.79 CZ9.1
N19876513: length 4.6
  BOTTOM w0.102: PR713.1 32.31,33.93 v1(32.12,34.12)
  BOTTOM w0.254: PR713.1 PR715.2 33.56,32.71 32.71,31.86 PQ706.1
N19877490: length 10.1
  BOTTOM w0.254: PR701.3 46.47,40.15 46.18,39.86 46.18,38.99 45.43,38.24 45.43,37.26 v1(44.75,36.58) 44.46,36.29 43.24,36.29 42.59,35.64 42.59,35.2 43.07,34.72 PQ702.1
N19877495: length 10.2
  BOTTOM w0.254: PQ700.1 41.71,34.72 42.2,35.2 42.2,35.84 v1(42.56,36.2) 43.03,36.68 44.24,36.68 45.03,37.48 45.03,38.38 45.79,39.14 45.79,40 45.64,40.15 PR701.2
N20195902: length 15.3
  TOP w0.254: PR1014.2 332.45,59.58 v2(332,60.03) ; PD1010.2 342.36,54.32 v2(342.23,54.19)
  BOTTOM w0.102: v2(342.23,54.19) 342.35,54.31 342.35,55.25 v1(339.23,58.38) 338.57,59.04 332.99,59.04 v2(332,60.03)
N20196027: length 7
  TOP w0.102: v3(338.94,61.76) PQ1011.2
  TOP w0.254: PR1032.1 341.86,56.81 PR1030.1 341.39,58.08 PD1100.2 341.39,60.58 PQ1011.2
N20202315: length 8.5
  TOP w0.254: PQ1011.1 342.75,60.47 342.75,59.2 v3(343.68,58.27) 344.3,57.65 PR1099.2 346.94,57.29 PQ1072.2
N20202318: length 7.1
  TOP w0.102: PQ1072.1 345.16,53.05 v1(344.46,53.05)
  TOP w0.254: PR1032.2 342.68,56.09 PD1010.3 343.84,54.94 345.69,54.94 345.97,54.65 PQ1072.1
N20354491: length 4.9
  TOP w0.254: PR400.2 v1(14.1,59.33) 14.1,58.47 14.53,58.03 14.53,56.97 15.27,56.23 PU400.2
N20966390: length 6.6
  TOP w0.102: PL3.1 14.32,20.93 14.29,20.96 PR10.2 13.32,20.96 13.29,20.93 PR7.1 12.55,21.46 12.78,21.69 13.32,21.69 v1(13.56,21.93) 13.75,22.12 13.75,23.03 13.3,23.47 PQ2.1
N20966408: length 9.8
  TOP w0.102: PR12.2 13.79,20.02 PR10.1 v2(12.78,20.04) ; v2(12.3,24.66) 13.04,25.4 v1(13.04,26.13) PQ3.2
  IN4 w0.109: v2(12.78,20.04) 12.3,20.52 v2(12.3,24.66)
N20966410: length 5.5
  TOP w0.102: PQ2.2 10.59,25.97 PR11.2 10.06,26.5 v1(9.63,26.5) 9.63,26.84 9.86,27.07 PR13.1 9.86,27.86 10.01,28.01 PQ3.1
N21631508: length 116.7
  TOP w0.254: v2(337.14,60.32) 336.45,59.63 PR1009.1 ; v2(283.13,16.66) 283.13,16.47 283.89,15.7 PQ1004.4
  IN1 w0.254: v2(283.13,16.66) 284.33,17.86 297.64,17.86 299.99,15.51 310.48,15.51 315.18,10.82 327.96,10.82 332.35,15.2 332.35,19.34 333.69,20.68 333.69,23.04 331.57,25.17 331.57,26.14 330.94,26.77 329.4,26.77 327.89,28.28 326.69,28.28 325.06,29.9 325.06,32.5 325.16,32.6 325.16,36.94 326.21,38 326.21,39.16 325.33,40.05 325.33,41.65 326.7,43.02 326.7,44.83 327.94,46.07 328.33,46.07 329.29,47.02 329.29,48.46 330.41,49.58 330.41,57.36 332.32,59.26 336.13,59.26 337.14,60.27 v2(337.14,60.32)
N22506578: length 3.3
  TOP w0.102: v1(328.48,57.17) 329.08,56.57 PR1008.2
  TOP w0.254: PR1008.2 329.35,55.69 PU1001.28
N22982928: length 5.7
  TOP w0.102: R944.2 224.17,107.77 224.74,108.35 224.74,109.54 224.99,109.79 v1(225.58,109.79) 225.88,109.79 Q87.1
N23873950: length 1.9
  TOP w0.102: R1970.2 209,89.44 JMXM1.55
N26820574: length 6
  TOP w0.508: PD701.1 282.28,39.5 v1(282.28,40.39) 282.28,41.87 PR717.1 282.82,42.41 PD702.1
N26820768: length 3.9
  TOP w0.203: 272.28,35.33 PU700.6
  TOP w0.254: PC711.1 PR718.1 272.58,37.09 272.6,37.07 PR719.1 272.6,35.76 v1(272.58,35.75) 272.28,35.44 272.28,35.33
N26821061: length 6.6
  TOP w0.102: v1(276.77,39.14) 276.67,39.04 276.67,37.46 275.79,36.58 PR706.2
  TOP w0.203: PR706.2 275.62,36.58 275.08,36.03 273.96,36.03 273.47,35.55 PU700.3
N26821286: length 2.3
  TOP w0.203: 272.68,35.12 PU700.5
  TOP w0.254: PR721.2 273.03,35.75 273.03,35.55 272.68,35.2 272.68,35.12
N26821586: length 4.1
  TOP w0.203: PU700.7 271.87,35.13
  TOP w0.254: 271.87,35.13 271.11,35.9 271.11,36.04 270.81,36.34 v1(270.81,36.53) PC721.2 PR716.2
N26821595: length 4.8
  TOP w0.102: PC720.2 269.4,36.61 v1(268.77,37.23)
  TOP w0.203: PU700.8 270.62,33.86 270.45,34.03
  TOP w0.254: PC720.2 269.4,35.21 PR726.2 269.79,35.2 270.45,34.54 270.45,34.03
N26821696: length 1.8
  TOP w0.203: PR725.2 269.47,33.42 269.83,33.06 PU700.10
N26821932: length 2
  TOP w0.203: PU700.15 271.87,30.37 270.92,29.42 PR728.2
N26822164: length 3.5
  TOP w0.203: 274.34,29.02 274.13,29.02 273.87,29.27 PU700.20
  TOP w0.254: 274.34,29.02 274.9,29.02 v1(274.98,28.94) 275.12,28.79 PR761.2
N26822183: length 2.9
  TOP w0.203: 273.47,28.97 v1(273.47,29.56) PU700.19
  TOP w0.254: PR762.2 274.17,28.28 273.47,28.97
N26822390:
  vias: v1(276.2,32.47)
N26822393:
  vias: v1(278.69,35.2)
N26949736: length 1.7
  TOP w0.203: PR727.2 270.01,32.53 270.14,32.66 PU700.11
N26949739: length 1.9
  TOP w0.203: PR729.2 269.71,31.64 270.33,32.26 PU700.12
N26975143: length 135.4
  TOP w0.254: PQ1002.4 261.14,12.34 v2(260.76,11.96) ; PR1006.1 v2(327.56,54.44)
  IN1 w0.254: v2(325.91,5.29) 317,5.29 315.76,6.54 293.09,6.54 292.7,6.14 289.02,6.14 288.08,7.09 288.08,11.71 285.47,14.32 282.11,14.32 281.6,14.82 272.08,14.82 271.88,14.63 263.42,14.63 v2(260.76,11.96)
  IN4 w0.254: v2(327.56,54.44) 327.94,54.44 331.28,51.1 331.28,47.76 332.35,46.69 332.35,44.51 333.29,43.57 333.29,40.66 332.21,39.58 332.21,39.14 332.91,38.44 332.91,37.77 332.18,37.04 331.83,37.04 331.36,36.57 331.36,34.97 331.79,34.54 331.79,29.57 332.47,28.89 334.21,28.89 335.54,27.56 335.54,26.44 334.99,25.89 334.99,23.53 334.27,22.81 334.27,18.1 331.11,14.94 331.11,13.36 325.91,8.15 v2(325.91,5.29)
N27069121:
  vias: v1(103.48,122.63)
N27069164:
  vias: v1(92.33,117.95)
N27069205: length 2.5
  TOP w0.254: PU800.1 101.84,128.55 102.24,128.95 v1(102.24,129.57) PR800.1
N27121902: length 6.4
  TOP w0.102: v2(151.33,142.67) 151.36,142.7 R3722.1
  BOTTOM w0.102: v2(151.33,142.67) 151.69,142.67 152.61,141.75 v1(152.61,141.37) 151.62,140.38 151.62,139.54 151.33,139.26 151.33,139.24 151.21,139.12 U630.48
N27182711: length 2
  TOP w0.102: PR1137.2 257.12,35.16 v1(256.8,34.84)
  TOP w0.254: PC1119.1 257.14,35.85 PR1137.2
N27207381: length 2.1
  BOTTOM w0.102: 238.46,70.94 239.11,70.94 239.51,71.34 v1(239.51,72.17)
N27207408: length 1.5
  BOTTOM w0.102: PC1703.1 236.63,72.17 v1(236.41,72.38)
N27207822: length 1.2
  BOTTOM w0.102: 230.93,70.54 229.92,70.54 v1(229.8,70.66)
N27208984:
  vias: v2(228.83,74.67)
N27208988:
  vias: v1(229.2,80)
N27209291: length 1.8
  TOP w0.508: v2(230.59,68.55) 230.19,68.16 v1(229.65,68.16) v2(228.94,68.16)
N27222324:
  vias: v2(232.5,46.2)
N27222328:
  vias: v1(233.99,46.93)
N27222382:
  vias: v1(236.5,35.68)
N27222513: length 1.4
  BOTTOM w0.102: PR1208.1 v1(244.31,38.01)
N27222533: length 1.3
  BOTTOM w0.102: PC1250.1 v1(242.91,41.89)
N27222541: length 3
  BOTTOM w0.102: v1(242.7,38.09) 242.91,38.31 PR1208.2
  BOTTOM w0.203: PR1208.2 242.42,39.92 PU1202.30
N27223948: length 6.6
  BOTTOM w0.102: v1(229.12,47.72) PR1210.1
  BOTTOM w0.254: PR1210.1 229.12,42.87 228.82,42.57 PL1202.3
N27229436:
  vias: v2(235.75,62.82)
N27229440:
  vias: v2(236.44,65.92)
N27229500: length 2.9
  TOP w0.508: v2(235.23,58.38) 235.55,58.69 v1(236.87,58.69) v2(237.96,58.69)
N27229588: length 1.4
  BOTTOM w0.102: PC1210.2 v1(244.39,62.58)
N27229600: length 1.3
  BOTTOM w0.102: PC1210.1 v1(242.99,62.58)
N27229608: length 1.3
  BOTTOM w0.102: PR1201.2 v1(242.99,58.74)
N27229674: length 7.9
  BOTTOM w0.102: PR1204.1 229.12,67.44 229.29,67.61 230.81,67.61 v1(230.91,67.71)
  BOTTOM w0.254: PR1204.1 229.12,63.19 228.82,62.89 PL1200.3
N27236350:
  vias: v2(234.92,51.28)
N27236354: length 1.4
  BOTTOM w0.102: v1(233.94,57) 234.17,57.23 PC1215.2
N27236394: length 3.9
  TOP w0.508: v2(235.28,48.22) 235.47,48.41 v1(236.91,48.41) v2(237.98,48.41)
  BOTTOM w0.203: PU1201.6 238.47,48.55 238.33,48.41 v2(237.98,48.41)
N27236502: length 1.4
  BOTTOM w0.102: PC1208.2 v1(244.26,52.49)
N27236514: length 1.4
  BOTTOM w0.102: PC1208.1 v1(242.86,52.49)
N27236522: length 1.4
  BOTTOM w0.102: PR1202.2 v1(242.86,48.47)
N27236588: length 6.8
  BOTTOM w0.102: v1(229.12,58.16) PR1205.1
  BOTTOM w0.254: PR1205.1 229.12,53.03 228.82,52.73 PL1201.3
N27241431:
  vias: v2(227.37,35.45)
N27241435:
  vias: v1(228.12,28.87)
N27241475: length 2.9
  BOTTOM w0.508: v2(229.28,37.69) 229.38,37.59 v1(230.69,37.59) 231.02,37.92 v2(231.96,37.92)
N27241583: length 2.3
  TOP w0.102: v1(238.02,38.3) 238.37,37.95 PR1408.1
N27241603: length 1.5
  TOP w0.102: v1(236.78,37.55) 236.97,37.36 PR1408.2
N27241669: length 7.3
  TOP w0.102: PR1410.1 223.15,38.29 v1(223.84,38.98)
  TOP w0.254: PR1410.1 223.15,33.66 222.78,33.29 PL1402.3
N27245966:
  vias: v1(229.24,7.31)
N27246006: length 3.6
  TOP w0.102: v1(231.35,17.52) 231.7,17.17 v2(231.99,17.17)
  BOTTOM w0.508: v2(231.99,17.17) 229.53,17.17 v2(229.26,17.43)
N27246076: length 1.3
  TOP w0.102: PC1408.2 v1(238.42,13.28)
N27246118: length 1.5
  TOP w0.102: PC1408.1 v1(237.02,13.14)
N27246134: length 1.4
  TOP w0.102: PR1401.2 v1(237.02,17.22)
N27246196: length 6.5
  TOP w0.102: PR1404.1 223.11,18.04 v1(223.05,18.1)
  TOP w0.254: PR1404.1 223.15,17.18 223.15,13.34 222.78,12.97 PL1400.3
N27251330: length 2.1
  TOP w0.102: v1(225.86,18.73) 227.18,20.05 227.18,20.33
N27251334:
  vias: v1(228.06,18.77)
N27251374: length 4.5
  TOP w0.102: PC1409.1 227.61,27.91 v1(226.61,28.91)
  BOTTOM w0.508: v2(232.01,27.45) 229.45,27.45 v2(229.26,27.64)
N27251444: length 1.6
  TOP w0.102: v1(238.95,27.66) 238.39,27.09 PR1402.1
N27251486: length 1.3
  TOP w0.102: PC1410.1 v1(236.99,23.73)
N27251502: length 1.4
  TOP w0.102: PR1402.2 v1(236.99,27.67)
N27251564: length 6.5
  TOP w0.102: PR1405.1 223.12,27.42 v1(223.12,28.26)
  TOP w0.254: PL1401.3 222.78,23.13 223.15,23.5 PR1405.1
N28146073: length 2
  TOP w0.203: PR1607.1 258.82,31.35 PU1600.1
N28146077: length 1.7
  TOP w0.203: PR1608.2 258.42,31.84 PU1600.2
N28146081: length 1.7
  TOP w0.203: PU1600.3 258.02,31.95 PR1609.2
N28146103: length 2.2
  TOP w0.102: v1(264.95,24.02) 264.7,24.28 264.7,24.72 PR1605.1
  TOP w0.254: PR1605.1 264.29,25.13 263.62,25.13 PC1608.2
N28146139: length 1.5
  TOP w0.102: v1(263.22,33.17) 262.83,33.56 PR1603.1
N28146151: length 5.7
  TOP w0.102: v1(263.21,31.21) 262.84,31.58 261.38,31.58 PC1600.2
  TOP w0.203: PR1600.2 260.89,29.72 260.14,28.98 PU1600.38
  TOP w0.254: PC1600.2 PR1600.2
N28146153: length 5.9
  TOP w0.102: v1(265.09,28.79) 264.57,28.26 PR1601.1
  TOP w0.203: PU1600.37 260.41,28.58 260.52,28.47 261.26,28.47 PR1602.1
  TOP w0.254: PR1601.1 263.47,28.29 PC1603.1 262.59,28.3 PC1690.1 261.7,28.33 PR1602.1
N28146361: length 1.8
  TOP w0.254: PR1613.1 262.04,23.72 PH1601.2 261.78,23.47 PR1616.1
N28146405:
  vias: v1(253.22,34.01)
N28146444: length 1.8
  TOP w0.102: PC1613.1 255.22,31.26 PU1600.10
N28146467: length 1.9
  TOP w0.203: PR1611.2 257.62,31.46 PU1600.4
N28146568: length 2.5
  TOP w0.203: PU1600.31 259.82,26.18 259.9,26.11 PR1606.1
N28152233: length 7.2
  TOP w0.203: PU1100.38 258.95,41.45 259.36,41.04 259.36,40.41 259.87,39.9 261.09,39.9 261.58,39.4 v1(261.58,38.76) PR1126.1
  TOP w0.254: PR1126.1 260.72,37.63 PC1111.1
N28152235: length 4
  TOP w0.102: PR1128.1 259.79,36.42 v1(260.51,35.71)
  TOP w0.254: PR1128.1 PC1111.2 259.79,38.48 PC1112.2 PR1127.2
N28152339: length 4.2
  TOP w0.203: PU1100.37 258.55,41.35 258.91,40.98 v1(258.91,40.74) 258.91,40.17 259.19,39.9 259.28,39.9 259.77,39.4 PC1112.1
  TOP w0.254: PR1127.1 PC1112.1
N28152401: length 4.4
  TOP w0.203: v2(252.88,47.52) 253.07,47.52 253.42,47.17 PU1100.15
  TOP w0.254: PR1150.2 251.62,47.52 v2(252.88,47.52)
  BOTTOM w0.254: v2(252.88,47.52) v1(252.35,47.52) 251.62,47.52 PR1150.2
N28152437: length 3.4
  TOP w0.203: PU1100.3 258.55,48.94 v2(258.65,49.05)
  BOTTOM w0.102: v1(257.07,49.84) PR1132.2
  BOTTOM w0.254: v2(258.65,49.05) 258.53,48.93 PC1118.2 PR1132.2
N28152465: length 4.2
  TOP w0.203: v2(258.34,40.72) 258.15,40.92 PU1100.36
  BOTTOM w0.102: v1(259.66,41.47) PR1135.1
  BOTTOM w0.254: v2(258.34,40.72) 257.84,41.23 PC1120.1 PR1135.1
N28152580: length 4.6
  TOP w0.254: PC1140.1 PR1107.1 264.19,53.09 v1(264.19,53.09) 264.19,53.09 264.19,53.84 263.59,54.43 PC1103.2 262.45,54.43 PR1106.2
N28152729: length 4.2
  TOP w0.102: v1(261.55,52.5) 261.9,52.5 262.3,52.1 PC1105.1
  TOP w0.254: PC1105.1 PR1109.1 263.31,52.12 PC1103.1 262.45,53.52 PR1108.2
N28152784: length 5.9
  TOP w0.102: PR1151.2 251.29,45.44 v1(250.82,44.97)
  TOP w0.203: v2(252.44,47.01) 253.07,47.01 253.31,46.77 PU1100.16
  TOP w0.254: v2(252.44,47.01) 252.12,47.01 PR1151.2
  BOTTOM w0.254: v2(252.44,47.01) 252.12,47.01 PR1151.2
N28152844: length 34.3
  TOP w0.254: PH1104.1 236.01,17.8 v2(236.45,18.24)
  IN4 w0.254: v2(249.71,42.69) 243.56,36.55 243.56,30.48 235.88,22.8 235.88,18.82 v2(236.45,18.24)
  BOTTOM w0.102: v1(251.25,44.74) 251.24,44.73 PR1168.1
  BOTTOM w0.254: v2(249.71,42.69) PR1166.2 250.33,42.79 250.64,43.1 250.7,43.1 PR1168.1
N28152958: length 70.6
  TOP w0.102: v1(254.33,35.66) 254.72,35.66 255.02,35.35 255.78,35.35 PR1144.1
  TOP w0.254: PH1102.2 v2(222.18,18.19) ; PR1144.1 v2(256.26,36.66) PR1141.2
  BOTTOM w0.254: v2(256.26,36.66) 255.75,36.15 252.45,36.15 248.39,32.09 248.39,14.12 242.93,8.66 237.47,8.66 236.01,7.2 227.25,7.2 224.13,10.31 224.13,17.55 223.49,18.19 v2(222.18,18.19)
N28153047: length 6.2
  TOP w0.203: PC1104.2 261.86,45.54 261.47,45.93 v1(261.29,45.93) 261.18,45.93 260.82,45.57 PU1100.47
  TOP w0.254: PC1104.2 PC1102.2 263.4,45.54 PR1102.1 264.82,46.33 265.32,45.83 PR1101.2
N28153073: length 60.2
  TOP w0.254: v2(265.32,44.14) PR1101.1
  IN3 w0.254: v2(226.88,70.19) 230.41,70.19 231.23,69.36 234.19,69.36 235.55,70.72 239.48,70.72 239.51,70.76 244.58,70.76 245.47,69.87 245.47,61.62 251.28,55.8 258.14,55.8 258.8,55.14 258.8,51.31 261.85,48.26 261.85,45.99 263.5,44.34 265.12,44.34 v2(265.32,44.14)
  BOTTOM w0.254: PH1100.2 v2(226.88,70.19)
N28153161: length 3.2
  TOP w0.203: v2(261.33,45.42) 261.07,45.17 PU1100.46
  BOTTOM w0.254: PR1112.2 PC1106.2 v2(261.33,45.42)
N28153459: length 26.8
  TOP w0.102: v1(249.06,50.49) 249.59,49.96 v2(249.59,48.8)
  TOP w0.254: PR1165.2 PR1167.1 v2(249.59,48.8)
  IN2 w0.254: v2(241.27,66.06) 241.27,66.07 241.27,65.44 242.19,64.52 242.19,57.97 245.34,54.82 245.34,53.47 245.64,53.17 246.55,53.17 246.63,53.25 247.91,53.25 248.75,52.41 248.75,49.65 v2(249.59,48.8)
  BOTTOM w0.254: v2(241.27,66.06) 242.06,66.85 PH1103.1
N28153589: length 2.6
  TOP w0.203: PR1198.1 261.76,43.26 261.43,43.26 v1(261.02,43.67) 260.95,43.67 260.65,43.97 PU1100.43
N28153620: length 3.5
  TOP w0.203: PC1100.2 261.56,46.68 260.97,46.68 260.66,46.37 PU1100.49
  TOP w0.254: PR1116.2 PC1100.2
N28153632: length 5.2
  TOP w0.203: PU1100.50 260.6,46.77 260.85,47.02 261.29,47.02 261.72,47.45 261.72,48.59 262.22,49.09 PC1107.2
  TOP w0.254: PC1108.2 263.59,49.09 PC1107.2
N28153954: length 1.8
  TOP w0.102: v1(258,53.06) 257.95,53.01 PC1115.1
  TOP w0.254: PC1115.1 257.95,51.29 PR1133.2
N28154016: length 3.8
  BOTTOM w0.102: PR1122.2 257.61,54.07 v1(257.36,54.33)
  BOTTOM w0.254: PC1109.1 PC1110.1 PR1123.1 258.36,54.06 PR1122.2
N28154283: length 35.4
  TOP w0.254: v2(241.07,68.35) 241.07,67.36 243.73,64.7 243.73,61.59 248.41,56.91 249.09,56.91 249.96,56.04 v1(252.85,56.04) 254.38,56.04 255.31,55.12 255.31,53.9 PR1140.2 256.2,53.02 PR1142.1
  IN2 w0.254: v2(234.29,66.45) 234.29,67.3 235.64,68.65 240.77,68.65 v2(241.07,68.35)
  BOTTOM w0.254: v2(234.29,66.45) 233.95,66.8 233.49,66.8 233.2,67.09 PH1101.2
N28180064: length 0.9
  TOP w0.254: PR1118.2 263.59,50.01 PC1107.1
N28185893: length 2.2
  TOP w0.102: v1(259.24,35.71) 259.39,35.86 259.39,36.26 PC1116.1
  TOP w0.254: PR1134.2 258.91,36.74 PC1116.1
N28185971: length 2.4
  TOP w0.102: PR1130.2 259.74,52.52 v1(260.53,53.31)
  TOP w0.254: PC1114.1 PR1130.2
N28194524: length 1.8
  TOP w0.102: PR1619.1 v1(263.78,19.96)
  TOP w0.254: PC1640.2 PR1619.1
N28246475: length 6.2
  TOP w0.102: PR502.2 76.41,6.59 76.66,6.34 78.49,6.34 v1(79.56,5.28)
  TOP w0.254: PU500.7 75.13,8.19 PR502.2
N28252437: length 6.8
  TOP w0.102: PR505.2 70.27,12.03 69.85,12.44 69.85,13.74 v1(69.58,14.01)
  TOP w0.254: PR505.2 71.25,12.03 PR506.2 71.76,11.53 71.76,11.12 72.04,10.84 72.44,10.84 72.54,10.94 73.12,10.94 73.47,10.59 PU500.12
N28308683:
  vias: v1(250.83,21.38)
N28781981: length 7.7
  TOP w0.254: PR509.2 v2(68.64,12.95) ; PU500.13 72.97,9.9 72.79,9.72 72.43,9.72 v2(72.3,9.85)
  IN4 w0.508: v2(72.3,9.85) 71.74,9.85 v2(68.64,12.95)
  BOTTOM w0.102: v1(67.96,12.54) 68.37,12.95 v2(68.64,12.95)
N29181478: length 19.5
  TOP w0.102: v2(114.79,141.75) 115.29,142.26 118.79,142.26 118.91,142.39 JEDP1.18
  IN2 w0.127: v2(114.79,141.75) 114.79,142.39 110.57,146.6 109.67,146.6 108.56,147.71 v2(108.56,147.79)
  BOTTOM w0.102: R208.2 112.16,149.61 111.62,149.08 110.43,149.08 109.63,148.28 v1(109.61,148.28) 109.12,147.79 v2(108.56,147.79)
N29189335: length 12.1
  BOTTOM w0.102: U33.4 124.79,145.05 R3727.1 125.25,146.08 124.82,146.52 D93.1 123.11,146.92 121.95,148.08 v1(121.14,148.08) 119.33,148.08 119,148.41 D92.1
N30357948: length 3.8
  BOTTOM w0.102: R802.2 v1(193.15,107.88) 193.35,107.88 193.56,107.67 193.94,107.67 194.24,107.97 194.24,108.24 194.86,108.86 U51.A36
N30361613: length 1.9
  TOP w0.102: T155.1 204.79,107.84 v2(204.26,107.84)
  BOTTOM w0.102: v2(204.26,107.84) 204.47,107.84 204.74,108.11 U51.B15
N30472355: length 13.4
  IN2 w0.127: v2(211.6,112.63) 211.19,113.04 210.58,113.04 209.9,112.35 208.65,112.35 207.72,113.28 205.95,113.28 205.83,113.16 203.92,113.16 203.48,113.6 v2(203.44,113.6)
  BOTTOM w0.102: v2(203.44,113.6) 203.89,113.15 204.14,113.15 204.15,113.16 204.55,113.16 204.6,113.11 U51.B5 ; v2(211.6,112.63) 211.6,112.63 211.6,113.38 210.83,114.15 R797.2
N30479172: length 4.4
  BOTTOM w0.102: U46.B1 175.3,115.73 175.24,115.8 175.24,116.64 174.98,116.89 173.11,116.89 T165.1
N30480309: length 2.2
  TOP w0.102: R804.1 183.45,114.74 183.45,114.45 v2(183.18,114.19)
  BOTTOM w0.102: U46.B19 183.26,114.26 v2(183.18,114.19)
N30742939: length 3.5
  TOP w0.102: v1(225.2,124.37) 224.82,124.37 224.1,123.64 C538.2
  TOP w0.203: UZ25.12 223.18,122.53 223.99,123.34 C538.2
N30743995: length 1.7
  TOP w0.203: UZ25.10 223.38,121.73 C436.2
N31279764: length 2.1
  TOP w0.203: UZ20.12 302.84,29.87
  TOP w0.254: 302.84,29.87 v1(302.47,29.87) 301.73,29.87 C543.2
N31279793: length 4.5
  TOP w0.102: C544.2 300.94,31.03 v1(299.26,31.03)
  TOP w0.203: UZ20.10 302.92,30.67
  TOP w0.254: C544.2 302.54,30.5 302.72,30.67 302.92,30.67
N32871435: length 2
  TOP w0.102: C704.1 v1(189.69,148.43) 188.7,148.43 R756.2
N32871527: length 2.7
  TOP w0.102: RE11.2 CE8.1 179.64,148.59 v1(179.64,150.16)
N32871556: length 1.8
  TOP w0.102: v1(176.76,148.43) RE12.2 CE9.1
N33080426: length 2.2
  BOTTOM w0.102: R423.2 v1(111.15,133.35) 111.93,134.13 Q22.1
N33211036: length 6.7
  TOP w0.102: R389.1 299.08,7.2 299.94,6.33 v1(300.23,6.33) 301.69,6.33 302.24,6.88 D59.1 303.39,6.88 303.46,6.8 Q74.3
N33211312: length 3.2
  TOP w0.102: v1(309.35,4.81) 308.52,5.65 R943.1 308.52,7.15 Q86.1
N33211319: length 3.3
  TOP w0.102: Q74.6 306.73,8.1 306.79,8.16 Q86.2 307.88,8.16 308.92,9.2 v1(308.92,9.24)
N34391004: length 4.4
  TOP w0.102: Q29.5 10.92,42.39 10.77,42.54 10.77,42.95 10.87,43.04 Q29.6 12.16,43.04 v1(12.32,43.21) 12.46,43.34 12.46,43.6 11.9,44.15 R513.2
N34950493: length 6.1
  BOTTOM w0.102: v1(196.95,133.91) 196.18,133.14 196.18,130.96 196.1,130.88 RZ20.1 195.69,130.32 194.91,129.55 U637.27
N34977399: length 3
  TOP w0.254: v2(189.04,23.19) 189.15,23.3 189.15,23.77 189.16,23.78 CPU1.BT25
  BOTTOM w0.254: RC222.1 v3(188.68,22.47) 188.68,22.84 v2(189.04,23.19)
N35065265: length 4.5
  TOP w0.089: CPU1.D1 171.65,62.72 169.27,65.1 168.33,65.1 T1.1
N35065285: length 7.3
  TOP w0.089: 167.42,64.16 169.73,64.16 171.17,62.72 171.17,62.45 CPU1.E1
  TOP w0.102: 167.42,64.16 167.36,64.09 166.16,64.09 165.98,64.26 T2.1
N35065297: length 7.6
  TOP w0.089: CPU1.E3 172.13,63.1 171.51,63.1 169.04,65.57
  TOP w0.102: 169.04,65.57 168.9,65.71 167.15,65.71 T3.1
N35065301: length 6.5
  TOP w0.089: CPU1.E2 172.27,62.31 171.63,62.31 171.34,62.59 171.34,62.79 169.66,64.47 167.94,64.47
  TOP w0.102: 167.94,64.47 167.14,64.47 T4.1
N35065321: length 7.2
  TOP w0.089: CPU1.BR1 171.69,24.1 170.71,23.13 170.71,21.97 171.53,21.16 171.53,20.93
  TOP w0.102: 171.53,20.93 171.53,20.69 172.11,20.11 172.98,20.11 T5.1
N35065331: length 3.4
  TOP w0.089: T6.1 172.13,21.11 172.13,22.05 171.89,22.29 171.89,22.56 171.77,22.68 171.77,23.3 172.26,23.78 CPU1.BT2
N35065345: length 4.6
  TOP w0.089: T7.1 195.42,22.04 195.88,22.5 195.88,23.7 195.7,23.88 195.7,24.29 195.76,24.35 195.76,25.55 CPU1.BN35
N35065469: length 1.2
  TOP w0.089: CPU1.BL34 195.71,27.54 v2(196.03,27.86)
  BOTTOM w0.089: v2(196.03,27.86) 195.92,27.75 T8.1
N35065471: length 1.3
  TOP w0.089: v2(194.28,26.36) 194.6,26.04 CPU1.BN33
  BOTTOM w0.089: v2(194.28,26.36) 193.89,25.97 T11.1
N35065481: length 10.2
  TOP w0.089: v2(188.42,58.72) 188.42,58.88 188.6,59.06 CPU1.J24
  IN2 w0.089: v2(188.42,58.72) 188.44,58.74 188.44,59.39 189.4,60.35 189.4,65.12 v2(190.23,65.95)
  BOTTOM w0.089: v2(190.23,65.95) 188.91,65.95 T9.1
N35065499: length 11.8
  TOP w0.089: v2(189.13,58.71) 189.13,59 188.96,59.17 188.96,59.75 CPU1.H24
  IN2 w0.089: v2(189.13,58.71) 189.13,59.82 190.16,60.85 190.16,64.82 190.59,65.25 190.59,67.16 v2(190.38,67.37)
  BOTTOM w0.089: v2(190.38,67.37) 190.38,66.74 T10.1
N35065517: length 1.2
  TOP w0.089: CPU1.AA14 180.58,49.73 v2(180.62,49.73)
  BOTTOM w0.089: T12.1 180.31,50.05 v2(180.62,49.73)
N35065519: length 2.1
  TOP w0.089: CPU1.AE29 191.97,47.15 v2(191.72,46.9)
  BOTTOM w0.089: T15.1 191.49,47.13 v2(191.72,46.9)
N35065537: length 3.8
  TOP w0.254: v2(191.67,56.43) 192.24,56.43 CPU1.N29
  BOTTOM w0.089: T14.1 189.27,55.09 189.91,55.73 190.27,55.73 190.96,56.43 v2(191.67,56.43)
N35065547: length 2
  TOP w0.203: v2(180.8,54.91) 180.63,54.74 CPU1.R14
  BOTTOM w0.089: T13.1 181.41,54.91 v2(180.8,54.91)
N35067252: length 5
  TOP w0.089: CPU1.B30 193.33,64.33 193.1,64.55 193.1,65.52 193.64,66.05 193.64,66.6 v1(193.77,66.74) 193.97,66.94 T18.1
N35067254: length 5.9
  TOP w0.089: CPU1.C30 193.33,63.62 192.93,64.01 192.93,65.59 193.43,66.08 193.43,68.17 193.48,68.22 193.48,68.59 T19.1
N35067276: length 9.1
  TOP w0.089: T21.1 167.24,59.96 168.57,59.96 168.83,60.22 168.83,60.55 169.31,61.03 169.87,61.03 171.32,59.58 172.36,59.58 172.67,59.89 172.67,60.45 CPU1.G3
N35067278: length 7.8
  TOP w0.089: T20.1 167.8,59.46 168.05,59.71 168.7,59.71 169.08,60.09 169.08,60.56 169.38,60.86 169.8,60.86 171.25,59.41 172.43,59.41 CPU1.J3
N35067292: length 2.8
  TOP w0.089: T24.1 194.09,22.37 194.03,22.43 194.03,23.86 194.14,23.97 194.14,24.2 194.02,24.32 194.02,24.52 193.88,24.66 CPU1.BR31
N35067294: length 1.1
  TOP w0.089: CPU1.BH30 193.06,29.05 v2(193.44,29.43)
  BOTTOM w0.089: T22.1 193.4,29.48 v2(193.44,29.43)
N35067312: length 6.2
  TOP w0.089: CPU1.BR35 196.22,24.85 196.52,25.15 197.06,25.15 197.22,25 197.22,24.44 197.37,24.29 197.37,21.89 196.43,20.95 T23.1
N35067374: length 2.6
  TOP w0.089: CPU1.BM33 194.74,26.69 v2(195.07,26.36)
  BOTTOM w0.089: v2(195.07,26.36) 194.52,25.81 T26.1
N35067376: length 1.9
  TOP w0.089: CPU1.BL33 195.06,27.54 v2(195.38,27.86)
  BOTTOM w0.089: v2(195.38,27.86) 195.03,27.51 195.03,27.4 194.91,27.27 T25.1
N35067398: length 2.3
  TOP w0.089: v2(180.68,29.3) 180.54,29.15 CPU1.BJ14
  BOTTOM w0.089: v2(180.68,29.3) 180.68,28.54 T28.1
N35067408: length 2
  TOP w0.089: CPU1.BJ13 179.39,28.59 v2(179.34,28.64)
  BOTTOM w0.089: T27.1 179.98,29.29 v2(179.34,28.64)
N35067430: length 3.1
  TOP w0.089: CPU1.BK28 191.52,27.99 191.15,28.36 191.15,28.79 190.93,29.01 190.63,29.01 v2(190.41,29.22)
  BOTTOM w0.089: T29.1 190.41,28.69 v2(190.41,29.22)
N35067432: length 1.7
  TOP w0.089: v2(191.05,29.38) 191.05,29.13 191.52,28.66 CPU1.BJ28
  BOTTOM w0.089: T30.1 190.97,29.45 v2(191.05,29.38)
N35067454: length 1.6
  TOP w0.089: CPU1.BJ16 182.07,28.74 v2(182.51,29.17)
  BOTTOM w0.089: T31.1 182.08,29.6 v2(182.51,29.17)
N35067456: length 2.5
  TOP w0.089: v2(181.82,29.17) 181.72,29.07 181.72,28.34 CPU1.BK16
  BOTTOM w0.089: v2(181.82,29.17) 181.82,28.07 T32.1
N35067478: length 3.1
  TOP w0.089: CPU1.BK24 188.78,28.4 188.78,28.84 189.09,29.15 v2(189.09,29.33)
  BOTTOM w0.089: v2(189.09,29.33) 189.09,28.3 T34.1
N35067480: length 1.8
  TOP w0.089: CPU1.BJ24 188.37,29.19 v2(188.38,29.2)
  BOTTOM w0.089: v2(188.38,29.2) 188.38,30.14 T33.1
N35067502: length 3.4
  TOP w0.089: v2(185.3,29.35) 185.62,29.04 185.62,28.38 CPU1.BK21
  BOTTOM w0.089: T36.1 184.17,29.69 184.96,29.69 v2(185.3,29.35)
N35067504: length 2.1
  TOP w0.089: v2(186.01,29.36) CPU1.BJ21
  BOTTOM w0.089: T35.1 186.01,30.01 v2(186.01,29.36)
N35067526: length 2.6
  TOP w0.089: T37.1 182.91,22.12 182.91,24.04 CPU1.BT17
N35067528: length 5.2
  TOP w0.089: CPU1.BR17 182.73,24.61 182.73,24.35 182.58,24.2 182.58,23.97 182.66,23.9 182.66,22.52 182.05,21.91 182.05,20.99 T38.1
N35067550: length 1.3
  TOP w0.089: v2(196.03,28.65) 195.71,28.32 CPU1.BJ34
  BOTTOM w0.089: v2(196.03,28.65) 196.23,28.84 T39.1
N35067552: length 1.4
  TOP w0.089: v2(195.38,28.65) 195.06,28.32 CPU1.BJ33
  BOTTOM w0.089: T40.1 194.81,29.22 v2(195.38,28.65)
N35067718: length 2.1
  TOP w0.089: v2(179.54,61.1) 179.83,60.81 CPU1.G13
  BOTTOM w0.089: v2(179.54,61.1) 179.65,61.1 CPU1.G13 179.94,60.13 T42.1
N35067720: length 1.6
  TOP w0.089: CPU1.AJ8 176.41,43.77 v2(176.74,44.22)
  BOTTOM w0.089: v2(176.74,44.22) 176.22,43.7 T41.1
N35067742: length 1.2
  TOP w0.089: v2(193.43,27.9) 193.76,27.57 CPU1.BL31
  BOTTOM w0.089: T44.1 193.41,27.88 v2(193.43,27.9)
N35067833: length 5.6
  TOP w0.089: CPU1.B2 171.7,64.05 169.2,66.54
  TOP w0.102: T43.1 168.8,66.95 169.2,66.54
N35067843: length 1.1
  TOP w0.089: v2(198.54,64.67) 198.54,64.39 CPU1.B38
  BOTTOM w0.089: v2(198.54,64.67) 198.61,64.61 T45.1
N35067845: length 5.4
  TOP w0.089: CPU1.BP1 171.56,25.38 170.9,24.72 170.9,23.86 170.35,23.31 170.35,21.78 170.66,21.47 170.66,20.93
  TOP w0.102: T46.1 170.66,20.77 170.66,20.93
N35067855: length 8
  TOP w0.089: CPU1.BR2 172.16,25.02 171.49,25.02 171.2,24.73 171.2,23.87 170.54,23.21 170.54,21.88 171.11,21.31 171.11,20.93
  TOP w0.102: T47.1 172.39,19.51 171.11,20.79 171.11,20.93
N35067873: length 7
  TOP w0.089: 169.2,65.93 CPU1.C1
  TOP w0.102: T48.1 166.53,66.82 167.24,66.82 167.95,66.12 169.02,66.12 169.2,65.93
N35067875: length 2.9
  TOP w0.089: v2(198.54,65.25) 198.1,64.81 198.1,64.43 197.97,64.3 197.97,63.72 CPU1.C38
  BOTTOM w0.089: v2(198.54,65.25) 198.61,65.32 T49.1
N35171080: length 2.4
  TOP w0.102: JDIMM1.162 122.81,57.43 T50.1
N35171100: length 2.4
  TOP w0.102: T51.1 134.79,58.29 134.67,58.17 JDIMM1.165
N35224222: length 4
  TOP w0.102: v2(122.37,56.95) 122.25,56.84 T53.1
  BOTTOM w0.102: JDIMM2.165 122.9,58.17 122.37,57.64 v2(122.37,56.95)
N35228093: length 3.2
  TOP w0.102: v2(108.39,57.22) 108.59,57.43 JDIMM3.162
  BOTTOM w0.102: T54.1 108.15,56.98 v2(108.39,57.22)
N35228103: length 2.5
  TOP w0.102: JDIMM3.165 119.76,58.17 119.89,58.31 120.85,58.31 T55.1
N35231774: length 4.3
  TOP w0.102: T56.1 v2(121.75,58.9)
  BOTTOM w0.102: v2(121.75,58.9) 120.27,57.43 JDIMM4.162
N35231784: length 3
  BOTTOM w0.102: T57.1 108.09,59.08 108.99,58.17 JDIMM4.165
N35432783: length 6.1
  TOP w0.102: Q74.1 302.97,8.1 D59.2 D62.2 300.73,8.28 300.61,8.16 R932.2 300.23,8.18 v1(300.23,9.05) 300.22,9.06 R389.2
N35434414: length 1.6
  TOP w0.089: v2(126.71,114.26) UH1.AE17
  BOTTOM w0.089: T58.1 127.25,113.73 v2(126.71,114.26)
N35434416: length 1.1
  TOP w0.089: UH1.AF17 v2(126.71,115.04)
  BOTTOM w0.089: T61.1 126.31,114.64 v2(126.71,115.04)
N35434426: length 1.2
  TOP w0.089: v2(128.1,115.31) 128.1,115.16 UH1.AG15
  BOTTOM w0.089: v2(128.1,115.31) 127.85,115.06 T59.1
N35434444: length 1.3
  TOP w0.089: UH1.AG14 128.37,114.95 v2(128.72,115.3)
  BOTTOM w0.089: v2(128.72,115.3) 128.72,115.14 T60.1
N35435133: length 1.4
  TOP w0.089: UH1.AN17 v2(127.65,117.82)
  BOTTOM w0.089: v2(127.65,117.82) 127.53,117.7 T62.1
N35435135: length 1.2
  TOP w0.089: UH1.AR19 v2(126.23,118.63)
  BOTTOM w0.089: v2(126.23,118.63) 126.57,118.97 T63.1
N35468556: length 3.2
  BOTTOM w0.102: SW2.2 201.87,142.09 202.29,142.51 v1(202.29,142.95) 202.03,143.21 R3728.2
N35632688: length 1.2
  TOP w0.089: UH1.AR22 v2(125.19,118.63)
  BOTTOM w0.089: v2(125.19,118.63) 124.77,118.63 T66.1
N35632711: length 1.1
  TOP w0.101: v2(128.77,110.87) UH1.W13
  BOTTOM w0.089: v2(128.77,110.87) 128.68,110.78 T67.1
N35632737: length 1.5
  TOP w0.089: v2(129.53,109.45) 129.13,109.86 UH1.U13
  BOTTOM w0.089: v2(129.53,109.45) 129.9,109.08 T68.1
N35632759: length 1.5
  TOP w0.089: UH1.P27 121.77,108.73 v2(121.67,108.63)
  BOTTOM w0.089: T71.1 121.04,108 v2(121.67,108.63)
N35632761: length 1.2
  TOP w0.101: v2(121.55,109.3) 121.55,109.29 UH1.R27
  BOTTOM w0.089: T72.1 121.08,109.3 v2(121.55,109.3)
N35632771: length 1.6
  TOP w0.101: v2(120.52,108.75) 120.52,108.5 UH1.N29
  BOTTOM w0.089: v2(120.52,108.75) 120.45,108.68 T74.1
N35632791: length 1.3
  TOP w0.089: UH1.AN29 120.6,117.9 v2(120.35,117.77)
  BOTTOM w0.089: T76.1 120.42,117.84 v2(120.35,117.77)
N35632799: length 1.2
  TOP w0.101: UH1.R24 122.85,109.29 v2(122.76,109.38)
  BOTTOM w0.089: v2(122.76,109.38) 122.49,109.11 T75.1
N35632831: length 1.4
  TOP w0.101: UH1.P31 v2(119.59,109.23)
  BOTTOM w0.089: T69.1 119.55,109.27 v2(119.59,109.23)
N35928091: length 3
  TOP w0.089: CPU1.BP13 179.41,25.09 179.41,23.84 179.54,23.71 179.54,23.2 179.47,23.13 T199.1
N36146693: length 1.9
  TOP w0.102: v1(137.9,55.32) CD127.2 138.79,54.45 RD16.1
N36161597: length 2.7
  TOP w0.102: CD136.2 136.55,7.91 136.78,8.15 v1(136.96,8.15) 137.16,8.15 137.44,7.87 RD34.1
N36161994: length 14.7
  TOP w0.254: PH1600.1 259.64,18.14 v2(260.3,17.49) ; v2(260.77,28.91) 261.07,28.91 PR1602.2
  IN3 w0.254: v2(260.77,28.91) 259.42,27.56 259.42,25.99 259.82,25.6 259.82,23.82 260.06,23.58 260.06,17.73 v2(260.3,17.49)
N36167915: length 2.7
  TOP w0.102: v1(105.52,55.06) 106.4,55.06 RD14.2
  TOP w0.508: RD14.2 106.46,54.2 RD47.1 RD46.2
N36357812: length 2
  TOP w0.102: v1(334.96,22.8) 334.83,22.68 PC304.2
  TOP w0.254: PC304.2 333.83,22.69 PR309.1
N36358256: length 1.8
  TOP w0.254: PU300.5 330.46,19.43 331.11,20.09 PC309.1
N36363134: length 2
  TOP w0.203: PU700.9 270.26,33.46 PR730.2
N36376984: length 2.9
  TOP w0.102: PR311.2 333.3,24.89 v1(333.3,25.45)
  TOP w0.254: PR314.1 PR311.2 332.94,23.6 PR307.2
N36552797: length 3.5
  TOP w0.102: v1(240.42,87.53) 240.77,87.88 C35.1 241.08,88.72 241.36,88.72 242.05,89.41 U8.33
N36554430: length 1.7
  TOP w0.102: v2(251.71,86.33) 251.71,85.98 251.74,85.95 R373.2 251.74,84.66 C365.1
N36983176: length 2.5
  TOP w0.102: R375.2 248.17,82.09 248.42,81.84 v1(248.7,81.84) 248.89,81.84 249.06,82.01 C1420.1
N37419796: length 10.5
  TOP w0.102: RC329.2 CC273.1 201.92,102.64 v1(203.56,102.64) 204.39,102.64 204.58,102.45 204.58,101.38 RC320.1 205.24,100.69 205.24,100.43 204.92,100.11 204,100.11 203.79,99.91 203.79,99.28 203.98,99.1 UC1.2
N37419798: length 14.3
  TOP w0.102: v2(201.87,101.84) 201.87,101.66 202.13,101.39 UZ19.4 ; RC320.2 205.48,101.69 206.05,102.27 v1(206.2,102.27) 206.39,102.27 206.55,102.11 206.55,101.55 206.1,101.1 v2(206.1,100.86) ; UC1.4 206.98,98.45 207.12,98.31 207.12,97.8 207.01,97.7 206.68,97.7 206.61,97.62 v2(206.61,97.62)
  IN2 w0.127: v2(206.1,100.86) 205.69,101.26 202.66,101.26 202.09,101.84 v2(201.87,101.84)
  IN3 w0.127: v2(206.61,97.62) 206.61,97.62 206.61,98.76 205.77,99.6 205.77,100.53 v2(206.1,100.86)
N37422512: length 3.3
  TOP w0.102: R371.2 255.65,84.4 v1(255.95,84.1) 255.96,84.09 LED5.2
N37422518: length 6.5
  TOP w0.102: U8.43 251.81,88.54 252,88.73 253.09,88.73 254.99,86.82 v1(254.99,86.29) R371.1
N37462221: length 3.3
  BOTTOM w0.102: R2198.2 150.88,115.32 150.88,114.88 151.04,114.73 151.52,114.73 151.93,114.31 v1(151.93,114.19) 151.93,114.15 151.86,114.08 Q355.3
N37462233: length 4
  BOTTOM w0.102: Q353.6 149.65,123.99 v1(149.57,123.9) 149.46,123.79 149.46,122.83 R2197.2 149.99,122.6 150.18,122.79 150.18,123.1 150.42,123.34 Q353.5
N37462411: length 2.4
  BOTTOM w0.102: R3736.2 149.46,120.39 149.28,120.57 v1(148.85,120.57) 148.04,120.57 147.82,120.35 Q364.3
N37462435: length 2.1
  BOTTOM w0.102: Q364.6 146.52,117.68 v1(146.18,117.34) 145.98,117.14 R3737.2
N37463021: length 3.5
  BOTTOM w0.102: RV41.1 v1(153.23,111.74) 153.65,112.16 153.65,112.29 154.09,112.73 UV2.20
N37463172: length 2
  TOP w0.102: CV42.1 155.37,112.35 v2(155.29,112.26)
  BOTTOM w0.102: UV2.17 v2(155.29,112.26)
N37758275: length 1.8
  TOP w0.089: 119.9,108.1 v2(119.37,108.63)
  TOP w0.101: UH1.N31 119.9,108.1
  BOTTOM w0.089: v2(119.37,108.63) 119.37,108.62 T70.1
N37986180: length 5.9
  TOP w0.102: UZ26.12 210,96.3 210.27,96.57 210.58,96.57 211.14,97.12 212.34,97.12 213.03,97.82 C437.2 213.49,98.6 v1(213.92,99.03)
N37986182: length 5.4
  TOP w0.102: UZ26.10 210.8,96.28 211.41,96.88 212.89,96.88 C542.2 213.92,97.91 v1(215.07,97.91)
N38685436: length 3.2
  TOP w0.102: v2(171.57,141.09) 171.82,141.35 R2196.2 v1(172.78,142.32)
  BOTTOM w0.102: v2(171.57,141.09) 171.32,141.34 Q365.3
N38685448: length 2.4
  TOP w0.102: v2(169.74,140.58) 169.66,140.51 R2195.2 v1(170.54,139.78)
  BOTTOM w0.102: Q365.6 170.02,140.29 169.74,140.57 v2(169.74,140.58)
N38717052: length 4.9
  TOP w0.089: T194.1 194.68,68.41 195.13,67.96 195.13,65.19 195.35,64.98 CPU1.A33
N38949830: length 2.9
  TOP w0.102: v1(189.3,95.85) 188.98,95.85 188.37,96.46 RC303.2 188.37,97.86 UZ18.4
N39322049: length 2.4
  BOTTOM w0.102: Q355.6 149.58,111.01 R2194.2 v1(149.34,109.84)
N39410700: length 5.6
  TOP w0.102: PR1802.2 59.21,6.21 59.59,5.83 61.12,5.83 v1(61.59,6.3)
  TOP w0.254: PU1800.7 58.33,8.03 58.53,7.83 58.53,7.18 PR1802.2
N39410717: length 4.8
  TOP w0.254: PR1805.2 53.33,11.77 PR1806.2 53.5,11.65 54.22,10.93 54.39,10.93 v1(54.54,10.78) 54.58,10.82 55.99,10.82 56.35,10.45 PU1800.12
N39410719: length 6.2
  TOP w0.254: PU1800.13 55.85,9.67 55.67,9.49 55.23,9.49 54.22,10.5 53.83,10.5 53.48,10.84 v1(51.95,10.84) 51.79,10.84 51.45,11.18 PR1810.2
N39410732:
  vias: v1(60.2,14.85)
N39467529: length 4.5
  BOTTOM w0.102: v1(235.93,81.02) PC903.2
  BOTTOM w0.254: PR903.1 235.91,82.02 PR902.2 ; PR902.2 235,82.47 235.23,82.7 PU900.2 ; PR902.2 235,81.04 PC903.2
N39810242: length 1.8
  TOP w0.102: JMXM1.57 208.5,89.16 208.39,89.26 R1971.2
N39900137: length 3.1
  TOP w0.102: R1972.1 v1(213.22,77.88) 213.22,78.49 212.75,78.97 JMXM1.40
N40865409: length 3.6
  TOP w0.102: R3744.2 170.01,99.36 170.64,98.72 170.64,98.36 v1(170.59,98.31) 170.27,97.99 170.09,97.99 Q367.5 Q367.6
N40865430: length 2.2
  TOP w0.102: Q369.1 171.41,95.17 171.19,94.94 v1(171.19,94.54) 171.42,94.3 R3745.1
N40865432: length 2.2
  TOP w0.102: Q369.4 172.71,97.9 172.65,97.96 R3747.1 172.65,98.6 173.11,99.05 v1(173.11,99.4)
N40900595: length 4.5
  BOTTOM w0.102: R3748.2 171.76,105.82 172.06,106.13 172.56,106.13 v1(172.7,105.99) 172.7,106.32 173.02,106.64 174.16,106.64 174.29,106.76 U46.B52
N41074937: length 140.7
  TOP w0.102: UZ27.3 153.35,124.73 v2(153.48,124.86) ; v2(128.69,142.7) 132.5,142.7 133.33,141.88 133.33,137.31 132.82,136.8 132.82,135.08 131.58,133.85 127.01,133.85 126.22,133.05 126.22,132.29 126.6,131.91 128.19,131.91 128.95,131.15 R418.2 ; v2(187.14,125.83) 187.21,125.76 187.21,125.06 186.06,123.91 186.06,117.23 186.56,116.73 187.01,116.73 187.43,116.31 188.62,116.31 190.3,114.64 191.55,114.64 192.05,114.14 192.05,112.68 191.74,112.36 191.46,112.36 191.21,112.11 191.21,111.58 191.93,110.86 191.93,109.43 v1(191.56,109.06) 191.56,108.26 v2(191.53,108.24)
  IN2 w0.127: v2(187.14,125.83) 186.4,125.83 185.57,125 181.93,125 181.09,124.16 175.58,124.16 174.88,123.46 169.84,123.46 169.08,122.7 167.46,122.7 167.02,122.27 165.39,122.27 165.13,122.53 162.39,122.53 162.18,122.32 155.05,122.32 154.6,122.77 154.6,123.73 v2(153.48,124.86)
  BOTTOM w0.102: v2(191.53,108.24) 191.24,108.24 R417.2 ; v2(128.69,142.7) 129.06,143.07 141.74,143.07 142.24,143.58 158.04,143.58 160.28,141.34 160.28,137.21 159.75,136.69 158.36,136.69 157.99,136.32 157.99,131.81 154.39,128.21 154.39,125.77 v2(153.48,124.86)
N41075951: length 8.5
  TOP w0.102: UZ27.6 150.1,124.73 149.9,124.92 149.9,125.37 150.09,125.56 153.03,125.56 153.11,125.64 154.05,125.64 154.05,125.65 154.12,125.65 155.21,126.73 v1(155.21,126.89) 155.21,127.11 154.65,127.67 C1444.2
N41076988: length 4.3
  TOP w0.102: v1(183.01,101.84) 182.84,101.67 C1423.1 181.5,100.45 181.81,100.14 UZ23.6
N41078830: length 2.6
  TOP w0.102: C547.2 148.82,122.88 148.92,122.98 v1(149.15,122.98) 149.35,122.98 150.02,122.32 UZ28.6
N41079831: length 2.7
  TOP w0.254: C539.1 243.63,78.37 243.63,78.89 243.05,79.46 UZ22.6
N41080862: length 2.6
  TOP w0.203: UZ21.6 18.62,43.32 18.33,43.61 18.33,43.62 18.3,43.65 18.3,43.83 18.04,44.09 v1(18.04,44.24) C477.2
N41081469: length 4.1
  TOP w0.102: UZ24.6 323.57,31.71 323.32,31.47 322.28,31.47 C541.1 321.34,32.41 v1(320.53,32.41)
N41115318: length 2.3
  BOTTOM w0.102: C1466.1 188.59,122.58 189.24,121.93 v1(189.24,121.81) 189.24,121.7 189.16,121.62 R3755.2
N41175521: length 2.2
  TOP w0.102: R795.2 184.13,106.85 v1(184.09,106.89) 183.8,107.18 C713.1
N41175710: length 2.7
  BOTTOM w0.102: C1469.1 208.39,133.24 208.51,133.12 v1(208.51,132.68) 208.51,132.4 208.46,132.35 R3757.2
N41251989: length 3.5
  TOP w0.102: T211.1 204.56,77.51 204.42,77.51 203.83,78.1 203.83,78.65 204.25,79.06 JMXM1.74
N41251992: length 2.2
  TOP w0.102: T212.1 203.54,77.9 203.54,78.68 203.75,78.89 JMXM1.76
N41251995: length 3.9
  TOP w0.102: JMXM1.80 202.75,78.77 202.76,78.75 202.76,77.73 203.75,76.74 T213.1
N41251998: length 2.6
  TOP w0.102: JMXM1.75 204,89.64 T214.1
N41252001: length 4
  TOP w0.102: JMXM1.77 203.5,89.94 204,90.45 204,91.24 T215.1
N41252004: length 3.3
  TOP w0.102: T216.1 203.31,90.4 202.5,89.58 JMXM1.81
N41682393: length 2.7
  TOP w0.203: v2(350.14,33.47) 350.27,33.34 PU101.19
  BOTTOM w0.102: PR114.1 351.39,33.29 v1(351.72,33.62)
  BOTTOM w0.254: PR114.1 350.32,33.29 v2(350.14,33.47)
N42439176: length 3.2
  BOTTOM w0.102: T52.1 135.18,56.45 134.2,57.43 JDIMM2.162
N42877369: length 3.4
  TOP w0.102: R39.2 245.38,106.26 v1(244.98,106.26) 244.41,105.68 Q366.4
N42877372: length 2.3
  TOP w0.102: Q366.1 242.3,103.96 242.12,103.96 v1(242.07,103.91) 242.02,103.86 R38.2
