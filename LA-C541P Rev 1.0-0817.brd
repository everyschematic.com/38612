# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALW on TOP (solid shape): 235.99,37.54 235.99,36.34 235.92,36.26 235.1,36.26 235,36.36 235,36.65 234.79,36.86 234.79,37.3 234.79,37.31 234.79,37.54 234.97,37.73 235.8,37.73
+5V_ALW on TOP (solid shape): 58.4,35.01 59.09,35.01 59.22,34.88 59.22,33.87 59.09,33.74 59.09,32.16 58.57,31.64 58.03,31.64 57.07,30.69 55.16,30.69 55.03,30.82 55.03,35.39 55.16,35.52 57.89,35.52
+5V_ALW on TOP (solid shape): 240.63,79.01 240.63,78.82 240.82,78.63 241.45,78.63 241.66,78.43 241.66,77.59 241.47,77.4 240.91,77.4 240.37,77.93 240.25,78.05 240.25,78.17 239.81,78.62 239.81,79.01 239.88,79.08 240.56,79.08
+5V_ALW on TOP (solid shape): 241.33,59.71 241.33,59.39 241.13,59.2 240.12,59.2 239.84,58.92 239.84,58.35 239.77,58.29 239.36,58.29 239.29,58.35 239.36,58.57 239.29,58.79 239.29,59 239.09,59.2 238.34,59.2 238.21,59.08 235.29,59.08 235.1,59.27 235.1,59.71 235.28,59.88 241.15,59.88
+5V_ALW on TOP (solid shape): 306.02,29.33 306.73,29.33 306.75,29.34 308.14,29.34 308.25,29.23 310.22,29.23 310.23,29.24 310.5,29.24 310.75,29.48 312.34,29.48 312.46,29.36 312.46,23.77 312.21,23.52 311.76,23.52 311.76,23.51 310.13,23.51 309.71,23.93 309.71,24.15 309.59,24.28 308.14,24.28 307.32,25.1 307.32,27.12 306.67,27.77 306.03,27.77 305.11,28.69 305.11,29.56 305.16,29.61 305.74,29.61
+5V_ALW on TOP (solid shape): 241.33,49.55 241.33,49.23 241.13,49.04 240.49,49.04 239.89,48.45 239.89,48.41 239.85,48.29 239.84,48.16 239.68,48 239.49,48 239.33,48.16 239.32,48.16 239.1,48.53 238.68,48.45 238.21,48.92 235.29,48.92 235.1,49.11 235.1,49.55 235.28,49.72 241.15,49.72
+5V_ALW on TOP (solid shape): 236.63,40.91 236.63,39.88 236.94,39.56 241.4,39.56 241.51,39.45 241.51,38.99 241.11,38.59 240.36,38.59 239.84,38.07 239.75,37.83 239.84,37.58 239.84,37.4 239.71,37.28 239.33,37.28 239.14,37.46 239.17,38.03 238.6,38 238.32,38.28 238.23,38.51 238,38.6 237.85,38.76 236.69,38.76 235.86,39.58 235.86,40.91 235.99,41.04 236.5,41.04
+5V_ALW on BOTTOM (solid shape): 242.03,39.56 242.03,38.94 241.9,38.8 240.99,38.8 240.84,38.95 240.84,39.18 241.03,39.37 241.03,39.55 241.13,39.65 241.94,39.65
+5V_ALW on BOTTOM (solid shape): 242.01,49.97 242.01,49.2 241.82,49 240.92,49 240.79,49.14 240.79,49.41 240.95,49.58 240.95,49.81 240.95,49.82 240.95,49.95 241.06,50.06 241.92,50.06
+5V_ALW on BOTTOM (solid shape): 241.98,60.25 241.98,59.41 241.89,59.32 241.11,59.32 241.11,59.32 240.82,59.32 240.73,59.41 240.73,59.72 240.97,59.97 240.97,60.24 241.06,60.33 241.9,60.33
+5V_ALW on BOTTOM (solid shape): 348.07,51.65 348.07,49.93 347.75,49.61 347.12,49.61 347.12,50.19 345.08,50.19 345.08,49.61 341.72,49.61 341.72,50.19 339.69,50.19 339.69,49.61 339.31,49.61 339.18,49.74 339.18,51.52 339.66,52 340.26,52.6 347.12,52.6
+5V_ALW on BOTTOM (solid shape): 235.66,69.83 235.66,69.61 235.62,69.56 235.32,69.56 235.08,69.36 235.07,69.05 235,68.98 234.65,68.98 234.52,69.11 234.52,69.62 234.59,69.69 234.59,69.73 234.77,69.92 235.58,69.92
+5V_ALW on BOTTOM (solid shape): 233.97,17.45 233.98,17.2 234.14,17.01 234.14,17.01 234.49,16.66 235.61,16.66 235.7,16.57 235.7,16.11 235.57,15.99 235.19,15.99 235.18,15.97 229.31,15.97 229.13,16.15 229.13,16.59 229.32,16.78 232.78,16.78 232.96,16.97 233.34,17.05 233.45,17.42 233.62,17.6 233.82,17.6
+5V_ALW on BOTTOM (solid shape): 234.07,28 234.08,27.72 234.29,27.52 234.46,27.35 235.5,27.35 235.78,27.07 235.78,26.57 235.58,26.37 232.33,26.37 232.09,26.13 229.05,26.13 228.95,26.24 228.95,26.8 229.1,26.94 232.24,26.94 232.93,27.63 233.39,27.63 233.51,28.07 233.63,28.19 233.88,28.19
+5V_ALW on BOTTOM (solid shape): 236.5,38.44 236.5,37.74 236.18,37.42 235.55,37.42 235.31,37.19 235.31,36.69 235.19,36.57 233.87,36.57 233.86,36.58 232.07,36.58 231.79,36.29 229.31,36.29 229.13,36.47 229.13,36.91 229.32,37.1 230.89,37.1 231.28,37.5 233.21,37.5 233.5,37.8 233.5,38.17 233.63,38.29 233.87,38.29 234.01,38.15 234.01,38.13 233.99,38.01 234.01,37.88 234.01,37.85 234.03,37.83 234.45,37.63 234.75,37.98 235.34,38.56 236.37,38.56
+5V_ALW on TOP: 208.14,94.28 209.7,94.28 209.78,94.21 209.78,92.09 209.66,91.97 207.81,91.97 207.68,92.1 207.68,93.83
+5V_ALW on IN1: 347.88,52.18 348.46,51.59 348.46,49.9 346.56,48 339.99,48 339.09,47.09 339.09,46.96 338.84,46.71 338.05,46.71 336.98,45.63 336.98,38.53 337,38.51 337,34.23 337,34.22 337,32.85 335.96,31.81 332.43,31.81 332.19,32.06 332.19,37.79 333.02,38.62 333.02,46.66 336.69,50.33 337.52,50.33 339.37,52.18
+5V_ALW on VCC: 58.76,20.85 54.57,25.08 54.57,36.43 56.45,38.31 72.08,38.31 86.66,52.94 86.66,61.25 89.77,64.3 89.77,74.97 94.77,79.98 98.18,83.34 110.56,95.71 188.85,95.71 204.13,95.71 204.3,95.63 204.5,95.7 204.51,95.71 224.71,95.71 224.71,88.18 225.62,87.27 236.24,87.27 237.26,88.29 246.19,88.29 251.44,83.04 251.44,75.73 254.87,72.3 254.87,67.86 257.41,65.32 257.41,60.24 261.79,55.86 261.71,37.06 268.33,30.44 269.11,30.44 269.88,29.67 271.36,29.67 272.12,30.44 314.65,30.44 319.09,34.88 323.03,34.88 330.42,42.27 330.42,42.37 339.33,42.37 341.46,40.24 341.46,31.94 333.63,24.09 329.06,24.09 328.3,23.32 327.32,23.32 253.69,23.32 249.39,27.62 249.41,56.54 249.41,58.55 246.23,61.72 246.23,74.55 241.07,79.75 240.96,79.9 155.98,79.9 150.01,85.87 112.14,85.87 106.28,80.01 106.28,20.85
+5V_ALW on IN3: 334.37,52.93 346.75,52.93 348.39,51.29 348.39,48.84 347.44,47.9 340.4,47.9 339.07,46.57 339.07,36.16 337.72,34.82 333.8,34.82 333.48,35.14 333.48,37.04 332.78,37.74 332.78,40.15 331.84,41.1 331.84,50.4
+5V_ALW on IN4: 59.25,33.79 51.67,33.79 50.44,35.02 46.82,35.02 46.36,34.56 42.9,34.56 39.5,31.16 36.81,31.16 35.74,30.09 35.74,28.85 34.73,27.83 31.35,27.83 28.93,25.42 26.98,25.42 26.8,25.24 24.67,25.24 23.41,26.5 23.41,28.99 17.63,34.77 17.05,34.77 15.04,36.77 15.04,39.52 16.67,41.15 21.36,41.15 25.96,36.54 37.54,36.54 38.39,37.4 57.31,37.4 59.7,35.01 59.7,34.25
+5V_ALW on IN4: 337.93,52.54 346.97,52.54 347.94,51.57 347.94,49.51 346.8,48.37 341.29,48.37 337.26,44.34 337.26,34.99 336.83,34.56 333.3,34.56 333.1,34.77 333.1,36.44 333.56,36.9 333.56,39.34 334.03,39.81 334.03,48.64
+5V_HDD on TOP (solid shape): 33.25,22.42 33.25,19.88 33.84,19.3 33.84,18.08 33.76,18 32.19,18 31.47,18.71 31.47,22.4 31.63,22.55 33.13,22.55
+5V_HDD on BOTTOM: 32.02,18.33 31.92,18.44 31.92,20.53 32.16,20.77 33.12,20.77 33.31,20.58 33.31,20.18 33.19,20.05 33.19,18.37 33.15,18.33
+5V_MXM on TOP (solid shape): 211.8,100.3 211.8,98.86 211.69,98.75 211.2,98.75 211.2,98.75 211.2,98.21 211.19,98.2 210.94,98.2 210.94,98.74 210.93,98.75 210.44,98.75 210.42,98.73 210.42,98.2 210.16,98.2 210.15,98.21 210.15,98.75 210.13,98.78 209.62,98.78 209.41,98.98 209.41,100.12 209.81,100.52 211.58,100.52
+5V_MXM on BOTTOM (solid shape): 212.73,90.04 213.51,90.04 213.64,89.91 213.64,89.59 213.02,88.97 213.02,87.33 212.83,87.14 211.75,87.14 211.5,87.4 211.5,89.81 211.75,90.06 212.7,90.06
+5V_MXM on TOP: 213.65,88.8 213.65,87.29 213.56,87.2 211.48,87.2 211.43,87.2 211.34,87.29 211.34,88.75 211.05,89.04 210.59,89.04 210.41,89.22 210.41,89.62 211.55,90.77 213.4,90.77 213.66,90.51 213.66,88.8
+5V_MXM on IN3: 209.08,94.57 208.89,94.76 208.89,99.97 209.27,100.35 210.1,100.35 210.23,100.48 211.31,100.48 212.13,99.65 212.13,96.67 213.37,95.43 213.37,89.02 213.15,88.79 209.47,88.79 209.08,89.17
+5V_MXM_PWR on TOP (solid shape): 212.04,98.41 212.04,97.61 211.79,97.35 211.05,97.35 210.52,96.82 210.05,96.82 209.69,96.46 209.69,95.59 209.63,95.52 207.65,95.52 207.37,95.8 207.37,97.05 207.96,97.64 208.88,97.64 209.43,98.19 209.43,98.46 209.58,98.61 209.97,98.61 210.01,98.57 210.01,98.09 210.04,98.06 210.55,98.6 210.55,98.61 210.77,98.61 210.81,98.57 210.81,98.07 210.82,98.06 211.32,98.06 211.36,98.1 211.36,98.57 211.41,98.62 211.83,98.62
+5V_RUN on TOP (solid shape): 317.92,24.15 317.92,22.25 317.73,22.05 316.27,22.05 316.03,22.29 316.03,22.52 316.03,22.52 316.03,23.05 315.57,23.52 314.62,23.52 314.37,23.77 314.37,24.85 314.49,24.98 317.1,24.98
+5V_RUN on TOP (solid shape): 35.56,19.22 38.33,19.22 39.7,17.85 39.7,12.03 39.15,11.48 38,11.48 37.67,11.81 37.67,17.09 37.18,17.58 34.22,17.58 33.96,17.84 33.96,18.47 34.54,18.47 34.54,19.04 33.96,19.04 33.96,19.36 34.03,19.43 35.36,19.43
+5V_RUN on TOP (solid shape): 305.71,26.64 305.71,26.15 305.75,26.11 305.79,26.11 306.45,26.11 306.51,26.06 306.81,26.06 307,25.86 307,24.72 306.81,24.53 303.89,24.53 303.38,24.02 300.33,24.02 299.95,24.4 299.95,25.86 300.19,26.11 304.05,26.11 304.06,26.11 304.06,26.16 304.06,26.64 304.08,26.66 304.48,26.66 304.51,26.63 304.51,26.13 304.54,26.11 305.21,26.11 305.25,26.15 305.25,26.65 305.27,26.67 305.68,26.67
+5V_RUN on TOP: 57.13,36.79 58.91,36.79 58.97,36.72 58.97,35.64 58.84,35.52 58.4,35.52 58.21,35.71 55.1,35.71 55.03,35.77 55.03,36.47 55.1,36.53 56.87,36.53
+5V_RUN on TOP: 192.63,119.79 192.49,119.65 190.86,119.65 190.79,119.72 190.79,120.79 191.11,121.11 192,121.11 192.01,121.1 192.4,121.1 192.63,120.87
+5V_RUN on TOP: 282.55,43.67 283.48,43.67 283.65,43.84 283.65,44.36 276.75,51.25 273.61,51.25 273.44,50.98 273.43,50.96 272.55,49.45 272.55,49.02 272.75,48.81 273.21,48.81 273.62,49.23 273.99,49.87 275.73,49.87 279.89,45.71 279.89,44.84 280.24,44.48 281.2,44.48 281.55,44.13 282.1,44.13
+5V_RUN on BOTTOM: 286.4,44.23 282.68,44.23 282.36,43.91 282.36,42.19 282.99,41.57 292.59,41.57 293.22,40.94 293.22,38.88 295.19,36.91 295.19,28.51 295.59,28.1 295.59,25.33 297.4,23.53 301.56,23.53 303.67,25.64 303.67,26.88 302.6,27.95 302.11,27.95 300.44,29.62 300.44,38.95 295.21,44.18 286.45,44.18
+5V_RUN on IN1: 311.66,25.69 312.64,24.71 315.74,24.71 317.21,23.24 317.21,20.87 315.28,18.93 311.14,18.93 306.87,23.2 301.22,23.2 300.14,24.28 300.14,25.17 300.67,25.69
+5V_RUN on IN2: 162.48,12.4 162.48,13.04 161.52,13.99 149.01,13.99 148.63,13.61 148.63,12.28 149.43,11.48 161.55,11.48
+5V_RUN on IN2: 40.09,13.69 43.35,10.43 45.19,10.43 47.1,12.34 53.2,12.34 56.95,16.09 60.38,16.09 60.38,16.08 62.3,16.08 62.95,15.42 62.95,13.93 64.11,12.78 67.54,12.78 68.5,11.82 74.09,11.82 75.61,10.31 75.61,9.55 74.32,8.26 70.07,8.26 68.72,9.61 60.7,9.61 59.86,10.45 58.34,10.45 54.95,7.07 38.9,7.07 36.94,9.04 36.94,13.33 37.3,13.69
+5V_RUN on IN2: 314.55,20.78 314.99,20.34 314.99,13.78 306.76,5.55 281.39,5.55 281.37,5.57 279.88,5.57 274.96,10.48 271.56,10.48 265.48,4.41 243.33,4.41 242.59,3.67 239.47,3.67 238.95,4.19 238.95,5.6 239.84,6.5 241.59,6.5 241.7,6.39 255.56,6.39 255.85,6.1 260.38,6.1 263.18,8.91 263.2,8.91 269.07,14.78 278.59,14.78 284.46,8.91 300.67,8.91 310.49,18.73 310.49,20.29 310.98,20.78
+5V_RUN_PWR on TOP (solid shape): 303.81,29.59 303.81,29.33 303.81,29.33 303.81,28.66 304,28.47 305.08,28.47 305.97,27.58 306.54,27.58 306.79,27.33 306.79,26.31 306.73,26.25 306.22,26.25 305.86,26.25 305.86,26.82 305.15,26.82 305.1,26.77 305.1,26.28 305.09,26.26 304.68,26.26 304.65,26.29 304.65,26.82 303.89,26.82 303.89,26.25 301.98,26.25 301.98,26.25 301.34,26.25 301.28,26.32 301.28,27.44 301.27,27.45 301.27,28.98 301.4,29.1 302.65,29.1 303.15,29.61 303.79,29.61
+5VALWP on BOTTOM (solid shape): 350.49,48.79 351.32,48.79 353.23,46.88 353.23,44.41 352.85,44.03 351.72,44.03 351.72,43.99 351.55,43.83 346.51,43.83 345.91,43.23 339.5,43.23 338.92,43.8 338.92,49.04 339.31,49.42 349.86,49.42
+V0.95SP_B+ on TOP: 330.29,17.99 330.29,16.02 330.54,15.77 331.37,15.77 331.81,15.32 331.81,12.09 332,11.89 334.04,11.89 334.29,12.15 334.29,15.83 333.78,16.34 333.78,16.78 333.21,16.78 333.21,18.18 333.78,18.18 333.78,18.5 333.59,18.69 332.64,18.69 332,18.05 330.35,18.05
+VCC_CORE on BOTTOM (solid shape): outline of 3578 points within 179.3,39.9 228.71,67.27
+VCC_CORE on IN4 (solid shape): outline of 3841 points within 185.09,39.9 229.47,67.27
+VCC_CORE on TOP: outline of 121 points within 191.49,39.9 228.83,67.27
+VCC_CORE on TOP: 179.3,59.71 179.81,59.71 181.08,58.44 181.08,47.39 180.7,47.01 179.43,47.01 179.18,47.26 179.18,59.58
+VCC_CORE on IN1: 199.42,56.28 205.89,56.28 212.12,62.5 217.7,62.5 222.47,67.27 227.48,67.27 228.69,66.06 228.69,40.79 227.8,39.9 222.34,39.9 218.26,43.98 209.56,43.98 208.78,44.76 204.53,44.76 204.53,44.77 203.56,44.77 202.63,45.7 199.39,45.7 198.79,46.3 186.17,46.3 184.32,48.15 184.32,55.65 184.95,56.28 197.26,56.28 197.45,56.09 197.76,56.09 197.95,56.28 198.91,56.28 199.03,56.41 199.29,56.41
+VCC_CORE on VCC: 223.08,41.99 220.92,44.15 203.27,44.15 202.22,45.22 201.63,45.8 199.46,45.8 198.82,46.44 186.91,46.44 180.81,46.44 179.56,46.44 179.56,57.59 178.92,58.23 178.92,58.91 179.22,59.2 180.09,59.2 181.23,58.06 185.61,58.06 186.34,57.31 187.82,55.84 198.19,55.84 198.82,56.47 199.12,56.47 199.5,56.09 205.81,56.09 212.16,62.44 215.46,62.44 221.96,68.94 221.96,69.68 225.03,69.68 228.69,66.02 228.69,42.35 228.33,41.99
+VCC_EDRAM on TOP (solid shape): 84.69,10.43 84.69,9.16 85.48,8.38 85.48,7.54 85.73,7.28 85.73,6.52 85.45,6.24 82.47,6.24 82.02,6.69 82.02,9.18 82.04,9.18 82.04,9.65 82.59,9.65 82.59,10.21 82.04,10.21 82.04,10.45 82.59,10.45 82.59,11.01 82.04,11.01 82.04,11.4 82.15,11.51 83.61,11.51
+VCC_EDRAM on BOTTOM: 183.18,29.5 185.7,29.5 186.67,28.52 187.41,28.52 188.75,27.19 188.75,26.24 188.73,26.24 188.73,24 188.37,23.64 188.37,18.43 188.35,18.41 188.35,17.67 187.01,16.34 187.01,14.63 186,13.61 186,12.24 185.58,11.82 181.38,11.82 180.32,12.88 180.32,13.36 178.6,15.07 178.6,20.53 178.62,20.53 178.62,22.38 182.03,25.8 182.03,28.36 ; 1 cut-out
+VCC_EDRAM on IN1: 186.54,6.94 186.03,7.45 186.03,8.91 185.02,9.93 185.02,17.04 182.41,19.64 181.53,19.64 179.56,21.61 179.56,27.39 180.06,27.9 185.72,27.9 185.91,27.71 185.91,24.85 187.11,23.64 187.81,23.64 190.1,21.36 190.1,11.58 190.67,11.01 190.67,7.2 190.42,6.94
+VCC_EDRAM on IN2: 82.89,4.91 82.45,5.35 82.45,7.69 83.48,8.72 92.99,8.72 95.72,5.99 182.97,5.99 184.8,7.82 189.82,7.82 189.99,7.66 189.99,7.58 190.48,7.58 190.67,7.39 190.67,5.42 188.64,3.39 91.4,3.39 89.88,4.91
+VCC_EDRAM_ED2 on TOP: 191.05,29.17 189.9,29.17 189.72,28.98 189.72,28.8 189.39,28.48 189.39,27.84 189.24,27.69 188.24,27.69 187.96,27.97 187.96,29.92 187.5,30.37 186.94,30.37 186.78,30.21 186.78,29.76 187.11,29.43 187.11,28.13 187.08,28.1 187.08,27.54 187.3,27.33 187.4,27.33 187.4,26.73 187.84,26.28 188.78,26.28 189.23,26.73 191.53,26.73 191.87,27.07 191.87,28.34
+VCC_EDRAM_P on TOP (solid shape): 83.61,13.29 83.61,12.09 83.16,11.64 82.02,11.64 81.83,11.45 81.83,7.64 81.45,7.26 78.81,7.26 78.46,7.61 78.46,12.78 79.23,13.55 83.35,13.55
+VCC_EOPIO on TOP (solid shape): 66.74,9.25 66.74,7.22 66.53,7.01 64.11,7.01 63.99,7.13 63.99,7.63 64.52,7.63 64.52,8.13 63.99,8.13 63.99,8.43 64.52,8.43 64.52,8.93 63.99,8.93 63.99,9.25 64.11,9.38 66.61,9.38
+VCC_EOPIO on BOTTOM (solid shape): 184.78,9.68 184.78,8.98 184.59,8.8 182.13,8.8 181.95,8.98 181.95,9.33 182.46,9.84 184.62,9.84
+VCC_EOPIO on IN1 (solid shape): outline of 312 points within 179.05,8.67 185.21,20.66
+VCC_EOPIO on TOP: 181.21,25.55 181.59,25.55 181.84,25.29 181.84,23.07 181.21,22.44 181.21,17.55 180.38,16.72 180.38,13.8 179.68,13.1 178.67,13.1 178.29,13.48 178.29,17.23 178.67,17.61 178.67,21.17 180.45,22.94 180.45,23.96 181.02,24.53 181.02,25.36
+VCC_EOPIO on IN2: 67.23,4.72 64.81,7.13 64.81,9.1 65,9.29 68.43,9.29 69.89,7.83 76.05,7.83 79.72,11.5 88.26,11.5 88.3,11.54 93.39,11.54 93.4,11.54 148.41,11.54 148.89,11.07 161.21,11.07 162.81,9.47 184.79,9.47 185.14,9.12 185.14,8.61 182.84,6.31 173.19,6.31 173.13,6.37 95.89,6.37 93.45,8.81 83.35,8.81 79.26,4.72
+VCC_EOPIO_P on TOP (solid shape): 64.49,11.07 64.49,10.28 63.76,9.55 63.76,7.26 63.64,7.13 61.45,7.13 61.32,7.26 61.32,10.05 60.81,10.56 60.81,11.1 60.88,11.16 64.4,11.16
+VCC_GT on TOP (solid shape): outline of 3508 points within 191.42,4.66 222.74,44.72
+VCC_GT on BOTTOM (solid shape): outline of 178 points within 178.86,38.47 181.13,43.39
+VCC_GT on BOTTOM (solid shape): outline of 913 points within 178.67,30.92 186.82,43.39
+VCC_GT on BOTTOM (solid shape): outline of 3420 points within 186.51,8.4 223.12,44.66
+VCC_GT on IN4 (solid shape): outline of 3149 points within 185.87,9.74 223.12,43.29
+VCC_GT on TOP: 179.43,43.07 180.83,43.07 181.08,42.82 181.08,30.63 180.83,30.37 179.43,30.37 179.18,30.63 179.18,42.82
+VCC_GT on IN1: 197.73,42.93 197.78,42.98 197.78,42.98 197.92,43.12 198.53,43.12 198.61,43.2 203.36,43.2 203.36,42.81 204.14,42.81 204.14,43.32 205.68,41.77 205.69,41.77 205.74,41.72 205.75,41.72 207.18,40.28 214.84,40.28 216.83,38.29 221.15,38.29 222.72,36.72 222.72,11.41 221.88,10.57 210.79,10.57 207.31,14.05 207.31,22.83 197.73,32.41
+VCC_GT on VCC: 208.62,8.97 208.62,17.97 196.79,29.8 185.11,29.8 180,29.8 179.56,30.25 179.56,45.93 182.35,45.93 186.91,45.93 198.61,45.93 199.25,45.3 201.42,45.3 201.86,44.86 203.06,43.64 220.71,43.64 222.72,41.63 222.72,8.97
+VCC_GT on IN3: 179.56,41.93 180.45,41.93 181.27,41.1 181.27,32.02 180.95,31.71 179.68,31.71 179.3,32.09 179.3,41.68
+VCC_GTU on TOP (solid shape): 257.47,18.75 257.47,15.7 257.19,15.43 251.74,15.43 251.16,14.84 250.8,14.84 250.52,15.12 250.52,18.7 250.82,19.01 255.19,19.01 255.34,18.85 255.34,16.56 255.38,16.53 256.2,16.53 256.2,18.82 256.39,19.01 257.22,19.01
+VCC_GTU on TOP: 205.02,13.61 202.16,13.61 201.15,14.63 200,14.63 199.88,14.5 199.88,10.18 200,10.05 200,8.78 199.47,8.25 199.47,5.02 199.97,4.53 204.13,4.53 204.51,4.91 204.51,7.32 206.86,9.67 206.86,12.72 206.19,13.39 205.24,13.39
+VCC_GTU on TOP: 179.43,46.25 180.83,46.25 181.08,45.99 181.08,43.58 180.83,43.33 179.3,43.33 179.05,43.58 179.05,45.87
+VCC_GTU on TOP: 191.61,46.26 191.97,46.63 193.72,46.63 193.97,46.38 194.16,46.38 194.29,46.5 195.78,46.5 196.11,46.17 196.96,46.18 197.21,45.92 197.21,45.17 196.77,44.72 194.73,44.72 194.42,44.41 193.91,44.41 193.59,44.72 193.34,44.72 193.02,44.41 191.92,44.41 191.61,44.72
+VCC_GTU on BOTTOM: 198.92,22.14 198.06,23 191.71,23 190.64,21.92 190.64,18.69 190.97,18.35 194.18,18.35 194.54,17.99 194.54,16.91 194.67,16.78 195.24,16.78 195.5,16.53 195.5,13.23 195.69,13.04 195.69,10.82 198.67,7.83 206.73,7.83 207.75,8.85 207.75,12.59 207.05,13.29 202.42,13.29 198.92,16.78
+VCC_GTU on BOTTOM: 190.18,46.99 191.93,47 193.31,47 193.97,46.34 196.04,46.34 196.36,46.14 196.65,46.21 196.89,46.08 197.16,45.63 197.16,45.39 196.72,44.94 193.24,44.94 192.96,44.66 192.74,44.66 191.9,43.82 180.2,43.89 180.09,45.53 180.09,46.52 180.7,47.14 187.91,47.14 187.99,47.05 190.12,47.05
+VCC_GTU on IN1: 191.11,7.09 191.11,15.77 190.57,16.31 190.57,21.58 188.26,23.9 187.18,23.9 186.1,24.98 186.1,27.7 185.39,28.41 185.39,35.39 185.39,35.55 185.39,36.35 185.39,43.18 184.93,43.64 184.93,45.03 184.9,45.03 184.9,45.37 185.32,45.82 185.34,45.83 185.44,45.91 185.51,46.02 185.51,46.03 185.6,46.13 195.09,46.18 195.24,46.18 195.3,46.14 195.33,46.07 195.63,45.71 196.03,45.96 196.04,46.02 196.04,46.07 196.06,46.14 196.11,46.18 196.68,46.18 196.88,46.13 197.21,45.8 197.21,43.96 196.83,43.58 196.83,32.66 205.08,24.41 205.08,13.74 208.65,10.17 221.72,10.17 221.72,10.12 222.04,10.43 230.36,10.43 230.61,10.69 233.66,10.69 234.36,9.99 242.29,9.99 243.69,11.39 243.69,15.7 246.94,18.96 252.78,18.96 253.25,18.49 253.25,15.97 253.23,15.95 253.23,15.46 252.58,14.82 251.12,14.82 250.55,15.39 248.96,15.39 248.39,14.82 248.39,10.5 244.83,6.93 191.27,6.93
+VCC_GTU on VCC: 178.77,8.97 178.48,9.27 178.48,10.58 180.94,13.06 180.94,26.12 180.95,27.07 180.95,29.29 182.16,29.29 182.18,29.27 182.2,29.29 196.58,29.29 208.11,17.76 208.11,8.97
+VCC_GTU on IN2: 197.34,22.5 195.94,21.1 189.4,21.1 189.08,21.42 189.08,25.67 187.49,27.26 181.4,27.26 180.19,28.47 180.19,34.39 180.4,34.6 180.4,35.87 180.19,36.08 180.19,46.88 181.08,47.77 196.45,47.77 197.34,46.88
+VCC_GTU on IN2: 252.72,19.16 250.24,19.16 241.42,10.35 218.35,10.35 214.72,13.98 203.69,13.98 203.08,13.37 203.08,7.86 203.26,7.68 220.52,7.68 221.26,6.94 228.08,6.94 228.74,7.6 253.83,7.6 254.19,7.96 254.19,14.51 253.43,15.27 253.43,16.82 253.23,17.03 252.79,17.03 252.77,17.05 252.77,19.11
+VCC_GTU on IN3: 205.85,21.6 214.34,21.6 217.93,18.01 217.97,18.05 229.76,18.05 230,17.81 243.73,17.81 245.02,19.11 252.72,19.11 252.72,17.12 252.85,17 253.24,17 253.57,16.67 253.57,13.49 251.02,10.93 244.77,10.93 244.75,10.91 242.13,10.91 239.61,8.4 207.63,8.4 207.62,8.4 204.77,8.4 203.56,9.61 203.56,19.31
+VCC_GTU on IN4: 185.95,46.12 196.84,46.18 196.96,46.06 196.96,44.35 195.62,43.02 185.95,43.07
+VCC_IO on TOP (solid shape): 317.59,19.13 317.59,18.63 317.02,18.63 317.02,17.91 317.09,17.84 317.59,17.84 317.6,17.83 317.6,17.39 317.59,17.38 317.14,17.38 317.14,17.38 317.04,17.38 317.02,17.36 317.02,17.31 317.02,17.3 317.02,16.59 317.59,16.59 317.59,16.02 317.4,15.83 315.68,15.83 315.37,16.15 315.37,19.13 315.68,19.45 317.27,19.45
+VCC_IO on BOTTOM: 191.16,64.98 192.06,65.88 192.82,65.88 193.71,66.76 193.71,67.5 194.03,67.82 194.03,68.79 194.73,69.49 194.73,70.25 195.16,70.68 195.16,74.19 195.27,74.3 195.96,74.3 196.45,73.81 197.84,73.81 198.1,73.55 198.1,73.35 198.55,72.9 198.55,69.3 201.54,66.31 202.61,66.31 202.99,65.93 202.99,64.85 201.62,63.48 197.21,63.48 196.84,62.97 196.81,62.98 196.49,62.83 196.45,62.48 196.46,62.45 196.29,62.21 196.13,62.06 195.75,61.93 195.74,61.52 195.76,61.49 195.57,61.22 195.53,61.24 195.08,61.14 195.12,60.67 195.15,60.64 194.96,60.39 194.92,60.41 194.55,60.42 194.41,60.07 194.39,59.99 194.31,59.95 194.08,59.95 193.81,59.68 192.3,59.68 191.32,58.7 190.71,58.7 190.1,58.69 190.04,58.71 190,58.77 189.94,58.82 189.56,58.82 189.54,58.73 189.46,58.69 187.43,58.67 186.63,58.67 186.63,58.66 184.27,58.65 184.19,58.69 184.18,58.79 183.88,59.26 183.58,58.79 183.57,58.69 183.49,58.64 181.45,58.62 180.75,58.62 179.79,59.58 179.79,64.19 180.58,64.98
+VCC_IO on IN1: 190.13,60.06 191.3,58.88 191.3,57.55 190.73,56.97 181.59,56.97 181.14,57.42 181.14,59.33 181.87,60.06
+VCC_IO on VCC: 197.55,61.93 196.03,60.41 192.28,60.41 190.67,58.8 190.67,56.34 188.03,56.34 186.71,57.67 185.82,58.57 181.44,58.57 180.3,59.71 179.01,59.71 178.56,59.27 176.74,59.27 171.11,64.9 171.11,66.04 166.03,71.12 166.03,79.4 240.71,79.4 240.74,79.35 240.76,79.35 245.72,74.34 245.72,61.51 248.9,58.33 248.9,56.54 248.88,27.41 253.48,22.82 317.08,22.82 317.08,16.57 314.05,13.55 299.11,13.55 297.77,14.88 292.74,14.88 291.4,13.55 281.25,13.55 278.39,16.42 278.17,16.53 260.73,16.53 258.83,14.63 250.02,14.63 248.12,16.53 240.96,16.53 240.96,64.96 239.54,66.38 229.05,66.38 225.24,70.19 212.58,70.19 205.67,63.26 204.34,61.93 ; 2 cut-outs
+VCC_IO on IN3: 186.16,59.5 181.33,59.5 181.19,59.36 181.19,59.27 178.86,56.93 178.86,45.99 179.18,45.68 180.19,45.68 180.45,45.93 180.45,54.52 182.86,56.93 189.86,56.93 190.73,57.81 190.73,58.82 190.48,59.08 186.54,59.08 186.16,59.46
+VCC_IOP on TOP (solid shape): 322.61,20.8 322.61,13.76 322.46,13.61 315.68,13.61 315.56,13.73 315.56,15.32 315.87,15.64 317.59,15.64 317.78,15.83 317.78,16.75 317.75,16.78 317.22,16.78 317.2,16.8 317.2,17.23 317.21,17.25 317.42,17.25 317.43,17.24 317.7,17.24 317.74,17.27 317.74,17.95 317.69,18 317.21,18 317.19,18.02 317.19,18.41 317.21,18.44 317.69,18.44 317.73,18.48 317.73,20.49 318.52,21.28 322.13,21.28
+VCC_SA on BOTTOM (solid shape): outline of 438 points within 191.43,56.28 224.45,74.5
+VCC_SA on TOP: 198.45,58.95 199.62,58.95 200.77,60.09 201.59,60.09 205.83,64.33 207.3,64.33 209.62,66.65 212.81,69.84 220.56,69.84 221.5,68.9 221.5,68.65 216.43,63.58 212.88,63.58 205.82,56.53 203.09,56.53 202.97,56.41 199.41,56.41 199.36,56.46 199.36,56.8 198.92,57.23 197.02,57.23 196.96,57.17 191.69,57.17 191.62,57.23 191.62,58.44 192.45,59.27 192.45,59.58 192.64,59.77 192.89,59.77 193.27,59.39 196.5,59.39 196.65,59.25 196.65,58.7 197.08,58.27 197.09,58.27 197.14,58.22 197.71,58.22
+VCC_SA on IN1: 197.7,56.28 197.51,56.28 197.38,56.41 192.13,56.41 191.56,56.98 191.56,57.87 192.26,58.57 193.78,58.57 194.03,58.82 198.1,58.82 198.9,59.62 204.6,59.62 208.75,63.78 208.75,65.78 212.81,69.84 220.56,69.84 221.5,68.9 221.5,68.65 216.43,63.58 215.48,63.58 214.69,62.79 212.08,62.79 205.7,56.41 199.54,56.41 199.35,56.6 198.97,56.6 198.78,56.41 197.83,56.41
+VCC_SA on VCC: 191.18,56.34 191.18,58.59 192.49,59.9 196.24,59.9 197.76,61.42 204.55,61.42 206.03,62.9 212.79,69.68 221.45,69.68 221.45,69.15 215.25,62.95 211.95,62.95 205.6,56.6 199.71,56.6 199.33,56.98 198.61,56.98 197.98,56.34
+VCC_SA on IN2: 197.7,56.28 197.51,56.28 197.49,56.3 192.23,56.3 191.62,56.92 191.62,57.65 192.49,58.51 193.34,58.51 194.23,59.39 196.68,59.39 198.07,60.78 202.09,60.78 206.99,65.68 208.65,65.68 212.81,69.84 220.56,69.84 221.16,69.24 221.16,68.31 216.43,63.58 215.48,63.58 214.69,62.79 212.08,62.79 205.7,56.41 199.54,56.41 199.35,56.6 198.97,56.6 198.78,56.41 197.83,56.41
+VCC_SFR_OC on TOP: 90.02,19.48 90.02,19.9 90.22,20.1 91.62,20.1 92.05,19.66 92.05,17.56 91.92,17.42 91.55,17.42 91.22,17.75 91.16,17.75 91.15,17.75 90.73,17.75 90.2,18.28 90.2,19.3
+VCC_SFR_OC on BOTTOM: 179.54,30.14 169.73,30.14 166.73,27.13 164.13,27.13 163.94,26.94 163.94,24.47 164.76,23.64 168.06,23.64 169.08,24.66 170.22,24.66 171.3,25.74 174.67,25.74 175.18,26.25 177.41,26.25 178.24,27.07 178.24,27.92 179.64,29.32 179.64,30.04
+VCC_SFR_OC on IN1: 180.42,46.82 181.84,45.39 181.84,29.67 181.02,28.85 178.29,28.85 177.52,29.61 177.52,36.72 176.06,36.72 175.37,37.42 175.37,47.71 174.79,48.28 174.79,60.15 175.43,60.79 178.92,60.79 179.49,60.22 179.49,49.74 180.42,48.82
+VCCAUSB_VCCAAZPLL_1P0 on BOTTOM: 139.05,118.79 135.72,118.79 135.67,118.74 135.67,118.13 135.36,117.82 135.36,116.67 135.49,116.55 137.71,116.55 138.81,117.64 138.86,117.64 138.87,117.64 139.12,117.64 139.23,117.75 139.23,118.62
AGND on TOP (solid shape): 259.31,47.39 259.31,42.95 259.19,42.82 254.74,42.82 254.61,42.95 254.61,47.39 254.74,47.52 259.19,47.52
AGND on BOTTOM (solid shape): 259.23,48.41 259.23,47.33 259.8,46.76 259.8,42.76 259.17,42.12 255.8,42.12 255.42,41.74 254.98,41.74 254.91,41.8 254.91,47.71 255.49,48.28 258.22,48.28 258.41,48.47 259.17,48.47
GND on TOP (solid shape): 21.06,62.95 21.06,61.93 20.68,61.55 18.58,61.55 18.27,61.87 18.27,62.89 18.46,63.08 20.93,63.08
GND on TOP (solid shape): 60.6,18.05 60.6,16.72 60.41,16.53 58.38,16.53 58.25,16.66 58.25,18.18 58.38,18.31 60.35,18.31
GND on TOP (solid shape): 148.51,136.81 148.51,135.94 147.03,134.47 144.87,134.47 144.63,134.7 144.63,137.36 144.83,137.56 147.76,137.56
GND on TOP (solid shape): 322.54,13.16 322.54,11.96 322.35,11.77 315.75,11.77 315.56,11.96 315.56,13.1 315.81,13.36 322.35,13.36
GND on TOP (solid shape): 335.77,55.71 335.77,51.65 335.7,51.58 331.7,51.58 331.64,51.65 331.64,55.71 331.7,55.77 335.7,55.77
GND on TOP (solid shape): 350.1,11.26 350.1,7.96 349.97,7.83 346.93,7.83 346.67,8.08 346.67,11.13 347.05,11.51 349.85,11.51
GND on TOP (solid shape): 354.62,36.1 354.62,34.07 354.44,33.89 353.71,33.89 353.58,34.02 353.58,36.1 353.73,36.25 354.47,36.25
GND on TOP (solid shape): 19.89,6.3 19.89,3.71 19.71,3.53 17.11,3.53 16.92,3.72 16.92,6.68 17,6.77 19.43,6.77
GND on TOP (solid shape): 105.1,16.59 105.1,13.1 104.78,12.78 100.53,12.78 100.34,12.97 100.34,16.59 100.91,17.17 104.53,17.17
GND on TOP (solid shape): 110.2,7.2 110.2,4.66 109.88,4.34 107.72,4.34 106.39,5.67 106.39,7.13 106.71,7.45 109.94,7.45
GND on TOP (solid shape): 64.48,25.74 64.48,23.58 64.16,23.26 61.05,23.26 60.86,23.45 60.86,25.48 61.3,25.93 64.29,25.93
GND on TOP (solid shape): 203.81,98.64 205.45,98.64 205.6,98.48 205.6,97.62 205.46,97.48 203.34,97.48 202.95,97.87 202.95,98.75 203.06,98.86 203.59,98.86
GND on TOP (solid shape): 213.12,8.44 213.12,5.39 212.07,4.34 205.72,4.34 205.34,4.72 205.34,7.92 206,8.58 212.98,8.58
GND on TOP (solid shape): 215.61,52.66 215.61,52.41 215.35,52.15 212.43,52.15 212.18,52.41 212.18,52.66 212.43,52.92 215.35,52.92
GND on TOP (solid shape): 215.61,50.06 215.61,49.8 215.35,49.55 212.43,49.55 212.18,49.8 212.18,50.06 212.43,50.31 215.35,50.31
GND on TOP (solid shape): 215.61,47.45 215.61,47.2 215.35,46.95 212.43,46.95 212.18,47.2 212.18,47.45 212.43,47.71 215.35,47.71
GND on TOP (solid shape): 215.61,44.85 215.61,44.6 215.35,44.34 212.43,44.34 212.18,44.6 212.18,44.85 212.43,45.11 215.35,45.11
GND on TOP (solid shape): 223.03,76.38 223.03,74.5 222.63,74.1 220.77,74.1 220.3,74.57 220.3,76.34 220.49,76.53 222.87,76.53
GND on TOP (solid shape): 228.58,7.97 228.58,4.91 228.24,4.57 223.45,4.57 223.22,4.8 223.22,7.89 223.65,8.33 228.22,8.33
GND on TOP (solid shape): 158.98,54.62 158.98,49.88 158.94,49.84 154.06,49.84 152.96,50.94 152.96,54.86 153.25,55.16 158.44,55.16
GND on TOP (solid shape): 249.87,55.75 249.87,54.85 249.52,54.49 249.52,53.36 249.33,53.17 247.99,53.17 247.74,53.42 247.74,56.41 247.93,56.6 249.03,56.6
GND on TOP (solid shape): 253.53,33.1 253.53,31.92 253.26,31.64 250.34,31.64 250.15,31.83 250.15,33.1 250.34,33.29 253.34,33.29
GND on TOP (solid shape): 256.65,28.15 256.65,27.01 256.52,26.88 256.01,26.88 255.88,26.75 255.88,26.37 255.76,26.25 255.12,26.25 255.12,28.15 255.25,28.28 256.52,28.28
GND on TOP (solid shape): 258.87,29.74 258.87,26.31 258.74,26.18 257.22,26.18 257.15,26.25 257.15,26.5 256.84,26.82 256.84,29.74 256.96,29.87 258.74,29.87
GND on TOP (solid shape): 261.26,34.46 261.26,34 261.18,33.92 261.18,33.33 261.08,33.23 260.21,33.23 260.12,33.32 260.12,34.38 260.27,34.53 261.19,34.53
GND on TOP (solid shape): 93.94,7.2 93.94,4.66 93.62,4.34 90.85,4.34 90.27,4.92 89.69,4.92 89.23,5.38 89.23,7.21 89.48,7.45 93.69,7.45
GND on TOP (solid shape): 176.34,11.56 176.34,10.66 176.24,10.56 172.79,10.56 172.7,10.65 172.7,11.22 172.8,11.32 174.57,11.32 175.06,11.82 176.09,11.82
GND on TOP (solid shape): 241.77,82.25 241.77,78.89 241.71,78.82 240.94,78.82 240.88,78.89 240.88,82.25 241.01,82.38 241.64,82.38
GND on TOP (solid shape): 241.83,48.66 241.83,40.09 241.45,39.71 237.01,39.71 236.82,39.9 236.82,46.5 238,47.68 240.53,47.68 240.74,47.9 240.74,48.79 240.86,48.92 241.58,48.92
GND on TOP (solid shape): 85.07,15.32 85.07,14.34 84.81,14.09 79.7,14.09 79.61,14.18 79.61,14.37 79.1,14.88 77.7,14.88 77.58,15.01 77.58,15.51 77.64,15.58 84.81,15.58
GND on TOP (solid shape): 248.18,50.52 248.18,43.96 248.06,43.84 246.72,43.84 246.53,44.03 246.53,48.72 247.12,49.31 247.12,50.57 247.18,50.63 248.07,50.63
GND on TOP (solid shape): 222.03,68.4 222.03,68.15 222.53,67.65 222.53,67.52 217.64,62.63 212.94,62.63 212.88,62.69 212.88,63.33 213,63.46 216.5,63.46 221.58,68.54 221.89,68.54
GND on TOP (solid shape): 59.14,31.26 59.14,28.58 58.78,28.21 57.13,28.21 56.62,27.71 55.16,27.71 55.1,27.77 55.1,30.44 55.16,30.5 57.12,30.5 58.08,31.45 58.95,31.45
GND on TOP (solid shape): 266.17,27.95 266.17,27.74 266.64,27.27 266.64,24.7 266.4,24.45 265.16,24.45 265.02,24.59 265.02,26.24 265.09,26.31 265.28,26.31 265.54,26.56 265.54,27.95 265.6,28.01 266.11,28.01
GND on TOP (solid shape): 253.98,28.28 254.85,28.28 254.85,26.26 254.65,26.06 254.28,26.06 253.53,25.3 253.53,24.84 253.33,24.64 250.23,24.64 250.19,24.68 248.75,24.68 248.14,25.29 248.14,28.02 248.26,28.15 250.4,28.15 250.41,28.15 253.84,28.15 253.97,28.28
GND on TOP (solid shape): 62.72,13.8 62.72,13.42 62.91,13.23 64.37,13.23 64.49,13.1 64.49,11.39 64.43,11.32 60.88,11.32 60.81,11.39 60.81,12.66 61,12.85 61.76,12.85 62.02,13.1 62.02,13.86 62.08,13.93 62.59,13.93
GND on TOP (solid shape): 262.09,22.81 262.09,22.15 261.55,21.61 261.08,21.61 260.64,21.17 258.93,21.17 258.79,21.31 258.79,22.37 258.85,22.44 260.39,22.44 260.58,22.63 260.58,22.82 260.63,22.87 262.04,22.87
GND on TOP (solid shape): 240.38,67.26 240.82,66.82 240.82,64.79 241.22,64.39 241.22,64.38 241.42,64.18 241.42,60.24 241.21,60.03 237.13,60.03 236.82,60.35 236.82,67.41 237.21,67.81 239.83,67.81
GND on TOP (solid shape): 246.36,35.15 246.74,35.15 247.34,34.55 247.34,33.72 246.91,33.29 246.91,15.96 245.96,15.01 245.96,9.1 245.64,8.78 243.55,8.78 243.36,8.97 243.36,16.09 242.79,16.66 242.79,33.93 244.02,35.17 246.34,35.17
GND on TOP (solid shape): 330.03,18.37 330.03,15.96 330.42,15.58 331.11,15.58 331.62,15.07 331.62,12.15 331.5,12.02 329.34,12.02 328.76,12.59 328.76,13.73 328.48,14.02 327.59,14.02 327.49,14.11 327.49,15.9 328.13,16.53 329.46,16.53 329.46,18.37 329.53,18.44 329.97,18.44
GND on TOP (solid shape): 118.22,145.12 118.22,144.36 117.75,143.89 117.58,142.9 117.52,142.7 116.37,142.9 116.31,143.02 116.5,144.17 116.63,144.23 117.01,144.23 117.26,144.48 117.26,144.8 117.09,144.97 116.42,144.97 116.34,145.05 116.34,145.28 116.81,145.75 117.58,145.75
GND on TOP (solid shape): 73.38,8.78 73.38,8.53 73.51,8.4 73.77,8.4 73.89,8.28 73.89,8.02 73.77,7.89 72.5,7.89 72.37,7.77 72.37,6.5 72.22,6.35 68.33,6.35 68.3,6.37 67.49,6.37 66.95,6.91 66.95,8.4 67.21,8.66 72.11,8.66 72.37,8.91 73.26,8.91
GND on TOP (solid shape): 343.76,28.52 344.77,27.52 344.77,24.85 344.64,24.72 343.12,24.72 342.99,24.85 342.99,26.25 342.73,26.5 342.57,26.5 342.57,26.5 341.6,26.5 341.6,26.5 341.49,26.5 341.49,26.5 341.42,26.5 341.3,26.38 341.3,25.85 341.23,25.77 340.56,25.77 340.45,25.89 340.45,28.7 340.91,29.17 343.12,29.17
GND on TOP (solid shape): 232.98,37.61 232.98,36.78 233.19,36.57 234.7,36.57 234.81,36.47 234.81,30.5 235.51,29.8 235.51,28.53 235.45,28.47 231.76,28.47 231.51,28.72 231.51,30.63 232.18,31.3 232.18,34.57 232.87,34.57 232.87,35.41 232.18,35.41 232.18,36.46 232.29,36.57 232.55,36.57 232.56,36.58 232.71,36.58 232.78,36.65 232.78,37.65 232.8,37.67 232.93,37.67
GND on TOP (solid shape): 241.83,58.88 241.83,50.25 241.45,49.87 238.09,49.87 237.96,49.99 237.01,49.99 236.82,50.19 236.82,57.28 237.27,57.73 239.99,57.73 240.01,57.75 240.45,57.75 240.56,57.86 240.56,59.01 240.63,59.08 241.64,59.08
GND on TOP (solid shape): 290.19,22.85 290.19,17.77 289.97,17.55 289.48,17.55 288.27,16.34 287.06,16.34 287,16.4 287,16.91 287.06,16.97 288.01,16.97 288.51,17.47 288.51,18.12 288.19,18.44 287.62,18.44 287.49,18.56 287.49,19.2 287.24,19.45 286.47,19.45 286.16,19.77 286.16,21.72 286.3,21.86 287.3,21.86 288.44,23.01 290.03,23.01
GND on TOP (solid shape): 233.01,27.41 233.01,26.48 233.1,26.39 234.74,26.39 234.79,26.34 234.79,25.78 234.78,25.77 234.78,20.8 235.19,20.39 235.19,20.02 235.19,20.02 235.19,18.56 235.01,18.38 234.33,18.38 234.32,18.38 234.01,18.38 233.94,18.31 231.81,18.31 231.56,18.56 231.56,20.47 232.22,21.13 232.22,24.39 232.89,24.39 232.89,25.23 232.22,25.23 232.22,26.32 232.3,26.39 232.69,26.39 232.81,26.52 232.81,27.43 232.86,27.48 232.94,27.48
GND on TOP (solid shape): 233.01,16.89 233.01,15.95 233.11,15.85 234.67,15.85 234.73,15.79 234.73,10.05 235.22,9.57 235.22,7.84 234.74,7.36 231.73,7.36 231.53,7.56 231.53,9 231,9.53 231,10.21 231.1,10.32 231.64,10.32 232.12,10.79 232.12,13.85 232.89,13.85 232.89,14.69 232.32,14.69 232.23,14.78 232.23,15.75 232.32,15.85 232.65,15.85 232.75,15.95 232.75,16.86 232.83,16.94 232.96,16.94
GND on TOP (solid shape): 53.57,8.72 53.57,8.03 53.66,7.94 54.44,7.94 54.59,8.09 54.59,8.21 55.1,8.72 56.05,8.72 56.18,8.59 56.18,8.34 56.3,8.21 56.75,8.21 56.81,8.15 56.81,7.96 56.75,7.89 55.35,7.89 54.84,7.39 54.84,7.39 53.51,6.05 49.81,6.05 49.6,6.27 49.6,7.89 49.76,8.06 50.56,8.06 50.58,8.05 50.98,8.05 51.16,8.22 51.16,8.59 51.35,8.78 53.51,8.78
GND on TOP (solid shape): 351.24,38.56 351.24,37.93 351.5,37.68 351.5,36.15 351.37,36.02 349.59,36.02 349.47,35.9 349.47,35.6 347.74,33.87 346.67,33.87 346.29,33.48 344.5,33.48 344.39,33.37 344.39,32.82 344.33,32.76 343.29,32.76 343.12,32.93 343.12,34.63 343.37,34.88 347.81,34.88 348.15,35.22 348.15,35.69 348.39,35.93 348.39,36.08 348.39,36.09 348.39,38.37 348.7,38.69 351.12,38.69
GND on TOP (solid shape): 16.21,58.94 16.22,58.85 16.25,58.77 16.25,58.72 16.4,58.57 16.47,58.57 16.8,58.58 17.01,58.83 17.06,58.88 17.5,58.88 17.63,58.76 17.63,57.36 18.21,56.78 18.21,56.64 18.11,56.54 17.38,56.54 17.25,56.41 17.25,54.44 17,54.19 16.3,54.19 16.11,54 15.16,54 14.71,53.55 13.89,53.55 13.76,53.68 13.76,54.57 14.58,55.39 16.17,55.39 16.23,55.46 16.23,57.11 15.6,57.74 15.6,58.87 15.68,58.95 16.2,58.95
GND on TOP (solid shape): 351.51,30.3 351.49,30.27 350.77,30.27 350.58,30.27 350.35,30.27 350.27,30.28 350.2,30.27 349.95,30.27 349.91,30.28 349.87,30.28 349.84,30.3 349.82,30.33 349.81,30.4 349.81,30.68 349.82,30.74 349.81,30.8 349.81,31.08 349.82,31.14 349.81,31.2 349.81,31.48 349.82,31.54 349.81,31.6 349.81,31.88 349.82,31.92 349.88,31.97 351.51,31.97
GND on TOP (solid shape): 348.2,64.74 348.4,64.7 348.5,64.67 348.59,64.65 349.23,64.11 349.7,63.42 349.73,63.25 349.74,63.16 349.75,63.02 349.75,60.9 344.96,59.9 345.58,64.74
GND on TOP (solid shape): outline of 136 points within 132.24,127.29 138.2,131.6
GND on TOP (solid shape): outline of 953 points within 210.42,120.73 236.26,143.21
GND on TOP (solid shape): outline of 2850 points within 0.25,0.25 355.75,159.65
GND on BOTTOM (solid shape): 60.68,18.18 60.68,16.59 60.62,16.53 58.97,16.53 58.91,16.59 58.91,18.24 58.97,18.31 60.56,18.31
GND on BOTTOM (solid shape): 105.1,16.59 105.1,13.1 104.78,12.78 100.53,12.78 100.34,12.97 100.34,16.59 100.91,17.17 104.53,17.17
GND on BOTTOM (solid shape): 55.33,31.4 55.33,29.4 55.27,29.34 49.35,29.34 49.05,29.64 49.05,30.59 49.89,31.42 49.89,31.42 49.93,31.47 55.26,31.47
GND on BOTTOM (solid shape): 214.59,52.66 214.59,52.41 214.34,52.15 211.42,52.15 211.16,52.41 211.16,52.66 211.42,52.92 214.34,52.92
GND on BOTTOM (solid shape): 215.61,50.06 215.61,49.8 215.35,49.55 212.43,49.55 212.18,49.8 212.18,50.06 212.43,50.31 215.35,50.31
GND on BOTTOM (solid shape): 215.61,47.45 215.61,47.2 215.35,46.95 212.43,46.95 212.18,47.2 212.18,47.45 212.43,47.71 215.35,47.71
GND on BOTTOM (solid shape): 215.61,44.85 215.61,44.6 215.35,44.34 212.43,44.34 212.18,44.6 212.18,44.85 212.43,45.11 215.35,45.11
GND on BOTTOM (solid shape): 219.97,31.39 219.97,28.52 219.71,28.26 216.69,28.26 216.56,28.4 216.56,31.44 216.75,31.63 219.74,31.63
GND on BOTTOM (solid shape): 248.18,48.72 248.18,43.96 248.06,43.84 246.72,43.84 246.53,44.03 246.53,48.72 246.72,48.92 247.99,48.92
GND on BOTTOM (solid shape): 249.95,55.7 249.95,54.54 249.52,54.11 249.52,53.65 249.03,53.17 247.99,53.17 247.74,53.42 247.74,56.09 248.08,56.43 249.22,56.43
GND on BOTTOM (solid shape): 223.12,56.15 223.12,53.49 222.99,53.36 218.47,53.36 215.16,53.36 214.91,53.61 214.91,56.54 215.16,56.79 222.48,56.79
GND on BOTTOM (solid shape): 235.04,36.22 235.04,29.29 234.66,28.91 231.29,28.91 230.85,29.36 230.85,35.08 232.18,36.41 234.85,36.41
GND on BOTTOM (solid shape): 222.04,68.39 222.04,68.15 222.53,67.67 222.53,67.52 217.64,62.63 215.61,62.63 215.42,62.82 215.42,63.27 215.61,63.46 216.5,63.46 221.58,68.54 221.89,68.54
GND on BOTTOM (solid shape): 235.04,15.32 235.04,8.97 234.66,8.59 231.29,8.59 230.85,9.04 230.85,15.51 231.17,15.83 234.53,15.83
GND on BOTTOM (solid shape): 261.93,48.81 261.93,47.05 261.76,46.88 259.93,46.88 259.42,47.39 259.42,47.65 259.99,47.65 259.99,48.15 259.42,48.15 259.42,48.66 259.68,48.92 261.83,48.92
GND on BOTTOM (solid shape): 353.48,43.53 353.48,38.39 353.34,38.25 351.94,38.25 351.75,38.06 348.83,38.06 348.58,38.31 348.58,40.47 348.83,40.72 349.78,40.72 351.82,42.76 351.82,43.39 352.16,43.73 352.79,43.73 353.28,43.73
GND on BOTTOM (solid shape): 78.19,28.4 78.19,17.27 77.26,16.34 74.72,16.34 74.51,16.55 74.51,22.56 74.89,22.94 75.91,22.94 76.29,23.32 76.29,24.47 75.78,24.98 74.19,24.98 74,25.17 74,28.21 74.45,28.66 77.94,28.66
GND on BOTTOM (solid shape): 61.51,20.78 61.51,20.59 60.35,19.43 60.3,19.39 60.3,18.63 60.24,18.56 60.11,18.56 60.05,18.63 60.05,19.64 60.48,20.07 60.57,20.07 60.57,20.16 60.62,20.21 60.62,20.4 61.19,20.98 61.32,20.98
GND on BOTTOM (solid shape): 230,88.53 230,84.41 229.86,84.27 226.86,84.27 226.28,84.85 226.28,86.78 227.1,87.6 227.67,87.6 227.76,87.59 227.85,87.59 228.13,87.59 228.7,88.17 228.73,88.19 228.73,88.6 228.89,88.76 229.77,88.76
GND on BOTTOM (solid shape): 235.04,25.95 235.04,17.93 234.86,17.75 234.14,17.75 233.68,18.2 233.68,18.2 233.13,18.75 231.29,18.75 230.85,19.2 230.85,25.67 231.17,25.99 232.18,25.99 232.42,26.23 234.75,26.23
GND on BOTTOM (solid shape): 241.94,57.87 241.94,56.04 240.81,54.92 240.81,50.03 240.81,50.03 240.81,49.81 240.74,49.74 239.13,49.74 239,49.61 239,48.7 238.93,48.62 238.84,48.62 238.76,48.71 238.76,49.61 238.67,49.7 238.6,49.7 238.47,49.74 238.34,49.7 238.28,49.7 238.23,49.75 238.23,50.82 238.29,50.89 238.86,50.89 238.86,51.73 238.21,51.73 238.21,54.68 237.83,55.06 237.83,57.28 238.51,57.96 241.84,57.96
GND on BOTTOM (solid shape): 240.61,67.89 240.61,66.02 240.8,65.83 240.8,60.35 240.79,60.35 240.79,60.14 240.69,60.04 240.51,60.04 240.5,60.06 239.09,60.06 239.09,60.04 239,59.95 239,58.98 238.96,58.93 238.79,58.93 238.75,58.97 238.75,59.94 238.64,60.06 238.21,60.06 238.16,60.11 238.16,60.93 238.16,60.93 238.16,61.1 238.22,61.16 238.91,61.16 238.91,61.99 238.81,62.09 238.35,62.09 238.21,62.23 238.21,64.95 237.5,65.65 237.5,68.08 237.74,68.32 240.18,68.32
GND on BOTTOM (solid shape): 241.55,47.33 241.55,46.06 240.82,45.32 240.82,39.42 240.75,39.36 239.2,39.36 239.2,39.36 239.06,39.22 239.06,38.3 238.99,38.22 238.87,38.22 238.8,38.29 238.8,39.23 238.68,39.36 238.32,39.36 238.29,39.38 238.29,40.33 238.38,40.43 238.84,40.43 238.97,40.56 238.97,41.18 238.83,41.33 238.31,41.33 238.27,41.37 238.27,44.52 237.55,45.23 237.55,47.14 237.81,47.39 241.49,47.39
GND on BOTTOM (solid shape): 233.99,79.12 233.99,75.87 234.44,75.43 234.44,69.75 234.33,69.64 234.15,69.64 234.15,69.63 233.61,69.63 233.52,69.54 233.52,69.53 233.44,69.46 233.44,68.59 233.38,68.53 233.27,68.53 233.21,68.58 233.21,68.63 233.19,68.65 233.19,69.36 232.93,69.61 232.68,69.36 232.68,68.62 232.56,68.5 232.48,68.5 232.4,68.58 232.4,69.53 232.3,69.63 231.95,69.63 231.86,69.71 231.86,70.7 231.93,70.76 232.53,70.76 232.53,71.6 231.95,71.6 231.88,71.67 231.88,74.55 231.17,75.27 231.17,79.11 231.56,79.5 233.61,79.5
GND on BOTTOM (solid shape): 47.1,6.88 47.1,4.27 45.92,3.1 41,3.1 39,5.1 41,7.1 46.87,7.1
GND on BOTTOM (solid shape): outline of 428 points within 0.25,0.25 355.75,159.65
GND on IN1 (solid shape): outline of 155 points within 46.22,0.25 355.75,158.65
GND on IN1 (solid shape): outline of 217 points within 0.25,2.35 232.07,159.65
GND on IN2 (solid shape): outline of 153 points within 46.22,0.25 355.75,158.65
GND on IN2 (solid shape): outline of 217 points within 0.25,2.35 232.07,159.65
GND on IN3 (solid shape): outline of 1485 points within 46.22,0.25 355.75,158.65
GND on IN3 (solid shape): outline of 217 points within 0.25,2.35 232.07,159.65
GND on IN4 (solid shape): outline of 154 points within 46.22,0.25 355.75,158.65
GND on IN4 (solid shape): outline of 217 points within 0.25,2.35 232.07,159.65
GND on TOP: 113.87,111.9 113.93,112.01 113.92,112.13 113.91,112.15 113.96,112.21 114.29,112.21 114.48,112.4 114.53,112.4 114.63,112.4 114.68,112.41 114.72,112.42 114.79,112.42 114.83,112.37 114.89,112.26 115,112.2 115.02,112.2 115.07,112.12 115.06,112.1 115.01,111.91 115.07,111.71 115.07,111.65 115.03,111.6 114.95,111.55 114.89,111.48 114.84,111.43 114.77,111.45 114.72,111.49 114.65,111.5 114.55,111.5 114.51,111.5 114.46,111.48 114.35,111.48 114.34,111.5 114.27,111.59 114.16,111.63 114.06,111.63 113.87,111.82
GND on TOP: 268.25,22.18 268.25,20.98 268.44,20.78 271.49,20.78 271.61,20.91 271.61,22.18 271.53,22.26 268.33,22.26
GND on TOP: 92.63,90.55 95.91,90.55 96.12,90.75 96.12,92.81 94.73,94.2 93.33,94.2 92.5,93.37 92.5,90.67
GND on TOP: 132.04,102.49 132.05,102.52 132.12,102.59 132.12,102.64 132.12,102.65 132.15,102.71 132.16,102.77 132.16,102.84 132.31,102.99 132.31,103.43 132.35,103.47 132.38,103.5 132.41,103.54 132.47,103.58 132.53,103.56 132.68,103.48 132.85,103.46 132.87,103.45 132.89,103.43 133.11,103.26 133.34,103.41 133.41,103.41 133.52,103.51 133.8,103.51 133.87,103.45 134.23,103.45 134.28,103.44 134.42,103.44 134.55,103.31 134.55,103.14 134.55,103.08 134.55,102.92 134.7,102.77 134.92,102.77 135.05,102.65 135.05,101.43 135.3,101.18 135.3,100.92 134.15,100.92 133.21,101.86 133.21,102.27 133.21,102.34 133.05,102.52 132.82,102.5 132.79,102.47 132.76,102.44 132.7,102.42 132.64,102.44 132.57,102.5 132.49,102.53 132.33,102.49 132.23,102.36 132.21,102.28 132.11,102.28 132.11,102.32 132.1,102.36 132.09,102.4 132.07,102.43 132.05,102.46
GND on TOP: 113.54,101.99 112.67,101.12 112.34,101.12 112.2,101.26 112.2,101.88 112.21,101.89 112.21,102.59 112.44,102.82 113.37,102.82 113.49,102.95 113.69,102.95 113.82,102.81 113.82,102.67 113.73,102.57 113.73,102.18
GND on TOP: 66.65,31.83 72.31,31.83 72.62,32.15 72.62,32.48 72.37,32.74 70.34,32.74 70.08,32.99 70.08,35.45 70.34,35.71 71.73,35.71 71.92,35.9 71.92,36.53 71.8,36.66 67.48,36.66 67.16,36.34 67.16,35.64 67.48,35.33 68.69,35.33 68.94,35.07 68.94,33.48 68.69,33.23 66.65,33.23 66.46,33.04 66.46,32.02
GND on TOP: 284.84,43.5 285.2,43.5 285.4,43.71 285.4,45.31 284.61,46.1 284.61,47.98 284.92,48.28 292.76,48.28 293.12,47.92 293.12,47.8 292.97,47.65 292.49,47.65 292.26,47.87 290.68,47.87 290.61,47.8 290.61,45 290.98,44.63 297.62,44.63 298.45,45.46 298.45,48.66 298.02,49.09 283.8,49.09 282.93,48.23 282.93,46.04 284.23,44.75 284.43,44.75 284.61,44.57 284.61,43.73
GND on TOP: 230.68,74.94 233.1,74.94 234.14,73.9 234.14,73.9 234.47,73.57 234.47,70.51 234.02,70.07 231.02,70.07 230.49,70.6 230.49,74.75
GND on TOP: 54.97,64.66 51.73,64.66 50.91,63.84 50.91,61.74 51.1,61.55 51.29,61.55 51.41,61.68 53.19,61.68 53.32,61.55 53.32,60.73 53.19,60.6 51.03,60.6 50.91,60.47 50.91,60.22 51.03,60.09 53.06,60.09 53.32,59.84 53.32,59.27 53.89,58.69 54.02,58.69 54.21,58.5 54.21,58.31 54.4,58.12 54.72,58.12 54.91,58.31 54.91,58.44 55.03,58.57 57.19,58.57 57.32,58.69 57.32,58.95 57.19,59.08 55.03,59.08 54.91,59.2 54.91,59.77 55.22,60.09 57.26,60.09 57.38,60.22 57.38,60.47 57.26,60.6 55.03,60.6 54.91,60.73 54.91,61.55 55.03,61.68 56.87,61.68 57.07,61.49 57.32,61.49 57.45,61.62 57.45,62 57.32,62.12 56.43,62.12 55.03,63.52 55.03,64.6
GND on TOP: 54.14,27.71 53.19,28.66 51.3,28.66 51.29,28.67 50.67,28.67 49.55,29.78 49.55,30.51 49.8,30.75 50.81,30.75 51.51,30.05 53.14,30.05 53.23,30.14 53.23,30.15 53.57,30.5 57.12,30.5 58.08,31.45 58.95,31.45 59.14,31.26 59.14,28.58 58.78,28.21 57.13,28.21 56.62,27.71
GND on TOP: 269.63,46.46 267.8,47.54 269.45,50.34 271.28,52.22 272.71,51.6 269.74,46.46 269.74,46.46
GND on TOP: 119.87,41.9 120.28,42.31 121.07,42.31 121.48,41.9 123.02,41.9 123.27,41.65 125.35,41.65 125.48,41.52 125.48,15.31 124.97,14.8 118.04,14.8 117.91,14.93 117.91,41.8 118.01,41.9
GND on TOP: 217.42,89.3 216.67,89.3 216.13,88.76 215.29,88.76 214.74,89.31 214.1,89.31 213.82,89.03 213.82,87.08 211.41,87.08 211.08,87.41 211.08,88.63 210.93,88.79 209.48,88.79 209.28,88.58 209.28,84.85 213.57,80.56 213.57,79.05 213.71,78.9 217.94,78.9 218.14,79.11 218.14,88.57
GND on TOP: 118,79.93 122.92,79.93 123.16,80.17 125.34,80.17 125.47,80.04 125.47,58.32 125.35,58.19 118.02,58.19 117.92,58.3 117.92,79.85
GND on TOP: 97.44,118.92 97.64,118.71 97.64,117.9 98.23,117.32 98.23,116.17 98.73,115.67 98.89,115.67 98.99,115.56 98.99,113.96 98.84,113.81 98.1,113.81 95.43,116.48 95.25,116.48 95.03,116.71 94.54,116.71 94.37,116.89 94.37,117.47 94.49,117.6 95,117.6 95.1,117.7 95.1,118.54 95.48,118.92
GND on TOP: 310.94,34.5 312.4,34.5 312.46,34.44 312.46,34.18 312.4,34.12 310.43,34.12 309.41,35.14 308.65,35.14 307.89,35.9 307.89,37.42 308.27,37.8 309.8,37.8 309.99,37.99 312.53,37.99 312.59,37.93 312.59,37.68 312.53,37.61 310.81,37.61 310.68,37.49 310.68,36.79 310.56,36.66 309.92,36.66 309.48,36.22 309.48,35.64 309.6,35.52 309.92,35.52
GND on TOP: 275.42,42.97 277.04,45.77 278.92,44.72 276.28,40.21 275.44,40.21 274.37,40.93 274.37,41.19 274.43,41.27
GND on TOP: 143.66,28.47 143.64,28.49 143.64,30.1 142.46,31.27 135.13,31.27 134.57,30.72 134.57,29.61 135.34,28.85 135.34,26.96 136.02,26.27 137.99,26.27 138.49,25.78 138.49,25.14 138.66,24.96 142.99,24.96 143.66,25.63
GND on TOP: 94.91,99.46 96.91,99.46 97.54,100.1 97.54,103.3 97.41,103.42 93.65,103.42 90.66,100.43 90.66,97.81 90.85,97.62 93.07,97.62
GND on TOP: 322.62,33.84 322.24,34.23 321.61,34.23 321.48,34.1 321.48,32.57 321.61,32.45 322.11,32.45 322.12,32.45 322.47,32.45 322.71,32.2 322.71,32.05 322.95,31.81 323.13,31.81 323.26,31.94 323.26,32.64 323.45,32.83 324.65,32.83 324.72,32.89 324.72,33.78 324.65,33.84
GND on TOP: 332.44,27.2 335.49,27.2 335.72,27.43 335.72,34.59 335.34,34.97 333.81,34.97 332.95,35.83 332.15,35.83 331.96,35.64 331.96,35.11 332.31,34.75 332.31,27.33
GND on TOP: 134.18,123.19 134.18,123.5 134.34,123.66 134.38,123.66 134.47,123.65 134.52,123.63 134.55,123.57 134.56,123.45 134.62,123.37 134.71,123.31 134.81,123.29 134.92,123.31 135,123.37 135.05,123.44 135.12,123.51 135.12,124.05 135.38,124.31 135.96,124.31 136.16,124.11 136.16,123.49 135.27,122.6 135.27,122.09 135.02,121.84 134.73,121.84 134.66,121.91 134.66,122.65 134.54,122.78 134.24,122.78 134.16,122.86 134.16,123.17
GND on TOP: 112.76,125.19 112.76,124.93 113.53,124.16 113.53,124.16 113.74,123.95 113.74,123.73 113.84,123.63 114.22,123.63 114.34,123.51 114.34,123.33 114.27,123.26 113.38,123.26 113.29,123.36 113.06,123.36 111.81,124.61 111.81,124.62 111.59,124.84 111.59,125.14 111.79,125.34 112.61,125.34
GND on TOP: 122.39,122.38 122.4,122.45 122.4,122.55 122.4,122.59 122.38,122.64 122.38,122.75 122.4,122.76 122.49,122.83 122.53,122.94 122.53,123.04 122.71,123.22 122.76,123.24 122.82,123.22 122.92,123.17 123.03,123.18 123.05,123.19 123.11,123.14 123.11,122.81 123.3,122.62 123.3,122.57 123.3,122.47 123.31,122.4 123.35,122.34 123.36,122.3 123.32,122.28 123.28,122.28 123.2,122.24 123.14,122.18 122.96,122.06 122.94,122.07 122.75,122.08 122.58,122.01 122.54,121.99 122.49,122.11 122.43,122.18 122.38,122.21 122.33,122.26 122.35,122.33
GND on TOP: 225.89,81.24 225.58,81.55 225.58,86.16 227.09,87.66 228.19,87.66 229.27,86.59 229.27,81.5 229.01,81.24
GND on TOP: 101.07,85.17 104.5,85.17 105.13,84.54 105.13,80.73 104.94,80.54 100.44,80.54 100.37,80.6 100.37,84.48
GND on TOP: 312.65,20.98 314.68,20.98 315.64,21.93 315.64,23.01 315.32,23.32 314.63,23.32 314.24,23.72 314.24,25.67 314.05,25.86 312.84,25.86 312.65,25.67 312.65,23.64 312.21,23.2 312.21,21.42
GND on TOP: 228.75,95.65 228.75,92.43 229.6,91.57 230.7,91.57 231.63,90.64 231.63,89.49 232.2,88.92 232.2,87.78 232.71,87.27 235.5,87.27 235.94,86.82 235.94,83.97 236.26,83.65 236.96,83.65 237.34,83.27 237.34,80.86 237.6,80.6 238.23,80.6 238.42,80.79 238.42,84.94 237.81,85.55 237.81,85.99 236.63,87.17 236.63,89.19 236.28,89.54 236.28,92.59 235.82,93.05 234,93.05 231.5,95.55 231.5,95.99 230.76,96.73 229.83,96.73
