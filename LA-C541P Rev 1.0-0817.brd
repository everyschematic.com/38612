# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CLK_0_R: length 4.9
  BOTTOM w0.102: v3(176.48,117.69) 176.48,118.69 R899.1 RE1.1 176.08,119.27 176.21,119.27 176.38,119.45 176.38,119.65 176.15,119.88 175.86,119.88 175.73,120.01 U52.6
PCH_SPI_CLK_1_R: length 5.8
  BOTTOM w0.102: R897.1 R3755.1 187.42,121.75 186.66,122.51 185.14,122.51 184.43,121.8 U53.6
PCH_SPI_CLK_R1: length 82.4
  TOP w0.102: v2(160.7,126.89) 160.95,126.89 162.81,125.04 165.59,125.04 168.43,122.19 168.98,122.19 169.29,121.89 169.81,121.89 170.22,122.3 170.22,123.91 172.85,126.54 175.34,126.54 176.86,125.01 176.86,124.72 177.4,124.19 177.4,122.19 176.64,121.43 176.64,119.42 176.69,119.37 176.69,118.54 176.97,118.26 v2(177.13,118.26) 177.21,118.33 177.21,118.78 177.77,119.34 177.77,119.69 178.2,120.12 178.2,120.14 179.29,121.23 181.68,121.23 182.62,120.29 182.62,118.99 v2(182.6,118.97)
  IN3 w0.127: v2(195.56,123.91) 195.5,123.97 195.5,127.94 195.52,127.96 195.52,128.31 195.5,128.34 195.5,129.81 196.32,130.64 196.32,134.77 194.73,136.35 193.41,136.35 v2(192.31,137.46)
  BOTTOM w0.102: RZ26.1 190.78,134.01 190.78,135.83 192.31,137.36 v2(192.31,137.46) ; R899.2 177.6,118.73 v2(177.13,118.26) ; v2(182.6,118.97) 182.66,119.03 184.08,119.03 v1(184.1,119.05) 186.14,119.05 186.62,118.57 188.45,118.57 189.02,119.15 189.02,119.98 R897.2 189.15,120.67 189.27,120.55 190,120.55 190.26,120.81 190.26,121.34 192.59,123.67 192.59,123.67 192.64,123.72 193.08,123.72 193.15,123.65 195.3,123.65 195.56,123.91 v2(195.56,123.91) ; v2(160.7,126.89) 160.12,126.32 JSPI1.7 160.12,123.47 160.6,122.99 RH181.1
PCH_SPI_CS#0: length 76.1
  TOP w0.089: 115.42,125.65 115.87,125.2 116.04,125.2 116.61,124.62 119.09,124.62 120.06,123.65 UH1.BD31
  TOP w0.102: v2(114.91,133.81) 114.05,132.95 114.05,131.56 114.3,131.31 v1(114.3,130.7) 114.3,130.32 114.15,130.17 114.15,128.26 114.48,127.93 114.48,127.73 114.41,127.66 114.41,127.05 115.29,126.16 115.29,125.78 115.42,125.65
  IN4 w0.109: v2(114.91,133.81) 116.55,133.81 117.68,132.68 119.43,132.68 121.36,130.76 125.32,130.76 125.58,131.02 127.99,131.02 130.56,128.44 130.99,128.44 131.47,127.96 132.7,127.96 133.52,128.79 135.83,128.79 136.18,128.45 136.94,128.45 136.99,128.49 136.99,128.49 137.21,128.71 137.35,128.71 137.6,128.96 138.55,128.96 138.68,129.1 139.22,129.1 139.41,128.91 140.57,128.91 141.19,128.29 141.98,128.29 142.6,128.91 143.97,128.91 146.93,131.86 147.12,131.86 152.92,131.86 154.25,130.53 157.24,130.53 158.01,129.76 160.24,129.76 v2(162.16,127.85)
  BOTTOM w0.102: RH182.2 162.16,121.91 162.16,123.15 161.62,123.68 JSPI1.10 161.62,125.72 161.71,125.81 161.71,127.4 v2(162.16,127.85)
PCH_SPI_CS#0_R1: length 18.4
  TOP w0.102: v2(171.17,127.53) 170.67,127.02 169.71,127.02 v1(168,128.74) 167.63,129.1 162.59,129.1 162.16,128.67 v2(162.03,128.67)
  BOTTOM w0.102: v2(171.17,127.53) 171.17,127.4 170.58,126.8 R7.1 ; RH182.1 161.68,123.12 161.12,123.67 JSPI1.9 161.12,125.79 161.4,126.07 161.4,127.72 162.03,128.35 v2(162.03,128.67)
PCH_SPI_CS#0_R2: length 4.6
  BOTTOM w0.102: U52.1 173.19,126.94 172.97,126.72 R7.2 171.49,127.24 171.71,127.45 171.71,127.93 v3(171.4,128.23)
PCH_SPI_CS#1: length 117.4
  TOP w0.089: UH1.AW31 v2(119.5,120.82)
  TOP w0.102: v2(159.1,127.77) 159.09,127.78 158.35,127.78 158.22,127.91 158.22,129.37 158.09,129.5 157.71,129.5 157.59,129.37 157.59,128.35 157.46,128.23 157.2,128.23 157.08,128.35 157.08,129.37 156.95,129.5 156.7,129.5 156.57,129.37 156.57,128.91 156.44,128.78 156.13,128.78 156,128.91 156,129.37 155.87,129.5 155.41,129.5 155.28,129.62 155.28,129.95 155.41,130.08 v1(157.92,130.08) 158.47,130.08 158.6,129.95 158.6,128.93 158.73,128.8 158.98,128.8 159.11,128.93 159.11,129.95 159.24,130.08 159.49,130.08 159.62,129.95 159.62,129.18 159.74,129.06 160.06,129.06 160.19,129.18 160.19,129.95 160.32,130.08 162.22,130.08 162.35,130.21 162.35,130.51 162.22,130.64 161.84,130.64 161.74,130.74 161.74,131.08 161.87,131.21 162.47,131.21 162.59,131.34 162.59,131.53 162.47,131.66 161.87,131.66 161.74,131.78 161.74,132.1 161.87,132.23 164.57,132.23 164.7,132.35 164.7,132.61 164.57,132.74 161.87,132.74 161.61,132.99 160.61,132.99 160.48,132.86 160.48,132.48 160.61,132.35 161.21,132.35 161.33,132.23 161.33,130.74 161.23,130.64 161.03,130.64 160.93,130.74 160.93,131.74 160.83,131.85 160.62,131.85 160.52,131.74 160.52,130.74 160.42,130.64 160.06,130.64 159.94,130.77 159.94,131.87 159.81,132 159.62,132 159.49,131.87 159.49,131.4 159.36,131.27 158.22,131.27 158.09,131.4 158.09,131.78 157.97,131.91 157.7,131.91 157.57,131.78 157.57,130.55 157.47,130.45 157.27,130.45 157.17,130.55 157.17,131.68 157.05,131.8 156.88,131.8 156.76,131.68 156.76,130.55 156.66,130.45 156.46,130.45 156.35,130.55 156.35,131.17 156.25,131.27 155.66,131.27 155.53,131.15 155.53,130.64 155.4,130.51 154.62,130.51 154.5,130.64 v2(154.5,131.27)
  IN1 w0.089: 134.92,126.2 134.92,125.38 133.33,123.8 130.04,123.8 129.14,122.89 129.14,120.23 128.65,119.75 128.35,119.75 128.34,119.76 125.08,119.76 124.69,120.14 124.69,120.8 124.18,121.31 120,121.31 119.51,120.82 v2(119.5,120.82)
  IN1 w0.109: v2(154.5,131.27) 153.77,131.27 153.75,131.26 152.48,131.26 151.89,131.85 150.41,131.85 150.28,131.97 150.28,132.27 150.16,132.4 149.9,132.4 149.78,132.27 149.78,131.97 149.65,131.85 148.97,131.85 148.84,131.97 148.84,132.86 148.71,132.99 148.51,132.99 148.38,132.86 148.38,131.97 148.25,131.85 148,131.85 147.87,131.97 147.87,132.18 147.74,132.31 147.55,132.31 147.43,132.18 147.43,131.32 147.3,131.19 146.85,131.19 146.73,131.32 146.73,132.35 146.6,132.48 146.41,132.48 146.28,132.35 146.28,131.32 146.16,131.19 145.77,131.19 145.65,131.32 145.65,131.72 145.52,131.85 145.33,131.85 145.2,131.72 145.2,131.32 145.08,131.19 144.82,131.19 144.7,131.32 144.7,131.72 144.57,131.85 144.31,131.85 144.19,131.72 144.19,131.32 144.06,131.19 142.89,131.19 142.76,131.32 142.76,131.61 142.64,131.74 142.35,131.74 142.22,131.61 142.22,131.32 142.09,131.19 141.81,131.19 141.15,130.53 140.57,130.53 140.46,130.42 140.46,130.18 140.35,130.07 140.13,130.07 140.02,130.18 140.02,130.42 139.92,130.53 139.7,130.53 139.59,130.42 139.59,130.18 139.48,130.07 139.26,130.07 139.15,130.18 139.15,130.42 139.04,130.53 138.82,130.53 138.71,130.42 138.71,130.18 138.6,130.07 138.39,130.07 138.28,130.18 138.28,130.42 138.17,130.53 137.95,130.53 137.84,130.42 137.84,130.18 137.73,130.07 137.51,130.07 137.4,130.18 137.4,130.42 137.29,130.53 136.63,130.53 135.93,129.83 135.93,129.43 135.78,129.28 135.38,129.28 135.17,129.07 135.17,128.93 135.3,128.8 135.64,128.8 135.77,128.67 135.77,128.42 135.64,128.29 135.3,128.29 135.17,128.16 135.17,126.57 134.92,126.32 134.92,126.2
  BOTTOM w0.102: RH177.2 157.78,121.98 157.78,122.77 157.62,122.92 JSPI1.2 157.62,125.37 157.79,125.54 157.79,126.15 158.58,126.93 158.58,127.06 159.1,127.59 v2(159.1,127.77)
PCH_SPI_CS#1_R1: length 29.9
  TOP w0.102: v2(178.49,126.39) 178.49,127.99 177.93,128.54 169.4,128.54 168.56,129.38 160.9,129.38 v1(160.68,129.16) 159.87,128.35 v2(159.15,128.35)
  BOTTOM w0.102: R936.1 179.01,126.91 v2(178.49,126.39) ; v2(159.15,128.35) 159.03,128.35 158.7,128.02 158.7,127.51 158.35,127.16 158.35,127.08 157.52,126.26 157.52,125.77 157.12,125.37 JSPI1.1 157.12,122.47 RH177.1
PCH_SPI_CS#1_R2: length 3.8
  BOTTOM w0.102: v1(180.19,128.04) R936.2 181.74,126.91 181.89,127.06 U53.1
PCH_SPI_CS#2: length 181.4
  TOP w0.089: UH1.AT31 119.69,119.65 v2(119.46,119.45)
  IN1 w0.089: v2(119.46,119.45) 120.16,118.75 120.74,118.75 120.99,119 123.47,119 124.24,118.23 128.34,118.23 128.35,118.24 128.35,118.23 128.65,118.23 128.82,118.4 129.79,118.4 130.53,119.15 131.52,119.15 131.87,119.49 131.87,119.67 132.74,120.54 133.91,120.54 134.19,120.82 134.19,123.31 135.89,125 135.89,125.2 136.2,125.51 136.58,125.51 136.83,125.76 136.83,126.2
  IN1 w0.109: v2(157.59,139.7) 156.7,139.7 156.57,139.83 156.57,140.1 156.7,140.23 157.2,140.23 157.33,140.36 157.33,140.61 157.2,140.74 155.74,140.74 155.62,140.86 155.62,141.18 155.74,141.31 157.14,141.31 157.27,141.43 157.27,141.69 157.14,141.82 156.82,141.82 156.7,141.94 156.7,142.2 156.82,142.32 157.14,142.32 157.27,142.45 157.27,142.7 157.4,142.83 157.65,142.83 157.78,142.7 157.78,141.43 157.9,141.31 158.16,141.31 158.28,141.43 158.28,143.21 158.41,143.34 159.68,143.34 159.81,143.21 159.81,142.83 159.68,142.7 158.92,142.7 158.79,142.58 158.79,140.8 158.67,140.67 158.28,140.67 158.16,140.55 158.16,140.29 158.28,140.16 158.86,140.16 158.98,140.04 158.98,139.78 158.86,139.66 158.28,139.66 158.16,139.53 158.16,139.21 158.28,139.09 158.92,139.09 159.05,138.96 159.05,138.7 158.92,138.58 158.47,138.58 158.35,138.45 158.35,138.26 158.47,138.13 158.73,138.13 158.86,138.01 158.86,137.62 158.73,137.5 158.03,137.5 157.9,137.62 157.9,138.64 157.78,138.77 157.52,138.77 157.4,138.64 157.4,137.75 157.27,137.62 157.04,137.62 156.91,137.75 156.91,139.09 156.79,139.21 156.32,139.21 156.19,139.34 156.19,139.66 156.06,139.78 154.22,139.78 153.52,139.09 153.52,138.45 153.65,138.32 154.09,138.32 154.22,138.45 154.22,139.09 154.35,139.21 155.11,139.21 155.24,139.09 155.24,138.32 155.35,138.21 155.68,138.21 155.81,138.34 155.81,138.7 155.93,138.83 156.25,138.83 156.38,138.7 156.38,137.88 156.27,137.77 153.2,137.77 153.08,137.65 153.08,137.37 153.2,137.24 153.46,137.24 153.59,137.12 153.59,136.8 153.48,136.7 152.74,136.7 152.63,136.59 152.63,136.37 152.74,136.26 153.48,136.26 153.59,136.15 153.59,135.93 153.48,135.82 152.74,135.82 152.63,135.71 152.63,135.49 152.74,135.38 153.48,135.38 153.59,135.28 153.59,134.39 153.71,134.26 154.03,134.26 154.16,134.39 154.16,137.12 154.28,137.24 156.25,137.24 156.38,137.12 156.38,136.8 156.25,136.67 155.2,136.67 155.08,136.55 155.08,136.3 155.2,136.17 156.64,136.17 156.77,136.05 156.77,135.86 156.64,135.74 155.03,135.74 154.9,135.61 154.9,135.43 155.03,135.3 157.33,135.3 157.46,135.43 157.46,136.28 157.59,136.4 158.35,136.4 158.47,136.28 158.47,136.04 158.35,135.91 158.16,135.91 158.03,135.78 158.03,135.43 158.16,135.3 159.43,135.3 159.56,135.17 159.56,134.99 159.43,134.86 154.92,134.86 154.8,134.73 154.8,134.55 154.92,134.42 159.43,134.42 159.56,134.3 159.56,134.12 159.43,133.99 158.98,133.99 158.86,133.86 158.86,133.24 158.73,133.12 158.41,133.12 158.28,133.24 158.28,133.86 158.16,133.99 154.72,133.99 154.59,133.86 154.59,133.68 154.72,133.55 156.46,133.55 156.57,133.44 156.57,133.22 156.46,133.11 155.76,133.11 155.66,133.01 155.66,132.61 155.42,132.37 155.42,131.84 155.52,131.74 155.52,130.87 154.92,130.28 152.05,130.28 151.46,130.87 149.66,130.87 149.09,130.3 148.1,130.3 148.01,130.21 142.21,130.21 141.05,129.05 140,129.05 139.87,128.93 139.87,128.61 139.74,128.48 139.55,128.48 139.42,128.61 139.42,128.93 139.3,129.05 138.66,129.05 138.47,128.86 138.47,127.46 138.1,127.08 137.58,127.08 137.46,126.96 137.46,126.58 137.33,126.45 137.08,126.45 136.83,126.2
  IN2 w0.127: v2(191.42,135.4) 188.77,135.4 188.49,135.68 187.3,135.68 186.27,136.71 182.96,136.71 182.6,136.35 180.1,136.35 179.64,135.89 177.19,135.89 176.57,136.51 174.49,136.51 173.6,137.4 170.81,137.4 170.34,137.88 168.89,137.88 168.26,137.26 163.67,137.26 163.05,137.88 162.86,137.88 162.44,137.46 162.26,137.46 161.97,137.74 161.97,137.92 162.49,138.44 162.49,138.62 162.31,138.8 162.13,138.8 161.61,138.28 161.44,138.28 161.26,138.46 161.26,138.64 161.77,139.16 161.77,139.34 161.59,139.52 161.41,139.52 161.12,139.23 160.94,139.23 160.7,139.47 157.82,139.47 v2(157.59,139.7)
  BOTTOM w0.102: RZ17.1 v1(191.62,134.89) 191.62,135.2 v2(191.42,135.4)
PCH_SPI_CS#2_R: length 9.6
  TOP w0.102: RZ84.1 196.23,131.3 v1(195.3,131.3) 192.65,131.3 191.75,132.2 v2(191.5,132.2) 191.5,131.79 191.56,131.73 RZ80.1
  BOTTOM w0.102: U637.20 v2(191.5,132.2) 191.5,132.31 191.62,132.43 RZ17.2
PCH_SPI_D0: length 80.5
  TOP w0.089: 119.82,126.2 119.82,126.11 119.36,125.65 119.36,125.34 120.48,124.23 120.71,124.23 120.91,124.03 120.91,123.94 120.91,123.93 120.91,123.54 120.94,123.51 120.94,123.34 120.95,123.33 120.95,122.95 121.22,122.69 UH1.BB29
  TOP w0.102: RC128.1 RC133.1 159.68,125.86 v1(159.49,126.06) 159.29,126.26 v2(158.92,126.26) ; 119.82,126.2 v2(119.82,126.49)
  IN4 w0.089: 123.31,126.2 123.31,125.83
  IN4 w0.109: v2(119.82,126.49) 120.3,126 120.3,125.39 120.18,125.27 120.18,124.75 120.96,123.97 122.43,123.97 122.8,124.34 122.8,125.32 123.31,125.83 ; 123.31,126.2 123.31,126.68 123.6,126.97 124.24,126.97 124.41,126.79 124.41,126.22 124.95,125.69 126.31,125.69 127.12,126.5 128.21,126.5 128.5,126.8 128.84,126.8 130.13,125.5 132.57,125.5 133.33,126.26 135.75,126.26 136.23,126.74 136.95,126.74 137.29,126.39 140.22,126.39 140.41,126.58 140.78,126.58 140.89,126.47 140.89,125.99 140.99,125.88 141.21,125.88 141.32,125.99 141.32,126.47 141.43,126.58 142.54,126.58 142.66,126.45 142.66,125.75 142.79,125.62 142.98,125.62 143.11,125.75 143.11,126.45 143.23,126.58 143.49,126.58 143.62,126.45 143.62,125.75 143.74,125.62 144.02,125.62 144.15,125.75 144.15,126.58 144.4,126.83 145.65,126.83 145.9,127.08 145.9,127.91 146.22,128.23 147.3,128.23 147.43,128.1 147.43,127.66 147.3,127.53 147.04,127.53 146.92,127.4 146.92,127.08 147.04,126.96 147.43,126.96 147.55,126.83 147.55,126.07 147.68,125.94 148.06,125.94 148.19,126.07 148.19,126.45 148.31,126.58 149.27,126.58 149.52,126.83 149.52,127.34 149.39,127.46 148.82,127.46 148.7,127.59 148.7,127.97 148.57,128.1 147.87,128.1 147.74,128.23 147.74,128.48 147.87,128.61 149.78,128.61 149.9,128.48 149.9,128.04 150.17,127.78 150.17,127.46 150.39,127.24 150.99,127.24 151.16,127.42 151.16,127.72 151.43,127.99 151.43,128.34 151.73,128.64 153.62,128.64 153.8,128.46 153.8,128.01 153.9,127.91 154.25,127.91 154.82,127.34 155.74,127.34 156.24,127.83 157.04,127.83 157.18,127.69 157.18,127.48 157.04,127.34 156.77,127.34 156.63,127.2 156.63,126.99 156.77,126.85 157.07,126.85 157.18,126.74 157.18,126.41 157.73,125.86 157.98,125.86 158.09,125.98 158.09,127.21 158.22,127.34 158.41,127.34 158.54,127.21 158.54,126.39 158.67,126.26 v2(158.92,126.26)
  BOTTOM w0.102: v2(158.92,126.26) 158.92,126.19 158.47,125.75 158.47,125.31 158.62,125.16 JSPI1.4 158.62,123.06 158.79,122.89 158.79,121.91 RH178.2
PCH_SPI_D0_0_R: length 3.7
  BOTTOM w0.102: U52.5 177,119.79 177.27,119.53 178.21,119.53 R901.1 178.54,120.7 v3(178.63,120.79)
PCH_SPI_D0_1_R: length 4.3
  BOTTOM w0.102: U53.5 185.7,121.7 185.84,121.84 186.31,121.84 186.8,121.36 186.8,120.28 R900.1
PCH_SPI_D0_R1: length 82.6
  TOP w0.102: v2(158.98,126.89) 159.16,126.89 160.37,125.69 161.3,125.69 162.55,124.43 164.46,124.43 167.81,121.08 169.87,121.08 v1(170.56,121.77) 171,122.21 171,123.82 173.11,125.93 175.08,125.93 176.03,124.98 176.03,119.01 176.08,118.96 176.08,117.94 176.88,117.14 177.21,117.14 177.65,117.58 v2(177.97,117.58) 177.97,118.61 178.38,119.02 178.38,119.44 178.59,119.65 180.43,119.65 v2(181.13,118.96) ; v2(188.8,135.97) 191.84,135.97 v2(192.14,135.67)
  IN1 w0.109: v2(181.13,118.96) 181.13,119.65 181.57,120.09 181.57,121.58 180.71,122.44 180.71,124.59 v2(180.8,124.68)
  BOTTOM w0.102: R900.2 187.86,119.18 186.94,119.18 186.46,119.66 182.35,119.66 181.74,119.06 181.23,119.06 v2(181.13,118.96) ; RZ29.1 192.52,133.89 192.03,134.39 192.03,135.55 v2(192.14,135.67) ; v2(188.8,135.97) 188.79,135.97 188.79,135.96 188.04,135.96 186.73,134.65 186.73,134.33 186.24,133.84 185.81,133.84 185.42,133.45 185.42,129.94 185.78,129.59 186.04,129.59 186.31,129.31 186.31,125.98 184.95,124.62 181.61,124.62 181.46,124.47 181.02,124.47 v2(180.8,124.68) ; RH178.1 158.12,122.55 JSPI1.3 158.12,126.1 158.92,126.89 v2(158.98,126.89) ; v2(177.97,117.58) 177.97,118.22 178.54,118.79 R901.2
PCH_SPI_D1: length 79.2
  TOP w0.089: 117.28,126.2 118.22,125.26 119.2,125.26 120.48,123.98 120.61,123.98 UH1.BE30
  TOP w0.102: 117.28,126.2 117.24,126.24 117.24,129.01 116.96,129.28 116.96,131.97 117.09,132.1 117.96,132.1 118.09,131.97 118.09,129.94 118.22,129.81 118.6,129.81 118.72,129.94 v1(118.72,130.3) 118.72,132.68 118.6,132.81 v2(116.97,132.81)
  IN4 w0.109: v2(160.7,127.59) 160.7,128.87 160.04,129.52 157.78,129.52 157.01,130.29 154.15,130.29 153.06,131.38 146.78,131.38 144.07,128.67 142.7,128.67 142.08,128.05 140.5,128.05 140.38,128.18 140.38,128.54 140.25,128.67 140,128.67 139.87,128.54 139.87,128.18 139.74,128.05 139.49,128.05 139.36,128.18 139.36,128.62 139.12,128.86 138.78,128.86 138.65,128.73 137.7,128.73 137.45,128.47 137.3,128.47 137.09,128.26 137.09,128.26 137.04,128.21 136.08,128.21 135.74,128.55 135.49,128.55 135.3,128.36 135.3,127.89 135.17,127.76 134.86,127.76 134.75,127.87 134.75,128.31 134.64,128.42 134.42,128.42 134.31,128.31 134.31,127.87 134.17,127.73 131.37,127.73 130.89,128.21 130.47,128.21 127.89,130.79 125.68,130.79 125.41,130.52 121.14,130.52 120.52,131.13 118.84,131.13 117.57,132.4 117.39,132.4 117.39,132.4 v2(116.97,132.81)
  BOTTOM w0.102: RH179.2 160,121.91 160,122.83 159.62,123.21 JSPI1.6 159.62,126.71 160.51,127.59 v2(160.7,127.59)
PCH_SPI_D1_0_R: length 8.9
  BOTTOM w0.102: U52.2 174.46,127.18 173.04,125.76 R8.2 171.49,126.08 171.32,126.25 170.02,126.25 169.46,125.69 169.46,123.96 v3(169.36,123.85)
PCH_SPI_D1_1_R: length 4.6
  BOTTOM w0.102: U53.2 183.16,126.56 182.94,126.33 180.57,126.33 R895.2
PCH_SPI_D1_R1: length 67.9
  TOP w0.102: v2(194.67,138.92) 193.8,139.78 192.63,139.78 191.22,141.19 190.36,141.19 189.78,141.19 189.46,140.88 181.88,140.88 181.6,141.16 181.2,141.16 180.74,140.69 180.74,140.03 178.62,137.92 178.62,134.82 176.71,132.91 176.71,131.87 177.86,130.71 177.86,128.94 178.9,127.91 178.9,126.19 v2(177.88,125.18) 175.68,127.38 171.72,127.38 v2(169.9,125.56) 169.9,125.98 v1(168.89,126.99) 167.09,128.8 162.9,128.8 162.35,128.25 160.41,128.25 159.45,127.3 158.81,127.3 158.51,127 158.51,126.09 158.98,125.62 v2(158.98,125.62)
  BOTTOM w0.102: v2(177.88,125.18) 177.88,125.27 178.57,125.95 R895.1 ; v2(169.9,125.56) 170.11,125.76 R8.1 ; v2(158.98,125.62) 159.12,125.48 JSPI1.5 159.12,122.75 RH179.1 ; v2(194.67,138.92) 194.7,138.89 194.7,137.32 195.03,136.98 RZ30.1
PCH_SPI_D2: length 98
  TOP w0.089: v2(120.95,125.52) 120.61,125.52 120.31,125.23 120.31,124.63 120.55,124.4 120.78,124.4 121.08,124.1 121.08,124.01 121.08,124 121.08,123.61 121.11,123.58 121.11,123.41 121.12,123.4 121.12,123.36 121.24,123.24 UH1.BC29
  IN4 w0.109: v2(120.95,125.52) 121.36,125.52 121.9,126.07 122.55,126.07 122.68,126.2 122.68,126.77 123.19,127.27 124.52,127.27 124.69,127.1 124.69,126.27 125.03,125.94 126.2,125.94 127,126.74 128.11,126.74 128.4,127.03 128.64,127.03 128.89,127.28 129.56,127.28 129.8,127.04 129.8,126.36 130.34,125.81 132.55,125.81 133.23,126.49 135.65,126.49 136.13,126.97 137.05,126.97 137.39,126.63 140.06,126.63 140.24,126.82 144.05,126.82 144.41,127.18 145.33,127.18 145.46,127.3 145.46,128.23 146,128.77 146.59,128.77 146.76,128.94 146.76,129.42 146.91,129.57 147.11,129.57 147.25,129.42 147.25,129.04 147.4,128.9 147.6,128.9 147.74,129.04 147.74,129.88 147.89,130.03 148.1,130.03 148.25,129.88 148.25,129.05 148.38,128.93 148.7,128.93 148.82,129.05 148.82,129.98 148.97,130.13 149.18,130.13 149.33,129.98 149.33,129.05 149.46,128.93 149.78,128.93 149.9,129.05 149.9,129.76 150.18,130.03 152.59,130.03 152.73,129.89 152.73,129.69 152.59,129.54 151.54,129.54 151.4,129.4 151.4,129.2 151.54,129.05 154.16,129.05 154.28,128.93 154.28,128.27 154.41,128.15 154.67,128.15 154.78,128.26 154.78,128.93 154.9,129.05 155.09,129.05 155.21,128.93 155.21,127.75 155.34,127.62 155.52,127.62 155.65,127.75 155.65,128.93 155.78,129.05 155.96,129.05 156.09,128.93 156.09,128.26 156.2,128.15 156.41,128.15 156.52,128.26 156.52,128.57 156.65,128.7 156.83,128.7 156.96,128.57 156.96,128.26 157.07,128.15 158.48,128.15 158.6,128.02 158.6,127.84 158.48,127.72 v2(157.65,127.72)
  BOTTOM w0.089: v2(120.95,125.52) 121.01,125.52 121.24,125.29 121.24,123.96 120.8,123.51 v1(120.61,123.51) 119.97,123.51 RH180.2
  BOTTOM w0.102: RH183.2 163.24,121.91 163.24,123.02 162.62,123.64 JSPI1.12 162.62,128.42 162.75,128.54 164.63,128.54 164.76,128.42 164.76,128.13 164.66,128.03 164.16,128.03 164.06,127.93 164.06,127.72 164.16,127.62 164.66,127.62 164.76,127.52 164.76,127.32 164.66,127.22 164.16,127.22 164.06,127.11 164.06,126.91 164.16,126.81 164.66,126.81 164.76,126.71 164.76,125.56 164.89,125.43 165.71,125.43 165.84,125.56 165.84,125.81 165.71,125.94 165.33,125.94 165.21,126.07 165.21,129.01 165.08,129.14 161.4,129.14 161.27,129.01 161.27,128.29 161.14,128.16 160.82,128.16 160.7,128.29 160.7,129.01 160.57,129.14 160.32,129.14 160.19,129.01 160.19,128.35 160.06,128.23 159.81,128.23 159.68,128.35 159.68,129.01 159.55,129.14 159.17,129.14 159.05,129.01 159.05,128.86 158.92,128.74 158.66,128.74 158.07,128.14 158.07,128.14 v2(157.65,127.72)
PCH_SPI_D2_0_R: length 7.3
  BOTTOM w0.102: R3664.2 R9.2 173.91,124.81 175.73,126.64 U52.3
PCH_SPI_D2_1_R: length 8
  BOTTOM w0.102: R3665.2 R3667.2 180.65,125.46 184.33,125.46 184.71,125.84 184.71,126.8 184.43,127.08 U53.3
PCH_SPI_D2_R1: length 27.7
  TOP w0.102: v2(162.16,127.21) 162.65,127.71 162.65,128.2 162.98,128.53 164.91,128.53 165.1,128.34 v1(165.74,128.34) 166.65,128.34 169.5,125.5 169.5,125.39 169.97,124.92 v2(169.97,124.94) 172.18,127.15 175.59,127.15 177.47,125.26 177.47,124.98 177.72,124.73 178.1,124.73 v2(178.54,125.18)
  BOTTOM w0.102: v2(169.97,124.94) 169.97,124.92 170.08,124.81 R9.1 ; v2(178.54,125.18) 178.72,125 R3667.1 ; v2(162.16,127.21) 162.16,127.15 162.12,127.11 JSPI1.11 162.12,123.63 162.76,122.99 RH183.1
PCH_SPI_D2_XDP: length 170.7
  TOP w0.102: RC127.2 164.7,15.08 164.7,17.35 163.64,18.41 v1(163.64,19.55) 163.64,19.89 148.93,34.6 148.93,56.6 156.99,64.66 158.03,64.66 159.31,65.94 159.31,68.14 163.54,72.37 163.54,72.46 163.56,72.48 163.56,73.09 v2(163.13,73.52)
  IN3 w0.089: 141.76,103.67 140.79,104.64 140.79,106.03 138.83,108 138.83,111.87 140.78,113.83 140.78,115.65 140.39,116.05 140.39,118.11 139.86,118.64 139.62,118.88 139.62,121.49 139.34,121.77 137.99,121.77 137.11,120.9 135.23,120.9 134.59,121.54 134.59,122.01 134.32,122.28 134.32,122.83 133.97,123.18 133.63,123.18 133.49,123.04 132.17,123.04 131.6,122.47 130.48,122.47 130.05,122.04 130.05,120.11 130.56,119.6 130.56,119.02 130.2,118.66 129.32,118.66 128.98,119 128.25,119 127.94,118.69 127.39,118.69 127.08,119 122.51,119 122.17,119.34 122.17,121.08 121.94,121.31 121.57,121.31 121.14,121.74 121.14,122.91 120.94,123.1 120.94,123.12 120.73,123.33 120.71,123.33 119.28,124.77 v2(119.28,126.11)
  IN3 w0.127: 141.76,103.67 143.45,101.98 143.45,98.72 141.75,97.02 141.75,89.5 142.73,88.53 142.73,88.05 150.44,80.34 151.31,80.34 156.76,74.89 161.28,74.89 162.65,73.52 v2(163.13,73.52)
  BOTTOM w0.089: RH180.1 119.28,125.12 v2(119.28,126.11)
PCH_SPI_D3: length 86.8
  TOP w0.089: UH1.BD30 120.68,123.53 120.43,123.78 120.43,123.79 119.15,125.07 117.88,125.07 116.74,126.2
  TOP w0.102: 116.74,126.2 116.63,126.32 RH334.1 115.97,127.73 115.97,128.21 115.65,128.52 115.65,129.41 116.16,129.92 116.16,129.92 116.56,130.32 116.56,132.99 116.87,133.29 117.38,133.29 v2(117.58,133.5) ; RH335.1 164.52,127.02 164.06,127.48 v2(163.49,127.48)
  IN4 w0.109: v2(163.49,127.48) 162.57,128.4 162.57,128.84 161.41,130 158.11,130 157.34,130.77 154.35,130.77 153.01,132.1 147.22,132.1 146.79,132.1 143.83,129.14 142.6,129.14 142.41,129.33 141.08,129.33 140.89,129.14 139.54,129.14 139.35,129.33 137.64,129.33 137.25,128.94 137.02,128.94 136.63,129.33 136.18,129.33 135.87,129.02 133.42,129.02 132.6,128.2 131.57,128.2 131.09,128.68 130.66,128.68 127.31,132.04 121.52,132.04 121.26,132.29 121.26,134.79 121.14,134.92 120.82,134.92 120.69,134.79 120.69,133.85 120.57,133.72 120.38,133.72 120.27,133.83 120.27,135.19 120.16,135.3 119.94,135.3 119.84,135.19 119.84,133.83 119.73,133.72 119.51,133.72 119.4,133.83 119.4,135.19 119.29,135.3 119.03,135.3 118.93,135.19 118.93,133.8 118.79,133.66 118.62,133.66 118.49,133.8 118.49,135.19 118.38,135.3 118.16,135.3 118.05,135.19 118.05,133.8 117.94,133.69 117.71,133.69 117.58,133.56 v2(117.58,133.5)
  BOTTOM w0.102: v2(163.49,127.48) 163.49,125.48 163.62,125.35 JSPI1.14 163.62,123.4 164.32,122.71 164.32,121.91 RH184.2
PCH_SPI_D3_0_R: length 5.9
  BOTTOM w0.102: U52.7 174.46,122.55 174.11,122.91 R3668.2 R3669.1
PCH_SPI_D3_1_R: length 5.8
  BOTTOM w0.102: U53.7 183.16,122.14 182.21,123.1 R3666.2 R3670.1
PCH_SPI_D3_R1: length 26.7
  TOP w0.102: v2(169.62,122.5) 169.27,122.84 168.75,122.84 v1(166.79,124.8) 165.47,126.12 165.47,126.85 164.62,127.71 163.89,127.71 v2(163.49,128.1)
  IN4 w0.109: v2(169.62,122.5) 169.73,122.38 177.02,122.38 177.63,122.99 v2(178.08,122.99)
  BOTTOM w0.102: v2(169.62,122.5) 169.64,122.5 169.64,122.47 170.04,122.07 170.46,122.07 R3669.2 ; RH184.1 163.84,122.86 163.12,123.58 JSPI1.13 163.12,125.61 163.05,125.69 163.05,127.73 163.41,128.1 163.49,128.1 v2(163.49,128.1) ; v2(178.08,122.99) 178.1,122.99 178.56,122.53 178.89,122.53 R3670.2
PCH_THERMTRIP#: length 258.5
  TOP w0.102: v2(105.3,50.44) 104.79,49.93 RD4.2 RD12.2 RD3.2 105.06,48.15 105.31,48.41 RD5.2 ; v2(210.08,71.41) 210.19,71.52 212.07,71.52 213.93,73.38 RC169.1 215.19,73.38 215.3,73.49 RC326.1 ; RH75.2 143.18,115.01 143.59,115.42 143.59,116.8 v2(143.59,116.8)
  IN1 w0.109: v2(105.41,81.66) 106.01,81.06 106.01,63.36 106.83,62.54 106.83,53.33 105.3,51.79 v2(105.3,50.44)
  IN2 w0.127: v2(143.59,116.8) 143.59,116.8 154.12,116.8 154.55,116.36 161.11,116.36 162.14,117.39 163.88,117.39 164.64,116.63 168.24,116.63 172.14,120.53 178.5,120.53 180.03,122.06 183.7,122.06 184.22,122.58 187.23,122.58 188.06,123.41 188.87,123.41 189.72,124.27 189.94,124.27 190.57,124.9 193.29,124.9 194.04,125.65 195.86,125.65 196.95,126.73 199.4,126.73 v2(200.07,126.07) ; v2(206.87,85.61) 205.4,87.09 205.4,92.84 203.73,94.51 202.89,94.51 202.15,95.25 v2(202.15,95.68)
  IN3 w0.127: v2(200.07,126.07) 201.34,124.8 201.34,119.97 202.46,118.85 202.46,116.48 201.59,115.61 201.59,109.81 200.98,109.2 200.98,106.73 201.78,105.93 201.78,103.78 202.94,102.62 202.94,101.83 201.79,100.68 201.79,96.03 v2(202.15,95.68)
  BOTTOM w0.089: 115.22,99.84 114.66,99.28
  BOTTOM w0.102: Q28.3 201.01,98.58 202.15,97.44 v2(202.15,95.68) ; v2(105.41,81.66) 105.56,81.8 105.56,83.86 104.88,84.54 102.75,84.54 101.72,85.57 100.69,85.57 96.4,89.86 96.4,91.22 103.65,98.46 103.65,99.52 105.06,100.93 105.4,100.93 105.99,101.53 107.38,101.53 108.83,100.08 108.83,99.52 109.14,99.21 114.58,99.21 114.66,99.28 ; 115.22,99.84 116.31,99.84 116.95,99.21 122.72,99.21 123.07,99.55 130.78,99.55 131.07,99.84 131.75,99.84 132,99.6 134.5,99.6 136.01,101.1 136.01,103.99 139.62,107.6 139.62,108.16 140.44,108.99 141.77,108.99 142.92,110.13 142.92,110.98 143.49,111.55 v1(143.49,113.84) 143.49,116.69 v2(143.59,116.8) ; v2(210.08,71.41) 211.81,73.15 211.81,73.81 213.43,75.42 213.43,75.87 211.35,77.95 211.35,79.1 208.74,81.71 208.74,82.16 208.13,82.76 208.13,84.35 v2(206.87,85.61)
PCH_THERMTRIP#_R: length 8.2
  TOP w0.089: UH1.AJ3 133.96,115.86 134.14,115.67 134.14,115.66 134.28,115.53 134.58,115.53 134.84,115.79 135.69,115.79 135.87,115.97 137.58,115.97 138.32,115.23
  TOP w0.102: 138.32,115.23 v1(140.29,115.23) 141.22,115.23 RH75.1
PCH_XDP_CLK_DN: length 135.6
  TOP w0.102: v2(161.76,76.1) 161.54,75.88 161.54,75.58 161.42,75.47 161.42,73.67 157.47,69.72 156.47,69.72 146.49,59.74 146.49,29.76 158.08,18.17 158.08,17.08 158.97,16.2 158.97,13.28 157.96,12.28 154.64,12.28 154.22,11.86 154.22,11.64 154.36,11.49 JXDP1.42 ; v2(140.63,108.31) 140.8,108.48 140.8,108.7 140.69,108.81 v4(140.19,108.81) 139.01,108.81 138.93,108.74 RH154.2
  IN1 w0.089: 138.82,99.28 138.82,99.3 138.83,99.32 138.83,102.76 140.63,104.57 v2(140.63,108.31)
  IN1 w0.109: v2(141.27,89.03) 140.28,89.03 138.99,90.33 138.99,94.44 140.8,96.25 140.8,97.4 140.35,97.85 139.54,97.85 138.82,98.57 138.82,99.28
  IN4 w0.109: v2(161.76,76.1) 161.76,75.5 161.46,75.2 160.6,75.2 159.16,76.64 158.5,76.64 157.93,77.21 154.45,77.21 147.5,84.16 146.16,84.16 142.96,87.36 142.96,88.14 142.07,89.03 v2(141.27,89.03)
PCH_XDP_CLK_DN_R: length 4.6
  TOP w0.089: 135.24,108.11 135.22,108.1 135.21,108.1 134.63,107.51 134.63,107.39 134.69,107.33 UH1.L1
  TOP w0.102: RH154.1 138.02,108.71 137.91,108.83 135.95,108.83 135.24,108.11
PCH_XDP_CLK_DP: length 135.6
  TOP w0.102: v2(141.2,108.35) 141.01,108.54 141.01,108.79 140.78,109.03 139.2,109.03 RH155.2 ; v2(161.17,76.1) 161.32,75.95 161.32,75.67 161.21,75.56 161.21,73.76 157.38,69.93 156.38,69.93 146.27,59.83 146.27,29.67 157.86,18.08 157.86,16.99 158.75,16.11 158.75,13.37 157.87,12.49 154.55,12.49 154,11.95 154,11.62 153.86,11.48 JXDP1.40
  IN1 w0.089: 139.03,99.28 139.03,99.29 139.02,99.31 139.02,102.68 140.83,104.49 140.83,107.98 v2(141.2,108.35)
  IN1 w0.109: 139.03,99.28 139.03,98.66 139.63,98.06 140.44,98.06 141.01,97.49 141.01,96.16 139.2,94.35 139.2,90.42 140.37,89.25 140.9,89.25 v2(141.27,89.62)
  IN4 w0.109: v2(141.27,89.62) 141.63,89.25 142.16,89.25 143.17,88.23 143.17,87.45 146.25,84.37 147.59,84.37 154.54,77.43 158.02,77.43 158.59,76.86 159.25,76.86 160.68,75.42 161.37,75.42 161.54,75.59 161.54,75.73 v2(161.17,76.1)
PCH_XDP_CLK_DP_R: length 4.6
  TOP w0.089: UH1.L2 134.42,107.45 134.42,107.6 135.03,108.2 135.07,108.25 135.07,108.26 135.09,108.27
  TOP w0.102: 135.09,108.27 135.86,109.04 v4(137.06,109.04) 137.77,109.04 RH155.1
PCH_XDP_PRDY#: length 123.8
  TOP w0.089: UH1.AT4 133.17,119.44 v2(132.66,119.95)
  TOP w0.102: v2(135.02,91.4) 135.53,91.91 137.64,91.91 138.43,91.12 138.43,89.48 140.74,87.18 141.33,87.18 142.24,86.27 142.24,85.62 144.3,83.56 144.3,82.23 141.66,79.59 141.21,79.59 138.79,77.17 138.79,72.22 144.26,66.75 144.26,23.34 149.67,17.93 RC314.2
  IN3 w0.089: 135.4,99.28 135.4,100.05 136.73,101.38 136.73,105.33 136.3,105.76 136.3,113.59 136.31,113.6 136.31,113.75 136.31,117.31 134.16,119.46 133.2,119.46 132.72,119.95 v2(132.66,119.95)
  IN3 w0.127: v2(135.02,91.4) 135.02,93.96 134.37,94.61 134.37,96.4 135.08,97.12 135.08,98.14 135.4,98.46 135.4,99.28
  BOTTOM w0.089: v2(132.66,119.95) 132.52,119.95 v3(132.21,120.25)
PCH_XDP_PREQ#: length 121.1
  TOP w0.089: UH1.AT3 133.43,119.82 v2(133.3,119.96)
  TOP w0.102: RC315.2 148.74,18.53 144.03,23.24 144.03,66.65 138.54,72.15 138.54,77.24 141.12,79.82 141.57,79.82 144.07,82.33 144.07,83.47 142.01,85.53 142.01,86.18 141.24,86.95 140.64,86.95 138.21,89.39 138.21,91.02 137.54,91.68 135.9,91.68 v2(135.61,91.4)
  IN3 w0.089: v2(133.3,119.96) 133.91,119.96 136.49,117.38 136.49,113.68 136.49,113.53 136.48,113.52 136.48,105.9 136.91,105.47 136.91,101.31 135.65,100.06 135.65,99.28
  IN3 w0.127: 135.65,99.28 135.65,98.36 135.34,98.04 135.34,97.01 134.62,96.3 134.62,94.71 135.27,94.06 135.27,91.74 v2(135.61,91.4)
PCI_CLK_LPC0: length 13.3
  TOP w0.089: UH1.BC17 126.88,123.13 127.11,123.36 127.11,123.62 127.07,123.65 127.07,124.33 127.65,124.9 127.65,126.04 v2(127.74,126.13)
  BOTTOM w0.089: v2(127.74,126.13) 127.67,126.2
  BOTTOM w0.102: 127.67,126.2 127.63,126.24 127.63,127.55 127.63,127.56 127.63,127.91 127.63,127.91 127.63,129.28 126.92,130 126.92,130.45 v1(127.17,130.7) 127.52,131.05 130.28,131.05 RH96.1 RH97.1
PCI_CLK_LPC1: length 27.2
  TOP w0.089: UH1.AV19 v2(126.23,120.16)
  IN3 w0.089: 122.53,126.2 122.41,126.08 122.03,126.08 121.39,125.45 121.39,124.3 121.69,124 121.7,124 121.7,122.6 122.36,121.94 122.36,121.48 122.61,121.23 123.12,121.23 123.19,121.31 124.29,121.31 124.87,121.89 125.33,121.89 125.68,121.53 125.68,120.67 126.2,120.16 v2(126.23,120.16)
  IN3 w0.127: 122.53,126.2 122.61,126.28 122.61,126.87 121.02,128.46 121.02,130.93 v2(121.51,131.41)
  BOTTOM w0.102: v2(121.51,131.41) v1(121.51,132.02) 122.1,132.62 126.18,132.62 126.81,131.99 128.13,131.99 RH99.1 RH98.1
PCIE_PRX_C_DTX_N4: length 2.1
  TOP w0.102: C459.1 255.56,108.03 255.31,108.03 254.9,108.44 254.7,108.44 254.6,108.54 U31.39
PCIE_PRX_C_DTX_N15: length 18.1
  TOP w0.102: v2(25.99,23.54) 25.8,23.72 25.8,24.02 RN132.1
  BOTTOM w0.102: v2(25.99,23.54) 25.8,23.35 25.8,22.28 26.51,21.57 v4(27.87,21.57) 34.46,21.57 34.97,22.08 35.81,22.08 37.19,20.7 38.41,20.7 38.91,20.2 38.91,19.79 39.05,19.64 JSATA2.11
PCIE_PRX_C_DTX_N16: length 8.5
  TOP w0.102: v2(37.16,23.56) 36.98,23.75 36.98,23.95 RN134.1
  BOTTOM w0.102: v2(37.16,23.56) 36.97,23.37 36.97,23.27 v4(37.66,22.58) 38.23,22.02 38.85,22.02 39.62,21.24 40.29,21.24 42.05,19.48 JSATA2.5
PCIE_PRX_C_DTX_P4: length 2.1
  TOP w0.102: U31.38 254.56,108.14 254.64,108.23 254.81,108.23 255.22,107.82 255.65,107.82 255.65,107.82 C458.1
PCIE_PRX_C_DTX_P15: length 18.1
  TOP w0.102: v2(25.4,23.54) 25.59,23.72 25.59,24.02 RN131.1
  BOTTOM w0.102: JSATA2.12 38.55,19.64 38.69,19.79 38.69,20.11 38.32,20.48 37.1,20.48 35.72,21.86 35.06,21.86 34.55,21.36 26.42,21.36 v4(25.99,21.79) 25.58,22.19 25.58,23.36 v2(25.4,23.54)
PCIE_PRX_C_DTX_P16: length 8.4
  TOP w0.102: v2(36.58,23.56) 36.76,23.75 36.76,23.95 RN133.1
  BOTTOM w0.102: v2(36.58,23.56) 36.76,23.39 36.76,23.18 38.14,21.8 38.76,21.8 v4(39.26,21.3) 39.53,21.03 40.2,21.03 41.55,19.68 JSATA2.6
PCIE_PRX_C_RD_DTX_N15: length 2
  TOP w0.102: CN76.2 26.28,32.62 26.28,32.34 26.34,32.28 26.34,31.86 26.46,31.74 UN8.4
PCIE_PRX_C_RD_DTX_N16: length 1.9
  TOP w0.102: CN80.2 37,32.55 37,32.44 37.3,32.14 37.3,31.81 37.44,31.67 UN9.4
PCIE_PRX_C_RD_DTX_P15: length 2
  TOP w0.102: CN69.2 26.06,32.58 26.06,32.25 26.13,32.19 26.13,31.91 25.96,31.74 UN8.5
PCIE_PRX_C_RD_DTX_P16: length 1.9
  TOP w0.102: UN9.5 36.94,31.68 37.09,31.82 37.09,32.05 36.78,32.35 36.78,32.48 CN74.2
PCIE_PRX_DTX_N2: length 131.7
  TOP w0.089: v2(127.52,104.62) 127.48,104.67 127.36,104.67 UH1.E17
  IN1 w0.109: v2(154.43,102.34) 154.32,102.34 154.16,102.51 154.16,102.65 157.42,105.91 158.98,105.91 160.3,107.23 160.58,107.23 161.37,108.02 161.37,108.52 161.43,108.58 161.43,108.59 162.35,109.51 162.35,113.25 162.73,113.63 163.86,113.63 164.57,114.35 164.57,118.62 166.4,120.46 166.4,121.23 168.05,122.88 168.05,132 168.38,132.32 168.38,133.55 167.3,134.63 167.3,135.01 167.85,135.55 167.85,137.03 168.78,137.96 169.21,137.96 169.55,137.96 169.55,137.96 191.73,137.96 191.88,138.11 192.68,138.11 196.63,134.15 197.89,134.15 204.8,127.24 204.8,126.9 204.8,125.69 208.04,122.44 208.04,119.88 209.34,118.58 210.39,118.58 v2(210.76,118.21)
  IN4 w0.109: v2(127.52,104.62) 127.64,104.73 127.87,104.73 127.99,104.61 127.99,103.98 129.86,102.12 130.76,102.12 131.03,101.85 132.97,101.85 133.73,101.09 135.64,101.09 138.56,104.01 141.57,104.01 141.59,104.02 144.08,104.02 146.44,101.65 147.58,101.65 147.83,101.4 153.75,101.4 154.12,101.77 154.12,101.96 154.43,102.28 v2(154.43,102.34)
  BOTTOM w0.102: JNGFF1.35 212,118.2 211.88,118.32 210.87,118.32 v2(210.76,118.21)
PCIE_PRX_DTX_N3: length 231.7
  TOP w0.102: v2(127.66,107.72) 127.25,107.31 UH1.L17 ; v2(305.27,43.52) 305.29,43.5 v4(305.29,42.26) 305.29,39.96 307.12,38.13 309.74,38.13 309.9,38.3 JIO1.42
  IN4 w0.089: 128.83,105.35 128.82,105.36 128.81,105.36 128.76,105.4 128.75,105.4 128.21,105.94 128.21,107.13 128.05,107.3 127.64,107.3 127.55,107.39 127.55,107.61 v2(127.66,107.72)
  IN4 w0.109: 128.83,105.35 129.2,104.97 129.2,103.91 130.22,102.89 131.03,102.89 131.44,102.48 135.99,102.48 138.19,104.69 141.33,104.69 141.5,104.86 144.63,104.86 146.41,103.08 147.11,103.08 147.3,102.89 153.28,102.89 153.88,103.49 155.58,103.49 156.98,102.09 160.55,102.09 162.35,100.29 163.04,100.29 164.12,99.21 165.06,99.21 165.93,98.33 165.93,97.89 167.64,96.19 167.96,96.19 168.21,95.94 171.46,95.94 172.83,94.57 172.83,93.99 173.83,92.98 175.73,92.98 177.06,91.66 181.3,91.66 182.01,92.38 182.01,92.9 182.44,93.33 183.01,93.33 185.38,90.96 202.95,90.96 203.26,91.26 205.29,91.26 205.67,90.89 206.28,90.89 206.95,90.22 207.45,90.22 207.97,89.69 209.39,89.69 210.44,88.65 221.57,88.65 224.35,91.43 228.8,91.43 231.2,89.02 235.84,89.02 237.91,86.95 238.49,86.95 239.63,85.81 245.71,85.81 248.56,82.96 248.56,81.58 248.9,81.24 248.9,80.4 250.74,78.56 250.74,78 253.87,74.87 253.87,72.82 255,71.7 255,69.99 256.51,68.48 256.51,67.64 257.75,66.41 257.75,63.32 265.79,55.28 267.25,55.28 275.78,46.75 280.26,46.75 281.83,45.19 284.76,45.19 285.6,44.35 289.03,44.35 289.11,44.27 289.11,44.27 289.72,43.65 299.35,43.65 299.87,43.14 301.22,43.14 301.3,43.05 301.93,43.05 302.02,42.96 305.11,42.96 305.35,43.2 305.35,43.44 v2(305.27,43.52)
PCIE_PRX_DTX_N4: length 201.2
  TOP w0.089: UH1.E20 125.93,104.22 v2(126.23,104.52)
  TOP w0.102: v2(257.65,108.27) 257.47,108.08 257.19,108.08 C459.2
  IN1 w0.089: v2(126.23,104.52) 126.39,104.52 126.5,104.63 126.5,104.78 126.39,104.88 125.94,104.88 125.77,104.71 125.77,102.64 122.97,99.84 122.97,99.38 122.98,99.37 122.98,99.31 122.99,99.29 122.99,99.28 ; 127.43,99.44 127.44,99.45 127.44,99.45 127.46,99.45 127.49,99.49 127.51,99.49 128.64,100.62 130.09,100.62 130.3,100.84 130.3,101.03 131.2,101.92 132.79,101.92 133,101.72 133.4,101.32 134.79,101.32 136.31,102.85 136.31,103.84 137.9,105.43 137.9,108.75 139.27,110.12 141.75,110.12 141.76,110.13
  IN1 w0.109: 122.99,99.28 122.99,98.36 123.54,97.81 125.8,97.81 127.43,99.44 ; 141.76,110.13 143.63,110.13 145.05,111.55 145.05,113.58 145.91,114.45 147.76,114.45 149.5,116.19 150.85,116.19 150.96,116.08 153.6,116.08 153.97,115.72 155.64,115.72 158.4,118.47 159.34,118.47 160.67,119.81 161.94,119.81 162.2,120.06 162.2,121.59 165.85,125.24 165.85,132.35 165.18,133.01 165.18,138.29 165.6,138.7 166.49,138.7 168.16,140.38 168.41,140.38 169.82,141.78 175.91,141.78 176.48,141.21 178.64,141.21 179.14,141.7 191.09,141.7 191.52,141.27 197.18,141.27 197.59,140.86 200.07,140.86 200.58,140.36 211.42,140.36 215.75,136.02 215.75,135.97 225.3,126.42 225.3,116.61 227.87,114.04 229.8,114.04 235.81,108.03 243.02,108.03 244.99,106.07 246,106.07 247.15,104.92 247.57,104.92 248.32,104.17 252.89,104.17 256.8,108.08 257.47,108.08 v2(257.65,108.27)
PCIE_PRX_DTX_N5: length 105.5
  TOP w0.089: UH1.K19 125.87,106.45 v2(126.23,106.8)
  TOP w0.102: JIO2.120 53.52,51.85 53.74,52.06 53.74,52.59 53.56,52.76 53.56,53.84 54.68,54.97 v2(54.68,57.35)
  IN3 w0.089: 123.04,99.46 123.06,99.47 123.08,99.47 126.83,103.22 126.83,106.84 126.49,107.18 125.92,107.18 125.79,107.05 125.79,106.88 125.86,106.8 v2(126.23,106.8)
  IN3 w0.127: 123.04,99.46 122.59,99.01 104.69,99.01 103.9,98.23 102.65,98.23 95.22,90.8 94.57,90.8 62.14,58.37 56.36,58.37 54.9,56.91 54.55,56.91 54.48,56.98 54.48,57.14 54.52,57.18 54.52,57.19 v2(54.68,57.35)
PCIE_PRX_DTX_N6: length 100.2
  TOP w0.089: UH1.G22 124.83,104.92 v2(125.19,105.28)
  TOP w0.102: v2(54.07,58.81) 54.07,58.15 53.66,57.74 53.66,56.36 53.81,56.2 53.81,55.18 53.49,54.85 JIO2.132
  IN3 w0.089: v2(125.19,105.28) 125.4,105.07 125.59,105.07 125.86,104.8 125.86,102.81 122.71,99.65 121.47,99.65 121.24,99.89 112.4,99.89 112.38,99.87 112.37,99.87
  IN3 w0.127: v2(54.07,58.81) 54.07,59.48 54.18,59.59 62.66,59.59 94.3,91.23 95.04,91.23 102.47,98.66 103.61,98.66 105.49,100.55 111.45,100.55 112.12,99.87 112.37,99.87
PCIE_PRX_DTX_N7: length 103.4
  TOP w0.089: UH1.L22 124.83,107.21 v2(125.19,107.57)
  TOP w0.102: v2(49.95,58.82) 49.95,58.25 50.35,57.85 JIO2.144
  IN3 w0.089: v2(125.19,107.57) 125.01,107.39 124.71,107.39 124.23,106.91 124.23,102.23 122.34,100.35 121.9,100.35 121.45,100.79 112.54,100.79 112.37,100.96
  IN3 w0.127: v2(49.95,58.82) 50.02,58.88 50.02,59.62 50.29,59.9 51.47,59.9 52.24,60.66 54.84,60.66 55.29,61.11 62.69,61.11 93.74,92.16 94.66,92.16 102.09,99.59 103.17,99.59 105.13,101.55 111.78,101.55 112.37,100.96
PCIE_PRX_DTX_N8: length 99.6
  TOP w0.089: UH1.K24 v2(122.81,106.8)
  TOP w0.102: v2(49.96,61.8) 49.96,61.2 50.31,60.85 JIO2.156
  IN3 w0.089: v2(122.81,106.8) 122.81,107.03 122.93,107.14 123.23,107.14 123.42,106.95 123.42,104.59 122.78,103.94 119.4,103.94 118.29,102.82 114.03,102.82 113.29,103.56 112.37,103.56
  IN3 w0.127: v2(49.96,61.8) 49.96,61.85 50.28,62.17 50.28,62.48 51.32,63.53 63.18,63.53 100.61,100.95 102.43,100.95 105.01,103.53 105.52,103.53 106.07,104.08 106.21,104.22 111.61,104.22 112.28,103.56 112.37,103.56
PCIE_PRX_DTX_N9: length 187.4
  TOP w0.089: UH1.G31 v2(119.48,105.37)
  TOP w0.102: v2(13.83,15.05) 14.12,15.34 14.33,15.34 14.81,14.85 v4(14.81,13.84) 14.81,13.27 13.06,11.51 13.06,6.36 12.94,6.24 12.28,6.24 12.16,6.36 12.16,6.53 12.28,6.65 v2(12.41,6.65)
  IN1 w0.089: v2(119.48,105.37) 119.65,105.54 119.87,105.54 119.93,105.49 119.93,105.3 119.46,104.83 119.46,103.97 118.26,102.76 114.19,102.76 113.45,103.5 113.45,104.29 113.01,104.73 112.4,104.73 112.39,104.74 112.37,104.74
  IN1 w0.109: v2(13.83,15.05) 13.73,15.05 13.1,15.68 13.1,16.56 13.47,16.92 13.47,32.24 18.55,37.32 20.77,37.32 21.82,38.37 21.82,49.11 23.61,50.89 23.61,51.27 26,53.65 26,63.24 27.34,64.59 54.6,64.59 56.66,62.53 64.27,62.53 105.46,103.72 106.15,103.72 107.18,104.74 112.37,104.74
  BOTTOM w0.102: v2(12.41,6.65) 12.56,6.5 13.02,6.5 13.25,6.26 JNGFF3.43
PCIE_PRX_DTX_N10: length 185.8
  TOP w0.089: v2(120.54,105.33) 120.95,104.92 UH1.G29
  IN1 w0.089: 112.37,103.54 112.45,103.46 112.65,103.46 113.94,102.17 118.47,102.17 119.98,103.68 119.98,104.68 120.27,104.97 120.42,104.97 120.54,105.09 v2(120.54,105.33)
  IN1 w0.109: 112.37,103.54 112.33,103.58 112.33,103.57 112.18,103.72 107.23,103.72 106.28,102.76 106.1,102.76 105.4,102.76 63.96,61.32 56.84,61.32 54.2,63.96 27.61,63.96 26.63,62.98 26.63,53.39 24.24,51.01 24.24,39.32 21.6,36.68 19.03,36.68 14.3,31.96 14.3,17.52 15.43,16.39 15.43,15.34 13.2,13.1 11.59,13.1 9.71,11.23 v2(9.71,8.9)
  BOTTOM w0.102: v2(9.71,8.9) 9.9,8.72 9.9,5.14 9.75,5 JNGFF3.29
PCIE_PRX_DTX_N11: length 184.8
  TOP w0.089: UH1.L31 v2(119.5,107.62)
  IN1 w0.089: 112.37,107.21 116.95,107.21 117.45,107.72 118.6,107.72 118.93,107.38 119.26,107.38 v2(119.5,107.62)
  IN1 w0.109: 112.37,107.21 107.67,107.21 106.24,105.77 102.12,105.77 100.6,104.25 100.6,101.78 92.37,93.54 92.37,92.4 63.8,63.84 57.19,63.84 55.18,65.85 26.82,65.85 24.74,63.77 24.74,54.18 20.35,49.79 20.35,48.57 15.07,43.29 15.07,40.34 7.31,32.58 7.31,9.32 v2(7.28,9.3)
  BOTTOM w0.102: v2(7.28,9.3) 7.48,9.1 7.48,8.41 6.86,7.79 6.86,4.9 6.75,4.8 JNGFF3.17
PCIE_PRX_DTX_N12: length 191
  TOP w0.089: UH1.G33 118.81,105.11 v2(118.46,105.46)
  TOP w0.102: v2(17.68,38.23) 17.55,38.36 17.16,38.36 1.59,22.79 v4(1.59,19.63) 1.59,11.35 4.07,8.87 4.07,6.28 3.83,6.05 3.61,6.05 v2(3.38,5.82)
  IN1 w0.089: v2(118.46,105.46) 118.6,105.61 118.78,105.61 118.91,105.48 118.91,104.57 118.56,104.22 116.44,104.22 116.37,104.16 115.8,104.16 115.5,104.47 115.5,104.47 114.97,104.99 114.37,104.99 114.37,104.99 114.02,104.99 113.46,105.55 112.4,105.55 112.39,105.56 112.37,105.56
  IN1 w0.109: v2(17.68,38.23) 17.51,38.39 16.66,38.39 15.89,39.17 15.89,42.15 20.98,47.23 20.98,49.52 25.37,53.92 25.37,63.5 27.08,65.22 54.86,65.22 56.92,63.16 64.02,63.16 93.07,92.22 93.07,93.36 101.27,101.56 101.83,101.56 102.99,102.72 102.99,103.36 104.17,104.54 106.02,104.54 107.04,105.56 112.37,105.56
  BOTTOM w0.102: JNGFF3.5 3.75,4.96 3.88,5.09 3.94,5.09 4.04,5.2 4.04,6.09 3.9,6.24 3.8,6.24 v2(3.38,5.82)
PCIE_PRX_DTX_N15: length 145.2
  TOP w0.089: UH1.F41 114.83,104.52 v2(114.74,104.43)
  TOP w0.102: CN76.1 26.33,33.85 26.18,34.01 26.18,34.54 26.46,34.82 v2(26.51,34.82)
  IN3 w0.089: v2(114.74,104.43) 114.63,104.32 114.63,104.15 114.72,104.06 115.09,104.06 115.34,104.31 115.34,104.58 115.12,104.79 113.98,104.79 113.26,105.51 112.4,105.51 112.38,105.49 112.37,105.49
  IN3 w0.127: v2(26.51,34.82) 26.43,34.82 26.1,35.14 26.1,35.77 21.71,40.16 21.71,52.33 24.12,54.74 24.12,61.47 29.22,66.57 56.21,66.57 57.92,64.87 62.95,64.87 101.29,103.21 102.15,103.21 102.59,103.65 102.59,105.11 102.98,105.49 103.15,105.49 112.37,105.49
PCIE_PRX_DTX_N16: length 127.5
  TOP w0.089: UH1.D43 114.07,103.74 114.18,103.61 v2(114.16,103.38)
  TOP w0.102: CN80.1 36.96,34.1 36.96,34.38 36.73,34.61 36.17,34.61 35.76,35.03 34.32,35.03 34.18,35.17 34.18,35.34 v2(34.4,35.55)
  IN3 w0.089: 112.37,104.8 112.38,104.8 112.4,104.81 112.47,104.81 112.47,104.82 112.75,104.82 113.65,103.92 114.03,103.92 114.16,103.78 v2(114.16,103.38)
  IN3 w0.127: 112.37,104.8 105.99,104.8 105.49,104.29 104.22,104.29 102.41,102.48 102.41,101.78 102.02,101.38 100.43,101.38 63.15,64.11 50.13,64.11 48.49,62.47 48.49,54.25 46.21,51.96 37.44,51.96 34.33,48.85 34.33,36.45 34.2,36.32 34.2,35.75 v2(34.4,35.55)
PCIE_PRX_DTX_N17: length 266.5
  TOP w0.101: v2(115.07,105.42) 115.09,105.42 114.77,105.74 UH1.H42
  IN4 w0.109: v2(115.07,105.42) 115.36,105.13 115.36,103.58 115.57,103.37 115.57,102.93 116.44,102.06 117.55,102.06 120.02,99.59 120.2,99.59 125.65,99.59 125.81,99.75 128.1,99.75 129.49,98.36 145.19,98.36 145.94,97.61 151.66,97.61 152.41,98.36 152.79,98.36 153.14,98.71 155.6,98.71 157.84,96.48 158.99,96.48 159.2,96.27 159.2,96.15 159.97,95.38 160.22,95.38 163.52,95.38 164.48,94.42 164.66,94.42 164.66,94.42 165.05,94.42 167.25,92.22 169.21,92.22 169.88,91.55 169.88,90.47 170.87,89.48 173.75,89.48 174.33,88.9 176.85,88.9 177.24,88.52 179.65,88.52 180.16,88.01 204.29,88.01 205.34,86.96 208.26,86.96 209.47,85.74 211.13,84.08 217.87,84.08 219.81,82.15 223.42,82.15 224.15,81.42 237.11,81.42 237.58,81.9 241.13,81.9 241.79,81.24 245.04,81.24 246.17,80.1 246.17,77.76 250.51,73.42 250.51,70.48 250.66,70.33 250.66,66.97 249.84,66.15 249.84,62.14 252.05,59.94 257,59.94 264.41,52.52 266.05,52.52 276.13,42.44 280.28,42.44 281.29,41.42 282.51,41.42 282.9,41.03 288.23,41.03 288.4,40.86 290.25,40.86 291.08,40.02 296.91,40.02 297.29,40.4 299.89,40.4 300.29,40 306.22,40 307.11,40.89 311.78,40.89 312.33,40.34 312.9,39.77 315.12,39.77 316.45,41.1 317.47,41.1 317.91,41.54 318.53,41.54 319.01,42.01 319.77,42.01 320.35,42.59 321.55,42.59 322.74,43.79 323.69,43.79 324.57,42.91 325.04,42.91 325.31,43.18 325.31,43.41 v2(325.51,43.6)
  BOTTOM w0.102: JNGFF2.35 327.55,33.93 327.47,33.85 327.47,33.71 327.4,33.64 327.19,33.64 326.23,34.6 326.23,39.51 325.26,40.47 325.26,42.95 325.21,43 325.21,43.47 325.34,43.6 v2(325.51,43.6)
PCIE_PRX_DTX_N18: length 263.4
  TOP w0.089: v2(116.7,105.96) 117.06,106.32 UH1.K37
  TOP w0.102: v2(328.63,45.54) 328.81,45.36 329.16,45.36 329.82,44.7 330.36,44.7 v4(330.79,44.27) 331.2,43.86 UZ29.14
  IN4 w0.109: v2(116.7,105.96) 117.56,105.1 117.56,103.22 120.41,100.36 122.31,100.36 122.43,100.48 128.76,100.48 130,99.23 130.62,99.23 131.2,99.81 131.69,99.81 131.89,99.61 136.15,99.61 136.5,99.97 136.5,100.23 138.49,102.22 143.47,102.22 144.15,101.54 144.15,100.69 145.86,98.98 147.9,98.98 148.4,98.47 151.07,98.47 152.21,99.61 155.96,99.61 157.17,98.41 159.07,98.41 159.77,97.71 160.09,97.71 161.57,96.22 164,96.22 164.95,95.27 165.59,95.27 167.62,93.24 169.4,93.24 170.73,91.9 172,91.9 172.68,91.22 172.68,91.08 173.44,90.32 174.1,90.32 174.65,89.77 178.62,89.77 179.02,89.37 179.99,89.37 180.48,88.88 204.61,88.88 205.69,87.8 208.61,87.8 211.48,84.93 218.23,84.93 218.48,84.67 226.06,84.67 228.45,82.28 236.77,82.28 237.29,82.8 241.67,82.8 242.26,82.21 245.25,82.21 247.01,80.45 247.01,79.62 248.48,78.15 248.48,77.45 251.36,74.58 251.36,70.83 251.5,70.69 251.5,66.36 250.69,65.55 250.69,62.49 252.4,60.78 257.35,60.78 264.76,53.37 266.4,53.37 276.44,43.33 280.7,43.33 281.65,42.37 282.87,42.37 283.37,41.88 288.64,41.88 288.82,41.7 297.05,41.7 297.51,41.25 300.43,41.25 300.83,40.85 305.87,40.85 307.3,42.27 311.6,42.27 312.58,41.29 313.25,40.62 314.78,40.62 316.11,41.96 317.13,41.96 317.56,42.38 318.14,42.38 318.61,42.86 319.37,42.86 319.95,43.44 321.2,43.44 321.92,44.17 321.92,44.68 322.56,45.32 327.64,45.32 327.77,45.45 328.54,45.45 v2(328.63,45.54)
PCIE_PRX_DTX_P2: length 131.7
  TOP w0.089: UH1.G17 127.17,105.03 127.29,105.15
  TOP w0.102: 127.29,105.15 v2(127.52,105.38)
  IN1 w0.109: v2(210.76,118.8) 209.43,118.8 208.26,119.97 208.26,122.53 205.02,125.78 205.02,126.81 205.02,127.33 197.98,134.37 196.72,134.37 192.77,138.32 191.79,138.32 191.64,138.18 169.64,138.18 169.64,138.18 169.12,138.18 169.12,138.18 168.69,138.18 167.63,137.12 167.63,135.64 167.09,135.1 167.09,134.54 168.17,133.46 168.17,132.41 167.84,132.09 167.84,122.97 166.19,121.32 166.19,120.55 164.36,118.71 164.36,114.44 163.77,113.85 162.64,113.85 162.13,113.34 162.13,109.6 161.21,108.68 161.21,108.67 161.15,108.61 161.15,108.11 160.49,107.45 160.21,107.45 158.89,106.13 157.33,106.13 153.94,102.74 153.94,102.41 v2(153.81,102.28)
  IN4 w0.109: v2(153.81,102.28) 153.9,102.19 153.9,101.86 153.66,101.62 147.92,101.62 147.67,101.87 146.53,101.87 144.17,104.23 141.5,104.23 141.49,104.22 138.47,104.22 135.55,101.3 133.82,101.3 133.06,102.06 131.12,102.06 130.85,102.34 129.95,102.34 128.21,104.07 128.21,104.7 127.92,104.99 127.61,104.99 127.46,105.14 127.46,105.32 v2(127.52,105.38)
  BOTTOM w0.102: JNGFF1.33 211.91,118.7 211.75,118.54 211.02,118.54 v2(210.76,118.8)
PCIE_PRX_DTX_P3: length 231.7
  TOP w0.089: UH1.K17 127.3,106.55 127.34,106.6
  TOP w0.102: v2(305.85,43.52) 305.85,43.39 305.73,43.27 305.61,43.27 305.54,43.2 v4(305.54,40.99) 305.54,40.01 307.21,38.35 309.65,38.35 309.81,38.52 310.69,38.52 310.74,38.57 310.74,38.71 310.83,38.8 JIO1.40 ; 127.34,106.6 v2(127.65,106.91)
  IN4 w0.089: v2(127.65,106.91) 127.85,107.1 127.96,107.1 128.02,107.05 128.02,105.85 128.68,105.19
  IN4 w0.109: 128.68,105.19 128.99,104.88 128.99,103.82 130.13,102.67 130.94,102.67 131.35,102.27 136.08,102.27 138.28,104.48 141.42,104.48 141.59,104.65 144.54,104.65 146.32,102.86 147.02,102.86 147.21,102.67 153.37,102.67 153.97,103.27 155.49,103.27 156.89,101.87 160.46,101.87 162.26,100.07 162.95,100.07 164.03,98.99 164.97,98.99 165.72,98.24 165.72,97.8 167.55,95.97 167.87,95.97 168.12,95.72 171.37,95.72 172.61,94.48 172.61,93.9 173.74,92.77 175.65,92.77 176.97,91.45 181.39,91.45 182.22,92.29 182.22,92.81 182.53,93.11 182.92,93.11 185.29,90.74 203.04,90.74 203.35,91.05 205.2,91.05 205.58,90.67 206.19,90.67 206.86,90 207.36,90 207.88,89.48 209.3,89.48 210.35,88.43 221.66,88.43 224.44,91.21 228.71,91.21 231.11,88.8 235.75,88.8 237.82,86.74 238.4,86.74 239.54,85.6 245.62,85.6 248.35,82.87 248.35,81.49 248.69,81.15 248.69,80.31 250.52,78.47 250.52,77.91 253.66,74.78 253.66,72.73 254.78,71.61 254.78,69.9 256.3,68.39 256.3,67.55 257.53,66.32 257.53,63.23 265.7,55.06 267.17,55.06 275.69,46.53 280.17,46.53 281.74,44.97 284.67,44.97 285.51,44.13 288.94,44.13 289.02,44.05 289.02,44.05 289.63,43.44 299.26,43.44 299.78,42.92 301.13,42.92 301.21,42.84 301.84,42.84 301.93,42.74 305.2,42.74 305.57,43.11 305.57,43.23 v2(305.85,43.52)
PCIE_PRX_DTX_P4: length 201.2
  TOP w0.089: v2(126.23,105.28) 125.87,104.92 UH1.G19
  TOP w0.102: v2(257.65,107.68) 257.47,107.87 257.19,107.87 C458.2
  IN1 w0.089: v2(126.23,105.28) 126.03,105.08 125.86,105.08 125.57,104.79 125.57,102.72 122.78,99.93 122.78,99.28 ; 141.76,109.92 139.34,109.92 138.1,108.67 138.1,105.35 136.51,103.76 136.51,102.77 134.87,101.13 133.31,101.13 132.71,101.73 131.28,101.73 130.5,100.95 130.5,100.76 130.17,100.43 128.72,100.43 127.58,99.28
  IN1 w0.109: 127.58,99.28 125.89,97.59 123.45,97.59 122.78,98.27 122.78,99.28 ; v2(257.65,107.68) 257.47,107.87 256.89,107.87 252.98,103.95 248.23,103.95 247.48,104.71 247.06,104.71 245.91,105.85 244.9,105.85 242.93,107.82 235.72,107.82 229.71,113.83 227.78,113.83 225.09,116.52 225.09,126.33 215.54,135.88 215.54,135.93 211.33,140.14 200.49,140.14 199.98,140.65 197.5,140.65 197.09,141.05 191.43,141.05 191,141.49 179.23,141.49 178.73,140.99 176.39,140.99 175.82,141.56 169.9,141.56 168.5,140.16 168.25,140.16 166.58,138.49 165.69,138.49 165.4,138.2 165.4,133.1 166.06,132.44 166.06,125.15 162.41,121.5 162.41,119.97 162.03,119.59 160.76,119.59 159.43,118.26 158.49,118.26 155.73,115.5 153.88,115.5 153.51,115.86 150.87,115.86 150.77,115.97 149.58,115.97 147.85,114.23 146,114.23 145.27,113.49 145.27,111.46 143.72,109.92 141.76,109.92
