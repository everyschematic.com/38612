# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MXM_DPA_P0_C: length 3.1
  BOTTOM w0.102: C545.2 160.37,110.87 160.37,111.13 v4(159.89,111.61) 159.62,111.88 159.62,112.44 159.69,112.51 UV2.6
MXM_DPA_P1: length 29.9
  TOP w0.102: v2(147.99,89.64) 148.04,89.59 148.19,89.59 148.26,89.67 148.26,89.9 148.32,89.96 148.5,89.96 148.65,89.81 148.65,89.04 148.73,88.95 148.73,88.88 148.66,88.82 148.55,88.82 148.5,88.77 JMXM1.291
  IN1 w0.117: v2(158.62,108.98) 158.49,108.85 158.49,108.19 158.09,107.79 156.65,107.79 152.52,103.66 151.27,103.66 150.78,103.17 150.78,100.43 151.11,100.1 151.11,97.6 150.89,97.37 150.89,96.1 148.73,93.95 148.73,89.92 148.49,89.68 148.03,89.68 v2(147.99,89.64)
  BOTTOM w0.102: v2(158.62,108.98) 158.55,108.98 158.41,109.13 158.41,109.28 C551.1
MXM_DPA_P1_C: length 2.8
  BOTTOM w0.102: UV2.9 158.49,112.51 158.42,112.44 158.42,110.91 C551.2
MXM_DPA_P2: length 30.8
  TOP w0.102: JMXM1.297 147,88.74 147.06,88.81 147.18,88.81 147.23,88.86 147.23,89.84 147.07,89.99 146.95,89.99 146.91,89.95 146.91,89.73 146.85,89.67 v2(146.63,89.67)
  IN1 w0.117: v2(146.63,89.67) 146.78,89.82 147.11,89.82 147.36,90.08 147.36,94.17 149.38,96.19 149.38,96.34 149.84,96.79 149.84,102.72 149.11,103.45 149.11,105.44 150.05,106.38 151.1,106.38 152.69,107.97 154.87,107.97 v2(155.02,107.82)
  BOTTOM w0.102: C573.1 156.87,108.59 156.1,107.82 v2(155.02,107.82)
MXM_DPA_P2_C: length 3.1
  BOTTOM w0.102: C573.2 156.57,110.86 156.57,111.09 157.22,111.74 157.22,112.44 157.29,112.51 UV2.12
MXM_DPA_P3: length 34
  TOP w0.102: v2(144.99,89.77) 145.24,89.77 145.29,89.82 145.29,90.04 145.34,90.09 145.49,90.09 145.73,89.85 145.73,89.07 145.66,89.01 145.57,89.01 145.5,88.93 JMXM1.303
  IN1 w0.117: v2(151.24,108.48) 151.24,108.61 151.32,108.69 151.45,108.69 151.52,108.77 151.52,108.89 151.46,108.96 149.46,108.96 148.19,107.69 148.19,106.42 147.33,105.56 147.33,104.66 148.2,103.79 148.2,103.08 148.47,102.8 148.47,102.57 148.47,96.57 145.84,93.94 145.84,90.32 145.59,90.07 145.34,90.07 145.29,90.02 145.29,89.83 145.23,89.77 v2(144.99,89.77)
  BOTTOM w0.102: v2(151.24,108.48) 151.22,108.47 151.22,108.46 151.66,108.02 151.66,107.78 151.87,107.56 v4(152.3,107.56) 154.15,107.56 154.53,107.94 154.53,108.61 154.72,108.8 154.88,108.96 154.89,108.97 154.89,109.28 154.97,109.35 C577.1
MXM_DPA_P3_C: length 3.8
  BOTTOM w0.102: UV2.15 156.09,112.74 156.02,112.67 156.02,111.76 155.47,111.21 154.79,111.21 154.61,111.03 154.61,110.91 C577.2
MXM_DPB_AUXN: length 44.6
  TOP w0.102: v2(174.06,96.87) 174.06,97.9 R3747.2 ; JMXM1.298 146.25,80.5 146.66,80.92 146.66,81.32 150.58,85.24 168.16,85.24 168.65,85.73 168.65,86.24 168.36,86.53 v2(168.36,86.86)
  IN1 w0.117: v2(174.06,96.87) 174.26,96.67 174.37,96.67 174.79,96.24 174.79,92.96 173.05,91.22 173.05,90.77 170.69,88.41 169.72,88.41 168.36,87.05 v2(168.36,86.86)
  BOTTOM w0.102: C627.1 174.59,96.48 174.45,96.48 174.27,96.65 174.27,96.76 174.16,96.87 v2(174.06,96.87) 173.88,96.7 173.87,96.7 173.63,96.46 173.63,96.41 173.62,96.39 173.27,96.04 U636.22
MXM_DPB_AUXN_C: length 5.8
  TOP w0.102: v2(173.79,93.95) 174.37,93.95 174.54,94.12 175.53,95.11 175.53,95.96 175.74,96.17 176.11,96.17 v2(176.25,96.31)
  BOTTOM w0.102: C627.2 176.03,96.16 176.1,96.16 v2(176.25,96.31) ; U636.27 173.68,94.04 173.79,93.92 v2(173.79,93.95)
MXM_DPB_AUXP: length 47.1
  TOP w0.102: v1(172.67,92.91) 173.11,93.34 R3745.2 173.11,94.94 173.32,95.15 173.32,96.11 173.5,96.29 v2(174.04,96.29) ; JMXM1.300 145.75,80.7 145.9,80.86 146.22,80.86 146.4,81.03 146.4,81.43 150.47,85.5 168.05,85.5 168.38,85.84 168.38,86.13 168.04,86.46 v2(167.92,86.46)
  IN1 w0.117: v2(167.92,86.46) 167.87,86.51 167.87,86.97 169.6,88.7 170.57,88.7 172.76,90.89 172.76,91.33 174.51,93.08 174.51,96.13 174.29,96.35 174.1,96.35 v2(174.04,96.29)
  BOTTOM w0.102: C601.1 174.64,95.69 v2(174.04,96.29) 173.88,96.29 173.82,96.21 173.56,95.96 173.56,95.82 173.38,95.64 U636.23
MXM_DPB_AUXP_C: length 5.8
  TOP w0.102: v2(176.22,95.68) 176,95.9 175.85,95.9 175.8,95.85 175.8,95 174.65,93.86 174.65,93.86 174.48,93.68 174.35,93.68 v2(174.1,93.43)
  BOTTOM w0.102: U636.28 173.51,93.64 173.71,93.43 v2(174.1,93.43) ; v2(176.22,95.68) 176,95.89 175.81,95.89 C601.2
MXM_DPB_HPD: length 58.6
  TOP w0.102: U14.2 150.86,75.71 D18.2 151.53,76.93 150.73,77.73 150.17,77.73 v2(149.93,77.97)
  IN2 w0.127: v2(139.89,90.98) 139.49,90.58 139.49,88.63 140.4,87.71 149.78,87.71 150.22,88.16 150.22,91.05 152.02,92.86 154.03,92.86 157.65,96.48 159.05,96.48 159.62,95.91 163.11,95.91 165.12,97.91 v2(165.12,98.18)
  IN3 w0.127: v2(149.93,77.97) 149.93,78.49 140.51,87.9 139.23,89.18 139.23,90.33 v2(139.89,90.98)
  BOTTOM w0.102: v2(165.12,98.18) 165.12,98.18 165.38,97.92 U636.3
MXM_DPB_HPD_GATE: length 6
  TOP w0.102: U14.4 147.27,76.36 147.14,76.5 147.14,76.98 R758.1 147.07,77.49 v1(146.67,77.89) 146.24,78.32 145.87,78.32 145.25,78.95 JMXM1.302
MXM_DPB_N0: length 47.4
  TOP w0.102: JMXM1.274 152.25,80.55 152.24,80.55 152.11,80.69 152.11,81.24 152.68,81.81 169.02,81.81 170.29,83.08 171.34,83.08 173.73,85.47 173.73,85.78 v2(173.94,86)
  IN3 w0.127: v2(173.94,86) 173.78,86.16 173.78,87.59 171.35,90.01 171.35,92.26 169.59,94.02 169.59,95.13 166.84,97.88 166.84,99.85 164.43,102.27 164.43,102.53 v2(164.61,102.71)
  BOTTOM w0.102: C585.1 164.45,102.08 164.45,102.55 v2(164.61,102.71)
MXM_DPB_N0_C: length 4.2
  BOTTOM w0.102: U636.2 164.98,97.58 164.27,98.29 v4(164.27,98.5) 164.27,99.97 164.46,100.16 164.46,100.55 C585.2
MXM_DPB_N1: length 54.2
  TOP w0.102: v2(172.87,86.83) 172.71,86.67 172.71,85.94 170.63,83.85 170,83.85 168.71,82.56 152.03,82.56 150.63,81.16 150.63,80.74 150.75,80.63 JMXM1.280
  IN3 w0.127: v2(172.87,86.83) 172.63,87.06 172.63,87.4 170.15,89.89 170.15,92.13 167.91,94.37 167.91,95.48 165.9,97.49 165.9,99.46 163.39,101.98 163.39,102.99 163.64,103.25 165.64,103.25 165.96,103.56 165.96,103.82 v2(166.1,103.97)
  BOTTOM w0.102: C589.1 165.66,100.3 165.66,102.01 165.94,102.29 165.94,103.81 v2(166.1,103.97)
MXM_DPB_N1_C: length 2.2
  BOTTOM w0.102: C589.2 165.78,98.81 165.78,98.61 166.09,98.29 166.09,97.7 166.18,97.62 U636.5
MXM_DPB_N2: length 56.6
  TOP w0.102: v2(171.46,86.37) 171.25,86.16 171.25,85.63 170.22,84.6 169.69,84.6 168.39,83.31 151.41,83.31 149.13,81.02 149.13,80.66 149.25,80.55 JMXM1.286
  IN3 w0.127: v2(171.46,86.37) 171.34,86.5 171.34,87.36 168.91,89.78 168.91,91.82 166.97,93.76 166.97,95.09 164.69,97.38 164.69,98.94 162.22,101.41 162.22,101.75 162.45,101.98 162.45,103.38 163.33,104.26 164.05,104.26 164.45,104.67 165.32,104.67 166.45,104.67 166.73,104.95 166.73,105.33 166.82,105.42 v2(166.9,105.5)
  BOTTOM w0.102: v2(166.9,105.5) 166.82,105.42 166.68,105.28 v4(166.68,104.84) 166.68,104.59 166.93,104.34 166.93,102.27 C592.1
MXM_DPB_N2_C: length 4
  BOTTOM w0.102: U636.7 166.98,97.68 166.91,97.75 166.91,99.26 167,99.34 167,100.68 C592.2
MXM_DPB_N3: length 63.6
  TOP w0.102: JMXM1.292 147.75,80.53 147.63,80.64 147.63,81.06 150.63,84.06 168.04,84.06 169.35,85.36 169.52,85.36 169.79,85.63 169.79,85.94 169.91,86.05 v2(170.16,86.05)
  IN3 w0.127: v2(167.36,104.58) 167.47,104.48 167.58,104.48 167.83,104.73 167.83,105.45 167.16,106.13 165.79,106.13 165.4,106.52 163.44,106.52 161.95,105.04 161.95,104.22 161.51,103.77 161.51,102.37 161.28,102.14 161.28,101.02 163.75,98.55 163.75,96.59 166.03,94.3 166.03,93.29 167.75,91.57 167.75,89.3 169.54,87.51 169.54,86.49 169.66,86.38 169.66,85.62 169.75,85.53 169.94,85.53 170.16,85.74 v2(170.16,86.05)
  BOTTOM w0.102: C595.1 168.36,100.27 168.36,103.84 167.78,104.41 167.53,104.41 v2(167.36,104.58)
MXM_DPB_N3_C: length 2.3
  BOTTOM w0.102: U636.10 168.18,97.62 168.11,97.68 168.11,98.23 168.23,98.35 168.23,98.86 C595.2
MXM_DPB_P0: length 47.4
  TOP w0.102: JMXM1.276 151.75,80.54 151.84,80.63 151.84,81.35 152.57,82.07 168.91,82.07 170.18,83.34 171.23,83.34 173.46,85.58 173.46,85.74 v2(173.21,85.99)
  IN3 w0.127: v2(173.21,85.99) 173.47,86.26 173.47,87.46 171.05,89.89 171.05,92.13 169.28,93.89 169.28,95.01 166.54,97.75 166.54,99.73 164.13,102.14 164.13,102.61 v2(164.02,102.71)
  BOTTOM w0.102: v2(164.02,102.71) 164.18,102.55 164.18,102.08 C587.1
MXM_DPB_P0_C: length 4.2
  BOTTOM w0.102: C587.2 164.19,100.54 164.19,100.27 164,100.08 v4(164,99.76) 164,98.18 164.58,97.6 U636.1
MXM_DPB_P1: length 54.2
  TOP w0.102: v2(172.11,86.82) 172.45,86.48 172.45,86.05 170.52,84.12 169.89,84.12 168.59,82.82 151.92,82.82 150.36,81.27 150.36,80.75 150.25,80.64 JMXM1.282
  IN3 w0.127: v2(172.11,86.82) 172.32,87.04 172.32,87.28 169.84,89.76 169.84,92.01 167.61,94.24 167.61,95.36 165.6,97.36 165.6,99.34 163.09,101.85 163.09,103.12 163.52,103.55 165.51,103.55 165.65,103.69 165.65,103.84 v2(165.52,103.97)
  BOTTOM w0.102: v2(165.52,103.97) 165.68,103.81 165.68,102.4 165.4,102.12 165.4,100.24 C590.1
MXM_DPB_P1_C: length 2.2
  BOTTOM w0.102: U636.4 165.78,97.13 165.78,97.54 165.83,97.59 165.83,98.18 165.51,98.5 165.51,98.65 C590.2
MXM_DPB_P2: length 56.6
  TOP w0.102: v2(170.72,86.35) 170.98,86.08 170.98,85.74 170.11,84.87 169.58,84.87 168.28,83.57 151.3,83.57 148.86,81.13 148.86,80.7 148.75,80.59 JMXM1.288
  IN3 w0.127: v2(170.72,86.35) 171.03,86.66 171.03,87.24 168.61,89.66 168.61,91.69 166.67,93.63 166.67,94.97 164.38,97.25 164.38,98.82 161.92,101.28 161.92,101.87 162.15,102.1 162.15,103.51 163.2,104.57 163.92,104.57 164.33,104.97 165.19,104.97 165.19,104.97 165.97,104.97 165.97,104.97 166.32,104.97 166.43,105.07 166.43,105.38 v2(166.31,105.5)
  BOTTOM w0.102: v2(166.31,105.5) 166.41,105.39 166.41,104.48 166.67,104.23 v4(166.67,102.95) 166.67,102.15 C594.1
MXM_DPB_P2_C: length 4.1
  BOTTOM w0.102: U636.6 166.58,97.68 166.64,97.75 166.64,99.37 166.73,99.45 166.73,100.67 C594.2
MXM_DPB_P3: length 63.7
  TOP w0.102: v2(169.24,86.13) 169.33,86.13 169.52,85.94 169.52,85.74 169.41,85.63 169.24,85.63 167.93,84.32 150.52,84.32 147.37,81.17 147.37,80.63 147.25,80.5 JMXM1.294
  IN3 w0.127: v2(169.24,86.13) 169.24,87.38 167.44,89.17 167.44,91.45 165.73,93.16 165.73,94.18 163.44,96.46 163.44,98.43 160.98,100.89 160.98,102.26 161.21,102.49 161.21,103.9 161.65,104.34 161.65,105.16 163.31,106.83 165.53,106.83 165.92,106.44 167.28,106.44 168.14,105.58 168.14,104.6 167.7,104.16 167.53,104.16 v2(167.37,104)
  BOTTOM w0.102: v2(167.37,104) 167.48,104.12 167.7,104.12 168.09,103.73 v4(168.09,103.14) 168.09,100.01 168.04,99.96 167.78,99.96 C596.1
MXM_DPB_P3_C: length 2.3
  BOTTOM w0.102: C596.2 167.97,98.86 167.97,98.46 167.84,98.34 167.84,97.68 167.78,97.62 U636.9
MXM_DPC_AUXN: length 67.9
  TOP w0.102: v2(157.97,89.4) 157.8,89.24 157.8,88.96 158,88.76 JMXM1.253
  IN1 w0.117: v2(157.97,89.4) 157.71,89.4 157.62,89.49 157.62,89.65 156.86,90.41 156.81,90.41 154.49,92.74 154.49,100.06 156.19,101.76 156.19,102.51 157.4,103.72 158.56,103.72 158.79,103.94 160.49,103.94 162.54,105.99 162.95,105.99 164.38,107.42 164.38,111.73 165.08,112.44 165.08,112.88 166.76,114.55 166.76,118.33 167.95,119.52 167.95,120.62 168.2,120.86 168.97,120.86 170.46,122.35 170.46,123.27 170.67,123.48 170.67,125.79 170.5,125.96 169.43,127.02 169.43,131.38 169.84,131.78 169.84,134.45 169.59,134.7 169.22,135.07 169.22,136.47 169.33,136.58 169.52,136.58 v2(169.77,136.33) 169.92,136.48 170.44,136.48 170.55,136.36 170.55,135.85 171.35,135.05 171.53,135.05 v2(171.68,134.91)
  BOTTOM w0.102: v2(171.68,134.91) 171.77,134.99 171.91,134.99 172.11,134.79 172.72,134.79 172.97,135.04 173.1,135.04 173.23,134.91 U629.22 ; C531.1 170.13,136.48 169.92,136.48 v2(169.77,136.33) 169.61,136.49 169.43,136.49 R132.2
MXM_DPC_AUXN_C: length 2.8
  BOTTOM w0.102: C531.2 171.65,136.49 172,136.49 v4(172.36,136.85) 172.55,137.04 173.17,137.04 173.3,136.91 U629.27
MXM_DPC_AUXP: length 68
  TOP w0.102: v2(157.22,89.42) 157.22,89.42 v2(157.22,89.42) ; v2(157.22,89.42) 157.53,89.1 157.53,88.8 157.49,88.77 JMXM1.255
  IN1 w0.117: v2(157.22,89.42) 157.22,89.65 156.74,90.13 156.7,90.13 154.2,92.62 154.2,99.94 154.2,100.18 155.9,101.88 155.9,102.63 157.28,104 158.45,104 158.67,104.22 160.37,104.22 162.42,106.27 162.83,106.27 164.09,107.53 164.09,111.85 164.8,112.56 164.8,112.99 166.48,114.67 166.48,118.45 167.67,119.64 167.67,120.73 168.08,121.14 168.85,121.14 170.17,122.47 170.17,123.39 170.38,123.6 170.38,125.67 169.15,126.91 169.15,131.49 169.56,131.9 169.56,134.33 169.47,134.42 168.93,134.95 168.93,136.59 169.21,136.86 169.72,136.86 v2(169.77,136.92) 169.92,136.77 170.56,136.77 170.84,136.48 170.84,135.96 171.46,135.34 171.53,135.34 v2(171.68,135.49)
  BOTTOM w0.102: C532.1 170.1,136.74 169.95,136.74 v2(169.77,136.92) 169.61,136.76 169.43,136.76 R129.2 ; U629.23 172.86,135.31 172.61,135.06 172.22,135.06 171.79,135.49 v2(171.68,135.49)
MXM_DPC_AUXP_C: length 2.7
  BOTTOM w0.102: C532.2 171.65,136.76 171.89,136.76 172.44,137.31 U629.28
MXM_DPC_HPD: length 179.1
  TOP w0.102: U25.2 157.39,75.2 158.35,76.16 D7.2 158.35,76.92 v2(158.75,77.32)
  IN2 w0.127: v2(198.08,81.58) 192.15,81.58 190.73,80.16 184.83,80.16 184.26,79.59 176.7,79.59 176.38,79.27 157.71,79.27 156.98,78.53 156.98,77.78 157.44,77.32 v2(158.75,77.32) ; v2(224.83,136.74) 217.47,136.74 216.07,135.34 215.04,135.34 214.79,135.08 205.69,135.08 204.29,133.69 199.05,133.69 198.1,134.64 194.87,134.64 193.41,133.18 187.19,133.18 186.8,133.57 184.82,133.57 184.69,133.7 181.98,133.7 v2(181.19,132.91)
  IN3 w0.127: v2(224.83,136.74) 224.83,133.2 225.21,132.82 225.21,122.98 224.86,122.62 224.86,113.11 226.48,111.48 226.48,109.63 226.39,109.54 226.39,109.19 226.39,108.72 226.28,108.61 226.22,108.61 226.15,108.54 225.83,108.54 225.82,108.52 225.79,108.52 225.54,108.28 225.54,103.38 224.88,102.72 224.88,99.29 v2(228.19,95.99)
  BOTTOM w0.102: v2(228.19,95.99) 227.14,95.99 225.14,93.99 217.79,93.99 217.09,93.28 217.09,92.03 215.37,90.32 211.75,90.32 211.23,89.79 211.23,88.72 208.76,86.25 206.85,86.25 204.82,84.22 204.82,83.22 v1(202.83,81.23) 201.99,80.39 200.77,80.39 199.24,81.91 198.42,81.91 v2(198.08,81.58) ; U629.3 v2(181.19,132.91)
MXM_DPC_HPD_GATE: length 5.4
  TOP w0.102: JMXM1.262 155.25,77.67 v1(155.33,77.59) 155.9,77.59 156.24,77.25 R519.2 156.24,76.78 155.31,75.85 U25.4
MXM_DPC_N0: length 58.5
  TOP w0.102: JMXM1.229 164,87.96 163.99,87.96 163.99,88.68 163.89,88.78 163.89,88.94 163.97,89.02 166.31,89.02 167.65,90.37 167.65,94.1 167.92,94.37 167.92,96.72 166.62,98.03 166.62,99.13 166.73,99.24 v4(166.73,100.11) 166.73,102.62 166.6,102.75 166.6,103.5 166.79,103.69 166.79,104.48 166.48,104.8 166.22,104.8 165.9,105.11 165.9,105.66 166.24,106 167.07,106.83 167.77,107.53 167.97,107.53 v2(168.15,107.35)
  IN1 w0.117: v2(183.8,129.11) 183.94,129.11 184.02,129.2 184.02,129.29 184.16,129.42 184.16,129.55 184.07,129.64 183.58,129.64 183.38,129.43 183.38,128.3 181.39,126.31 180.68,126.31 178.82,124.45 176.82,124.45 174.82,122.45 174.82,120.53 171.95,117.65 171.95,114.99 170.91,113.95 170.91,112.86 170.75,112.7 170.75,109.92 168.96,108.13 168.29,108.13 167.81,107.65 167.81,107.5 167.96,107.35 v2(168.15,107.35)
  BOTTOM w0.102: C525.1 183.87,129.59 183.87,129.19 v2(183.8,129.11)
MXM_DPC_N0_C: length 4.3
  BOTTOM w0.102: C525.2 183.77,131.23 183.77,131.42 v4(183.19,132.01) 182.9,132.29 182.35,132.29 181.65,132.99 181.65,133.24 181.59,133.31 U629.2
MXM_DPC_N1: length 61.2
  TOP w0.102: JMXM1.235 162.5,88.71 162.27,88.94 162.27,89.22 162.81,89.77 165.85,89.77 166.54,90.46 166.54,91.17 166.54,92.1 166.7,92.25 166.7,94.23 167.17,94.71 167.17,96.41 165.79,97.8 165.79,99.83 v4(165.03,100.59) 163.55,102.06 163.55,103.33 165.16,104.93 165.16,105.98 165.71,106.53 166.29,107.11 166.29,108.03 166.47,108.21 167.03,108.21 167.38,108.55 167.38,108.88 167.5,109.01 v2(167.71,109.01)
  IN1 w0.117: v2(181.88,129.15) 181.88,129.17 182.18,129.47 182.18,129.58 182.12,129.64 181.54,129.64 181.42,129.52 181.42,127.74 180.99,127.31 180.29,127.31 179.83,126.85 178.35,126.85 178.03,126.53 178.03,125.97 177.72,125.66 175.02,125.66 173.63,124.27 173.63,121.67 170.92,118.96 170.92,117.97 170.92,117.97 170.92,117.66 170,116.74 170,113.23 168.52,111.75 168.12,111.75 167.83,111.46 167.83,109.78 167.28,109.23 167.28,108.88 167.34,108.82 167.52,108.82 v2(167.71,109.01)
  BOTTOM w0.102: v2(181.88,129.15) 182,129.26 182,129.63 C527.1
MXM_DPC_N1_C: length 3.8
  BOTTOM w0.102: U629.5 180.39,133.31 180.46,133.24 180.46,132.56 180.88,132.14 181.17,132.14 181.93,131.38 181.93,131.23 C527.2
MXM_DPC_N2: length 66.3
  TOP w0.102: v2(161,89.38) 160.79,89.38 160.72,89.31 160.72,89.02 161,88.75 JMXM1.241
  IN1 w0.117: v2(161,89.38) 160.82,89.56 160.63,89.56 160.53,89.45 160.53,89.21 160.51,89.18 160.51,89 160.68,88.82 161.28,88.82 161.58,89.12 161.58,89.63 161.3,89.91 159.85,89.91 158.92,90.84 157.81,91.95 157.45,91.95 156.04,93.35 156.04,99.45 157.72,101.12 157.72,101.57 158.28,102.13 161.24,102.13 162.61,103.5 166.4,103.5 166.6,103.7 166.6,104.22 165.61,105.21 165.61,105.79 165.91,106.08 165.91,110.33 166.62,111.04 166.62,111.94 167.63,112.94 168.02,112.94 168.44,113.36 168.44,116.92 169.73,118.21 169.73,119.45 172.44,122.16 172.44,125.13 174.93,127.62 177.42,127.62 177.99,128.19 178.99,128.19 179.31,128.51 180.07,128.51 180.22,128.66 180.22,129.18 180.15,129.25 v2(180,129.25)
  BOTTOM w0.102: C529.1 180.18,129.6 180.18,129.31 180.13,129.25 v2(180,129.25)
MXM_DPC_N2_C: length 3.3
  BOTTOM w0.102: U629.7 179.59,133.31 179.65,133.24 179.65,132.26 v4(179.93,131.98) 180.13,131.78 180.13,131.27 C529.2
MXM_DPC_N3: length 60.1
  TOP w0.102: JMXM1.247 159.49,88.73 159.26,88.96 159.26,89.13 159.5,89.36 v2(159.5,89.36)
  IN1 w0.117: v2(159.5,89.36) 159.43,89.29 159.43,89.13 159.37,89.07 159.17,89.07 159.05,89.2 159.05,89.81 157.53,91.32 157.19,91.32 155.4,93.11 155.4,99.69 157.1,101.38 157.1,102.06 157.8,102.76 160.99,102.76 162.56,104.33 164.24,104.33 164.99,105.08 164.99,106.05 165.28,106.34 165.28,110.59 166,111.3 166,112.5 167.81,114.31 167.81,117.28 169.06,118.53 169.06,119.67 171.37,121.97 171.37,122.89 171.58,123.1 171.58,125.15 174.67,128.25 177.08,128.25 177.84,129.01 177.84,129.43 177.97,129.57 178.36,129.57 178.45,129.48 178.45,129.3 v2(178.26,129.11)
  BOTTOM w0.102: C528.1 178.35,129.59 178.35,129.2 v2(178.26,129.11)
MXM_DPC_N3_C: length 3.1
  BOTTOM w0.102: C528.2 178.29,131.27 178.29,131.54 178.46,131.72 178.46,133.24 178.39,133.32 U629.10
MXM_DPC_P0: length 58.5
  TOP w0.102: v2(167.55,107.98) 167.6,107.92 167.6,107.74 166.96,107.09 166.05,106.19 165.64,105.78 165.64,105 166.11,104.53 166.37,104.53 166.53,104.37 166.53,103.8 166.34,103.61 166.34,102.64 166.46,102.51 v4(166.46,101.67) 166.46,99.35 166.35,99.24 166.35,97.92 167.66,96.61 167.66,94.48 167.38,94.21 167.38,90.48 166.2,89.29 163.86,89.29 163.62,89.05 163.62,88.86 163.5,88.73 JMXM1.231
  IN1 w0.117: v2(184.44,129.12) 184.44,129.67 184.19,129.92 183.46,129.92 183.09,129.55 183.09,128.42 181.27,126.6 180.56,126.6 178.7,124.73 176.7,124.73 174.54,122.57 174.54,120.64 171.66,117.77 171.66,115.11 170.62,114.07 170.62,112.98 170.46,112.82 170.46,110.04 168.84,108.41 168.17,108.41 167.73,107.98 v2(167.55,107.98)
  BOTTOM w0.102: v2(184.44,129.12) 184.14,129.42 184.14,129.8 C523.1
MXM_DPC_P0_C: length 4.3
  BOTTOM w0.102: U629.1 181.99,133.31 181.92,133.24 181.92,133.1 182.46,132.56 183.01,132.56 184.04,131.53 184.04,131.23 C523.2
MXM_DPC_P1: length 61.2
  TOP w0.102: JMXM1.237 162,88.82 162,88.83 162,89.33 162.7,90.04 165.74,90.04 166.27,90.57 166.27,91.06 166.27,91.06 166.27,92.21 166.43,92.36 166.43,94.34 166.91,94.82 166.91,96.3 165.52,97.69 165.52,99.72 v4(163.9,101.34) 163.29,101.95 163.29,103.45 164.89,105.05 164.89,106.09 166.02,107.22 166.02,108.14 166.36,108.48 166.92,108.48 167.11,108.66 167.11,108.97 166.87,109.21 166.86,109.21 166.86,109.21 v2(166.86,109.21)
  IN1 w0.117: v2(182.47,129.15) 182.47,129.7 182.24,129.93 181.42,129.93 181.13,129.64 181.13,127.85 180.87,127.59 180.17,127.59 179.71,127.13 178.24,127.13 177.75,126.65 177.75,126.08 177.61,125.94 174.91,125.94 173.35,124.38 173.35,121.79 170.64,119.07 170.64,117.85 170.64,117.78 169.71,116.86 169.71,113.35 168.4,112.03 168.01,112.03 167.55,111.57 167.55,109.9 v2(166.86,109.21)
  BOTTOM w0.102: C524.1 182.26,129.76 182.26,129.36 v2(182.47,129.15)
MXM_DPC_P1_C: length 3.8
  BOTTOM w0.102: U629.4 180.79,133.32 180.73,133.26 180.73,132.67 180.99,132.4 181.28,132.4 v4(181.64,132.04) 182.19,131.49 182.19,131.23 C524.2
MXM_DPC_P2: length 66.4
  TOP w0.102: JMXM1.243 160.5,88.87 160.46,88.91 160.46,89.29 160.36,89.38 v2(160.12,89.38)
  IN1 w0.117: v2(180.68,129.11) 180.51,128.94 180.51,128.54 180.19,128.23 179.43,128.23 179.11,127.91 178.11,127.91 177.54,127.34 175.05,127.34 172.72,125.01 172.72,122.04 170.01,119.33 170.01,118.09 168.72,116.8 168.72,113.24 168.14,112.66 167.75,112.66 166.92,111.83 166.92,110.94 166.91,110.93 166.19,110.21 166.19,105.97 165.9,105.67 165.9,105.32 166.88,104.34 166.88,103.58 166.52,103.22 162.73,103.22 161.36,101.84 158.4,101.84 158.01,101.45 158.01,101.01 156.33,99.33 156.33,93.47 157.57,92.23 157.93,92.23 159.12,91.04 159.97,90.19 161.42,90.19 161.86,89.75 161.86,89 161.4,88.54 160.56,88.54 160.22,88.88 160.22,89.28 v2(160.12,89.38)
  BOTTOM w0.102: C526.1 180.45,129.79 180.45,129.34 v2(180.68,129.11)
MXM_DPC_P2_C: length 3.2
  BOTTOM w0.102: U629.6 179.99,133.36 179.92,133.29 179.92,132.37 180.4,131.89 180.4,131.19 C526.2
MXM_DPC_P3: length 60
  TOP w0.102: JMXM1.249 159,88.98 v2(158.61,89.36)
  IN1 w0.117: v2(178.85,129.11) 178.74,129.22 178.74,129.59 178.48,129.85 177.86,129.85 177.55,129.55 177.55,129.12 176.96,128.53 174.56,128.53 171.29,125.27 171.29,123.22 171.08,123.01 171.08,122.09 168.77,119.78 168.77,118.65 167.52,117.4 167.52,114.43 165.71,112.62 165.71,111.42 165,110.71 165,106.46 164.7,106.16 164.7,105.2 164.12,104.62 162.44,104.62 160.87,103.05 157.68,103.05 156.81,102.18 156.81,101.5 155.12,99.8 155.12,92.99 157.07,91.04 157.41,91.04 158.68,89.77 158.68,89.43 v2(158.61,89.36)
  BOTTOM w0.102: v2(178.85,129.11) 178.62,129.34 178.62,129.8 C530.1
MXM_DPC_P3_C: length 3.1
  BOTTOM w0.102: U629.9 178.79,133.33 178.73,133.27 178.73,131.6 178.55,131.43 178.55,131.19 C530.2
MXM_EDP_AUXN: length 64.6
  TOP w0.102: v2(155.93,80.9) 155.93,80.74 156.25,80.42 JMXM1.258
  IN3 w0.127: v2(155.93,80.9) 155.74,81.08 155.74,81.29 154.84,82.19 153.78,82.19 148,87.97 147.1,87.97 146.22,88.84 146.22,89.49 146.21,89.5 146.21,90.43 146.22,90.44 146.22,92.02 145.9,92.34 145.9,95.46 145.55,95.82 145.55,96.32 146.33,97.11 146.33,103.25 145.06,104.52 145.06,105.43 145.06,106.32 146.4,107.65 146.4,109.68 145.36,110.73 145.36,113.6 146.28,114.52 146.28,121.33 146.52,121.57 146.52,122.91 144.77,124.66 144.44,124.66 144.05,125.05 144.05,127.97 142.84,129.18 142.84,129.67 v2(142.92,129.75)
  BOTTOM w0.102: v2(142.92,129.75) 142.75,129.92 142.75,130.27 142.45,130.58 141.51,130.58 v4(141.24,130.3) 140.62,129.69 139.84,129.69 139.73,129.8 139.73,130.03 C568.1
MXM_EDP_AUXN_C: length 9.1
  BOTTOM w0.102: C568.2 139.66,131.32 139.56,131.41 139.56,131.7 140.15,132.28 v4(140.15,132.79) 140.15,134.5 141.72,136.07 141.77,136.14 142.16,136.86 142.28,137.08 142.49,137.47 142.72,137.71 142.98,137.71 143.12,137.58 U630.29
MXM_EDP_AUXP: length 64.6
  TOP w0.102: JMXM1.260 155.75,80.5 v2(155.34,80.9)
  IN3 w0.127: v2(142.33,129.75) 142.54,129.55 142.54,129.05 143.74,127.85 143.74,124.92 144.31,124.35 144.65,124.35 146.22,122.78 146.22,121.7 145.98,121.46 145.98,114.65 145.05,113.72 145.05,110.6 146.09,109.56 146.09,107.78 144.76,106.45 144.76,105.56 144.76,105.56 144.76,104.39 146.03,103.12 146.03,97.24 145.24,96.45 145.24,95.69 145.6,95.33 145.6,92.21 145.91,91.9 145.91,90.56 145.91,90.56 145.91,89.37 145.91,89.37 145.91,88.72 146.97,87.66 147.87,87.66 153.65,81.88 154.72,81.88 155.43,81.17 155.43,80.99 v2(155.34,80.9)
  BOTTOM w0.102: v2(142.33,129.75) 142.49,129.9 142.49,130.16 142.34,130.31 141.62,130.31 140.73,129.42 v4(140.16,129.42) 139.73,129.42 139.46,129.69 139.46,130.01 C566.1
MXM_EDP_AUXP_C: length 9.1
  BOTTOM w0.102: U630.30 142.61,137.98 142.27,137.64 142.04,137.2 141.92,136.98 141.53,136.26 139.88,134.61 v4(139.88,134.16) 139.88,132.39 139.3,131.81 139.3,131.55 C566.2
MXM_EDP_HPD: length 70
  TOP w0.102: v2(154.24,81.04) 154.24,80.96 154.75,80.46 JMXM1.264
  IN2 w0.127: v2(139.05,127.85) 139.17,127.97 139.36,127.97 139.39,128 142.01,128 142.71,128.7 143.83,128.7 147.21,132.08 v2(147.21,132.54)
  IN3 w0.089: 141.76,120.21 140.85,121.12 140.85,122.43 140.32,122.96 140.32,123.52 139.37,124.47
  IN3 w0.127: v2(154.24,81.04) 153.13,81.04 151.92,82.25 151.31,82.25 144.54,89.01 144.54,93.85 144.19,94.2 144.19,96.48 145.2,97.49 145.2,97.64 145.27,97.7 145.27,102.81 141.95,106.12 141.95,106.29 141.95,106.45 139.95,108.45 139.95,110.1 141.82,111.98 141.82,112.29 142.35,112.81 142.35,119.62 141.76,120.21 ; v2(139.05,127.85) 139.05,124.79 139.37,124.47
  BOTTOM w0.102: v2(147.21,132.54) U630.13
MXM_EDP_N0: length 65.7
  TOP w0.102: v2(162.31,78.57) 162.13,78.75 162.13,78.95 162.25,79.07 JMXM1.234
  IN3 w0.127: v2(150.99,126) 150.96,125.97 150.96,123.67 151.05,123.58 151.05,114.26 150.59,113.8 150.59,111.33 152.33,109.58 152.84,109.58 153.26,109.16 153.26,108.56 153.09,108.39 153.09,107.39 154.35,106.13 154.35,103.72 152.3,101.67 152.3,99.45 152.19,99.33 152.19,95.91 151.62,95.33 151.62,94.1 151.97,93.75 151.97,93.02 152.89,92.1 152.89,89.11 155.93,86.06 157.19,86.06 161.38,81.87 161.38,80.55 162.16,79.78 162.16,78.72 v2(162.31,78.57)
  BOTTOM w0.102: C537.1 147.7,129.86 147.7,128.11 147.48,127.88 147.48,126.53 148.2,125.8 v4(148.71,125.8) 149.41,125.8 149.98,125.23 150.78,125.23 150.99,125.45 v2(150.99,126)
MXM_EDP_N0_C: length 2.9
  BOTTOM w0.102: U630.12 147.61,133.17 147.67,133.12 v4(147.67,132.04) 147.67,131.61 147.79,131.48 147.79,131.25 C537.2
MXM_EDP_N1: length 65.2
  TOP w0.102: v2(160.72,78.48) 160.56,78.64 160.56,78.92 160.75,79.11 JMXM1.240
  IN3 w0.127: v2(146.46,127.66) 147.36,127.66 147.81,127.21 147.81,126.31 149.83,124.29 149.83,123.47 150.11,123.19 150.11,116.77 149.65,116.31 149.65,110.26 149.43,110.04 149.43,108.45 151.7,106.18 152.97,106.18 153.12,106.03 153.2,105.95 153.24,105.89 153.41,105.73 153.41,104.11 152.79,103.48 152.59,103.48 152.44,103.33 151.54,103.33 150.91,102.7 150.91,100.49 151.17,100.22 151.17,97.12 150.91,96.86 150.91,96.02 149.28,94.39 149.01,94.39 148.72,94.1 148.72,93.51 148.97,93.26 149.52,93.26 151.63,91.15 151.63,88.91 155.5,85.03 156.05,85.03 156.37,84.71 156.37,84.71 159.22,81.86 159.22,80.8 160.72,79.31 v2(160.72,78.48)
  BOTTOM w0.102: v2(146.46,127.66) 146.61,127.81 146.61,128.41 146.55,128.47 146.37,128.47 C556.1
MXM_EDP_N1_C: length 4.8
  BOTTOM w0.102: C556.2 146.52,129.54 146.52,130.18 146.66,130.32 146.66,131.26 146.52,131.4 146.52,133 146.41,133.12 U630.15
MXM_EDP_N2: length 62.8
  TOP w0.102: JMXM1.246 159.25,79.1 159.06,78.92 159.06,78.73 v2(159.34,78.45)
  IN3 w0.127: v2(159.34,78.45) 159.2,78.32 158.98,78.32 158.89,78.41 158.89,79.81 157.83,80.87 157.83,81.87 155.6,84.09 155.11,84.09 150.35,88.86 150.35,90.89 148.91,92.32 148.58,92.32 147.78,93.12 147.78,94.8 149.7,96.71 149.7,100.85 149.9,101.05 149.9,103.4 149.13,104.18 149.13,105.92 148.49,106.56 148.49,110.43 148.7,110.64 148.7,116.69 149.17,117.16 149.17,122.8 148.89,123.08 148.89,123.27 146.71,125.45 146.71,125.76 146.79,125.84 v2(146.96,125.84)
  BOTTOM w0.102: v2(146.96,125.84) 146.86,125.84 146.86,125.83 146.71,125.99 146.49,125.99 v4(146.14,126.34) 145,127.48 145,129.37 145.04,129.4 145.04,129.86 C559.1
MXM_EDP_N2_C: length 3.1
  BOTTOM w0.102: U630.17 145.61,133.12 145.68,133.05 145.68,132.13 145.19,131.64 145.19,131.31 C559.2
MXM_EDP_N3: length 61.5
  TOP w0.102: JMXM1.252 157.75,78.94 157.51,78.71 157.51,78.5 157.59,78.42 157.8,78.42 v2(157.84,78.45)
  IN3 w0.127: v2(157.84,78.45) 157.8,78.49 157.8,79.51 156.87,80.43 156.87,81.49 155.22,83.14 154.16,83.14 148.95,88.35 148.95,89.59 148.94,89.59 148.94,90.77 148.33,91.38 148.19,91.38 146.84,92.73 146.84,95.19 148.57,96.91 148.57,102.75 146.66,104.65 146.66,105.89 147.49,106.71 147.49,107.15 147.48,107.16 147.48,116.8 148.23,117.55 148.23,120.29 147.74,120.77 147.74,123.06 147.39,123.41 145.11,125.69 145.08,125.69 v2(144.76,126)
  BOTTOM w0.102: C562.1 143.72,128.48 143.86,128.48 143.94,128.39 143.94,127.91 144.03,127.82 144.03,127.38 v4(144.36,127.06) 144.9,126.52 144.9,126.14 v2(144.76,126)
MXM_EDP_N3_C: length 4.9
  BOTTOM w0.102: U630.20 144.41,133 144.48,132.93 144.48,132.83 144.19,132.54 144.19,131.78 143.92,131.51 v4(143.92,130.22) 143.92,129.6 C562.2
MXM_EDP_P0: length 65.6
  TOP w0.102: JMXM1.236 161.75,79.03 161.86,78.91 161.86,78.71 v2(161.72,78.57)
  IN3 w0.127: v2(150.41,126) 150.65,125.76 150.65,123.54 150.74,123.45 150.74,114.38 150.28,113.93 150.28,111.2 152.21,109.28 152.71,109.28 152.96,109.03 152.96,108.69 152.78,108.51 152.78,107.26 154.04,106 154.04,103.84 152,101.8 152,99.57 151.88,99.46 151.88,96.03 151.31,95.46 151.31,93.97 151.66,93.62 151.66,92.89 152.58,91.97 152.58,88.98 155.81,85.76 157.07,85.76 161.08,81.75 161.08,80.42 161.85,79.65 161.85,78.7 v2(161.72,78.57)
  BOTTOM w0.102: v2(150.41,126) 150.73,125.69 150.73,125.56 150.67,125.5 150.09,125.5 149.52,126.07 148.31,126.07 147.74,126.64 v4(147.74,127.08) 147.74,127.77 147.97,128 147.97,130.22 148.06,130.31 148.15,130.31 C549.1
MXM_EDP_P0_C: length 2.9
  BOTTOM w0.102: C549.2 148.06,131.31 148.06,131.59 147.93,131.72 147.93,133.1 148.01,133.18 U630.11
MXM_EDP_P1: length 65.2
  TOP w0.102: v2(159.96,78.57) 160.06,78.57 160.29,78.8 160.29,78.97 160.25,79.01 JMXM1.242
  IN3 w0.127: v2(146.46,127.07) 146.52,127.07 146.8,127.35 147.24,127.35 147.5,127.08 147.5,126.18 149.52,124.16 149.52,123.34 149.8,123.06 149.8,116.9 149.34,116.44 149.34,110.39 149.13,110.17 149.13,108.32 151.57,105.87 152.84,105.87 152.97,105.74 153.01,105.69 153.1,105.6 153.1,104.23 152.66,103.79 152.47,103.79 152.32,103.64 151.41,103.64 150.6,102.83 150.6,100.36 150.87,100.1 150.87,97.25 150.6,96.98 150.6,96.15 149.15,94.7 148.82,94.7 148.42,94.29 148.42,93.38 148.84,92.96 149.39,92.96 151.33,91.02 151.33,88.78 155.38,84.73 155.92,84.73 156.25,84.41 158.92,81.73 158.92,80.68 160.41,79.18 160.41,78.77 160.22,78.57 v2(159.96,78.57)
  BOTTOM w0.102: v2(146.46,127.07) 146.98,127.6 146.98,128.19 C557.1
MXM_EDP_P1_C: length 4.7
  BOTTOM w0.102: C557.2 146.79,129.47 146.79,130.07 146.93,130.21 146.93,131.37 146.79,131.51 146.79,133.1 146.81,133.12 U630.14
MXM_EDP_P2: length 62.8
  TOP w0.102: JMXM1.248 158.75,79 158.79,78.95 158.79,78.64 158.64,78.49 v2(158.47,78.49)
  IN3 w0.127: v2(158.47,78.49) 158.59,78.6 158.59,79.68 157.52,80.75 157.52,81.74 155.48,83.79 154.99,83.79 150.04,88.73 150.04,90.76 148.79,92.02 148.45,92.02 147.48,92.99 147.48,94.92 149.39,96.84 149.39,100.97 149.6,101.18 149.6,103.28 148.82,104.05 148.82,105.8 148.19,106.43 148.19,110.56 148.39,110.76 148.39,116.82 148.86,117.29 148.86,122.67 148.58,122.95 148.58,123.15 146.41,125.32 146.41,125.94 146.86,126.4 v2(146.86,126.42)
  BOTTOM w0.102: v2(146.86,126.42) 146.71,126.26 146.6,126.26 145.27,127.59 v4(145.27,128.51) 145.27,129.26 145.3,129.29 145.3,130.1 145.38,130.18 145.61,130.18 C560.1
MXM_EDP_P2_C: length 3.1
  BOTTOM w0.102: C560.2 145.46,131.25 145.46,131.53 145.94,132.02 v4(145.94,132.25) 145.94,132.93 146.01,133 U630.16
MXM_EDP_P3: length 61.6
  TOP w0.102: v2(157.4,78.06) 157.4,78.16 157.25,78.32 JMXM1.254
  IN3 w0.127: v2(157.4,78.06) 157.25,78.21 157.25,78.44 157.49,78.69 157.49,79.38 156.57,80.31 156.57,81.36 155.09,82.84 154.03,82.84 148.65,88.22 148.65,89.46 148.64,89.47 148.64,90.64 148.2,91.08 148.06,91.08 146.54,92.6 146.54,95.31 148.26,97.04 148.26,102.62 146.36,104.53 146.36,106.01 147.19,106.84 147.19,107.02 147.17,107.03 147.17,116.93 147.92,117.68 147.92,120.16 147.44,120.64 147.44,122.93 147.17,123.2 144.97,125.4 144.79,125.4 v2(144.76,125.37)
  BOTTOM w0.102: v2(144.76,125.37) 144.76,125.43 145.17,125.84 145.17,126.63 144.58,127.22 144.54,127.25 144.3,127.5 144.3,128.18 C564.1
MXM_EDP_P3_C: length 4.8
  BOTTOM w0.102: U630.19 144.81,133 144.74,132.93 144.74,132.72 144.46,132.43 v4(144.46,132.05) 144.46,131.67 144.19,131.4 144.19,129.4 C564.2
MXM_ENVDD: length 179
  TOP w0.102: JMXM1.59 208,88.9 207.89,89.01 207.89,89.91 207.62,90.19 207.23,90.19 206.89,90.53 206.89,90.94 207.05,91.1 209.96,91.1 210.35,91.5 211.56,91.5 211.73,91.32 217.71,91.32 218.22,91.83 218.9,91.83 219.41,92.34 219.41,96.52 220.04,97.15 220.72,97.15 221.04,97.46 221.04,97.79 221.04,100.26 221.85,101.07 222.74,101.07 223.08,101.42 223.35,101.42 223.99,102.06 223.99,104.53 223.74,104.79 223.74,107.63 222.72,108.65 220.23,108.65 219.31,109.57 219.31,112.29 219.01,112.59 219.01,113.14 219.07,113.2 219.07,113.67 218.74,114 218.74,114.78 219.29,115.33 219.29,117.44 218.7,118.03 217.49,118.03 217.25,118.27 217.25,120.59 213.02,124.82 213.02,133.24 206.58,139.69 v1(206.58,140.16) 206.58,141.71 v2(204.46,143.82)
  IN2 w0.127: v2(156.95,149.88) 157.46,150.39 157.46,153.18 157.87,153.59 157.87,154.6 158.67,155.4 168.8,155.4 170.26,153.94 185.44,153.94 189.02,150.36 191.29,150.36 191.82,149.84 194.78,149.84 198.56,146.06 202.96,146.06 203.35,145.66 203.36,145.66 204.46,144.56 v2(204.46,143.82)
  BOTTOM w0.102: v2(156.95,149.88) 157.17,149.66 157.17,147.37 156.84,147.04 153.7,147.04 152.91,146.25 150.42,146.25 148.21,144.04 142.05,144.04 141.55,143.53 129.58,143.53 128.63,144.48 128.16,144.48 124.23,148.42 D93.3
MXM_OVERT#: length 66.1
  TOP w0.089: 167.92,68.47 168.28,68.47 168.51,68.24 170.56,68.24 v2(171.26,67.54)
  TOP w0.102: R10.2 162.04,67.71 163.39,69.06 Q4.3 163.39,69.68 164.12,70.41 164.97,70.41 166.79,68.6 167.49,68.6 167.62,68.47 167.92,68.47 ; JMXM1.56 208.75,81.45 v2(208.07,82.13)
  IN2 w0.127: v2(198.72,80.88) 198.06,80.22 191.18,80.22 190.86,79.9 185.08,79.9 184.51,79.33 176.83,79.33 176.45,78.95 172.99,78.95 v2(172.67,78.63)
  IN4 w0.089: v2(171.26,67.54) 171.94,68.21 171.94,69.31 173.53,70.91
  IN4 w0.109: v2(172.67,78.63) 172.7,78.63 172.7,78.62 172.65,78.62 172.64,78.61 172.7,78.55 172.7,77.3 173.14,76.85 173.14,74.57 173.63,74.09 173.63,71 173.53,70.91
  BOTTOM w0.102: v2(198.72,80.88) 199.45,80.16 202.99,80.16 205.66,82.82 v1(206.99,82.82) 207.37,82.82 v2(208.07,82.13)
MXM_PANEL_BKEN: length 216.3
  TOP w0.102: JMXM1.61 207.5,89.16 207.66,89.32 207.66,89.76 207.46,89.96 206.99,89.96 v1(206.81,90.13) 206.65,90.3 206.65,91.13 206.85,91.33 209.86,91.33 210.25,91.73 211.65,91.73 211.83,91.55 217.19,91.55 217.7,92.06 218.8,92.06 219.18,92.44 219.18,96.84 219.46,97.11 219.46,98.29 219.82,98.65 219.82,100.85 220.93,101.97 220.93,103.42 222.51,105 v2(222.51,105.56)
  IN1 w0.109: v2(154.16,148.58) 154.73,148.01 154.73,147.4 152.76,145.44 152.76,145.24 150.99,143.47 137.96,143.47 137.25,142.76 136.36,142.76 135.16,141.56 127.49,141.56 125.14,143.91 125.14,145.05 123.99,146.2 123.17,146.2 122.85,146.51 118.09,146.51 117.64,146.07 114.53,146.07 v2(113.71,145.24)
  IN2 w0.127: v2(154.16,148.58) 154.34,148.76 155.31,148.76 155.42,148.87 155.42,148.96 155.92,149.46 156.88,149.46 157.92,148.43 167.2,148.43 167.83,147.8 169.12,147.8 169.73,147.19 171.51,147.19 172.23,147.91 180.89,147.91 181.82,148.84 184.6,148.84 185.76,147.67 190.68,147.67 191.19,147.16 194.69,147.16 197.68,144.17 200.01,144.17 203.03,141.16 224.68,141.16 237.08,128.76 237.08,120.8 235.91,119.62 235.91,111.88 238.62,109.16 v2(239.69,109.16)
  BOTTOM w0.102: v2(222.51,105.56) 222.99,105.56 223.39,105.96 223.39,106.52 224.36,107.48 224.36,107.96 225.76,109.36 226.24,109.36 226.64,108.96 226.98,108.96 227.18,109.16 v2(239.69,109.16) ; D64.2 113.03,144.57 v2(113.71,145.24)
MXM_PRESENTL#: length 56.4
  TOP w0.089: UH1.M44 113.57,107.51 112.37,106.31
  TOP w0.102: 112.37,106.31 112.03,105.96 v1(111,105.96) 110.85,105.81 109,105.81 109,105.81 108.66,105.81 108.66,105.81 108.56,105.81 v2(108.12,106.26) 107.99,106.38 RH317.2 ; v2(127.87,98.89) 127.8,98.83 127.8,97.24 132.12,92.92 137.19,92.92 137.54,93.26 140.48,93.26 140.89,92.86 140.89,92.16 140.5,91.78 140.5,90.38 140.86,90.02 141.61,90.02 141.88,89.76 141.88,89.36 142.49,88.75 142.49,87.54 142.93,87.09 143.37,87.09 143.5,87.21 JMXM1.310
  IN2 w0.127: v2(127.87,98.89) 126.92,99.84 117.64,99.84 117.33,100.16 112.82,100.16 110.53,102.45 110.53,103.84 v2(108.12,106.26)
MXM_PRESENTR#: length 137
  TOP w0.089: UH1.T45 113.1,109.78 112.56,109.24 112.56,108.96 112.37,108.77
  TOP w0.102: 112.37,108.77 112.32,108.72 112.32,107.66 111.28,106.62 110.42,106.62 110.01,106.22 v1(109.58,106.22) v2(108.83,106.22) 108.83,106.25 107.81,107.27 RH91.2 ; JMXM1.38 213.25,80.7 213.09,80.85 v2(211.95,80.85)
  IN2 w0.089: 141.76,105.37 138.37,105.37
  IN2 w0.127: 141.76,105.37 146.6,105.37 147.17,105.94 155.87,105.94 157.14,107.21 160.82,107.21 162.16,105.87 164.25,105.87 164.76,105.37 165.4,105.37 166.58,104.19 166.58,103.48 167.17,102.89 167.73,102.89 168.42,103.59 169.67,103.59 170.63,104.54 173.14,104.54 173.46,104.22 174.96,104.22 175.79,105.05 176.32,105.05 178.29,103.08 179.3,103.08 181.72,100.66 181.72,100.52 183.6,98.64 185.02,98.64 185.98,97.68 190.42,97.68 191.38,96.72 192.55,96.72 193.21,96.06 196.77,96.06 197.39,95.44 198.52,95.44 198.88,95.08 200.78,95.08 202.36,93.49 203.31,93.49 203.73,93.07 203.73,88.9 204.38,88.25 204.38,86.43 209.87,80.94 211.86,80.94 v2(211.95,80.85) ; v2(108.83,106.22) 108.83,106.25 110.79,104.3 110.79,102.95 113.07,100.67 117.26,100.67 117.58,100.35 122.61,100.35 124.57,102.31 135.31,102.31 138.37,105.37
MXM_PWR_LEVEL: length 192.1
  TOP w0.254: U17.4 214.85,76.87 R37.2 214.08,76.89 214.08,78.42 v2(214.23,78.57) ; v2(335.65,45.37) 335.65,45.38 337.32,45.38 337.94,44.76 PQ1074.3 ; v2(213.91,80.86) 213.91,80.89 213.44,81.36 209.74,81.36 209.25,80.87 JMXM1.54
  IN2 w0.254: v2(214.23,78.57) 214.4,78.74 219.39,78.74 220.49,77.63 233.81,77.63 236.64,74.8 237.67,74.8 240.92,71.55 244.12,71.55 247.84,67.82 247.84,60.37 251.29,56.93 258.15,56.93 269.27,45.81 269.27,44.03 272.9,40.39 275.82,40.39 277.04,39.17 277.04,38.3 278.71,36.63 278.71,33.78 279.05,33.44 279.05,30.89 281.36,28.58 288.06,28.58 292.65,23.99 296.81,23.99 298.33,25.51 303.14,25.51 303.9,24.75 315.6,24.75 316.08,25.23 318.27,25.23 318.37,25.33 327.14,25.33 328.54,26.73 330.7,26.73 332.71,24.72 335.51,24.72 336.69,25.9 336.69,30.49 336.38,30.8 336.38,44.64 v2(335.65,45.37)
  BOTTOM w0.254: v2(213.91,80.86) 213.91,79.89 v1(214.23,79.57) v2(214.23,78.57)
MXM_VGA_DIS#: length 46.3
  TOP w0.102: v2(207.31,90.7) 207.37,90.64 R1971.1
  IN1 w0.109: v2(182.31,114.08) 182.31,113.93 181.94,113.55 181.94,108.66 182.03,108.57 182.03,107.39 181.81,107.16 181.81,106.13 182.29,105.65 182.29,104.2 182.67,103.82 182.8,103.82 183.12,103.5 187.95,103.5 189.08,102.37 189.08,101.72 v2(188.95,101.59)
  IN2 w0.127: v2(188.95,101.59) 190.58,99.97 192.6,99.97 194.22,98.34 195.95,98.34 196.47,98.86 198.87,98.86 199.42,98.32 200.91,98.32 201.85,97.38 202.88,97.38 203.06,97.2 203.43,97.2 206.93,93.71 206.93,91.08 v2(207.31,90.7)
  BOTTOM w0.102: U46.B16 182.8,115.11 182.63,114.94 182.54,114.94 182.3,114.7 182.3,114.08 182.31,114.07 v2(182.31,114.08)
NB_PSID: length 49.3
  TOP w0.254: v2(32.68,42.37) 32.68,43.43 PD4.3 PD4.2 31.44,42.02 v2(30.84,41.42) ; v2(15.4,21.67) 15.58,21.67 15.88,21.37 15.88,20.49 15.57,20.18 PL3.2
  IN1 w0.254: v2(32.68,42.37) 32.68,45.5 32.08,46.1 v2(32.08,51.56)
  BOTTOM w0.102: v3(33.19,41.17) 32.94,41.42 v2(30.84,41.42)
  BOTTOM w0.254: v2(30.84,41.42) 27.22,41.42 26.01,40.22 25.63,40.22 25,39.58 25,37.61 22.78,35.39 22.78,28.85 15.6,21.67 v2(15.4,21.67)
NB_PSID_TS5A63157: length 5.5
  TOP w0.102: PR9.2 9.79,20.51 9.75,20.47 PR8.1 9.65,19.98 v1(8.44,18.77) 8.44,17.85 8.96,17.33 PU1.3
NRB_BIT: length 4.6
  TOP w0.089: UH1.BD28 121.34,123.62 121.31,123.65 121.26,123.7 121.26,124.51 120.95,124.82 v2(120.83,124.82)
  BOTTOM w0.089: 120.51,126.2 120.51,125.14 v2(120.83,124.82)
  BOTTOM w0.102: RH331.2 119.94,127.07 120.51,126.5 120.51,126.2
NXRES: length 50.2
  TOP w0.102: JDEG3.3 263.99,61.9 263.99,64.12 263.71,64.39 263.71,66.99 258.16,72.54 258.16,83.34 v1(257.71,83.78) 257.71,84.28 256.96,85.03 v2(256.96,85.11) ; U8.32 244.58,90.21 245.45,91.08 247.18,91.08 248.67,92.56 250.96,92.56 252.14,93.75 v2(253.03,93.75)
  IN1 w0.109: v2(253.03,93.75) 253.15,93.75 253.88,93.02 253.88,87.44 256.22,85.11 v2(256.96,85.11)
OA_M1: length 5.5
  TOP w0.102: U8.41 250.21,86.48 250.04,86.32 v2(250.04,86.15) 250.04,85.96 250.53,85.48 R373.1 250.85,85.45 C141.2 R414.2
OA_M2: length 5.1
  TOP w0.102: U8.38 247.81,86.82 247.09,86.09 v1(247.09,85.88) 247.09,85.68 247.29,85.48 C143.2 R376.2 248.17,84.57 R375.1
OA_OUT1: length 6.3
  TOP w0.102: v1(250.09,83.64) 250.09,83.23 249.94,83.08 249.94,82.81 249.93,82.81 R414.1 ; v1(250.09,83.64) 250.09,84.06 249.94,84.22 249.94,84.58 C141.1 249.93,85.03 249.55,85.41 249.55,85.9 249.41,86.04 U8.40 ; v1(250.09,83.64) 249.6,83.64 249.53,83.71 C1420.2
OA_OUT2: length 3.2
  TOP w0.102: U8.39 248.61,86.4 v2(248.76,86.25) 249.07,85.94 C143.1 R376.1
P0_7: length 3.4
  TOP w0.102: R413.2 240.99,89.41 v2(241.3,89.41) 241.47,89.41 241.71,89.65 241.71,90.42 242.3,91.01 U8.31
P33ALW: length 2.7
  TOP w0.254: PU1001.18 337.2,55.69 337.73,56.22 v2(337.73,56.68) 337.73,56.86 338.04,57.17 PR1025.1
P33ALW2: length 3.3
  TOP w0.102: PR1022.2 v1(337.82,49.12)
  TOP w0.254: PU1001.9 335.7,50.38 335.86,50.21 336.17,50.21 336.89,49.49 PR1022.2
P50ALW: length 3.2
  TOP w0.102: PR1012.1 v1(329.77,58.43)
  TOP w0.254: PR1012.1 330.67,58.19 331.7,57.16 PU1001.27
PANEL_BKEN_EC: length 120.1
  TOP w0.102: v2(178.54,144.61) 178.54,144.86 v1(178.13,145.28) 177.91,145.5 177.4,145.5 177.08,145.82 v2(177.08,146.64)
  IN1 w0.109: v2(112.27,147.49) 112.5,147.72 119.2,147.72 120.17,146.75 122.95,146.75 123.27,146.43 123.9,146.43 124.09,146.43 125.37,145.15 125.37,144.06 127.63,141.8 135.06,141.8 136.26,143 137.15,143 137.86,143.71 150.9,143.71 152.51,145.32 152.51,145.52 154.14,147.15 154.14,147.99 v2(154.15,147.99) ; v2(180.78,107.46) 180.32,107.92 180.32,115.02 181.37,116.07 181.37,118.22 181.94,118.79 181.94,119.27 182.29,119.62 182.29,122.26 181.29,123.26 181.29,124.48 181.29,124.48 181.29,124.95 v2(181.31,124.97)
  IN2 w0.127: v2(154.15,147.99) 154.15,147.8 154.6,147.34 157.99,147.34 158.57,147.92 166.99,147.92 167.62,147.29 168.91,147.29 169.52,146.68 171.72,146.68 172.44,147.4 172.65,147.4 176.32,147.4 v2(177.08,146.64)
  IN3 w0.127: v2(178.54,144.61) 178.54,144.55 177.52,143.53 177.52,143.15 176.51,142.13 176.51,139.47 177.02,138.96 177.02,135.11 177.73,134.4 177.73,128.96 177.74,128.94 180.15,126.53 180.15,125.56 180.61,125.1 181.17,125.1 181.31,124.97 v2(181.31,124.97)
  BOTTOM w0.102: v2(180.78,107.46) 181.8,106.44 U46.B38 ; D69.2 112.29,147.51 v2(112.27,147.49)
PANEL_BKEN_PCH: length 91.6
  TOP w0.089: UH1.W35 v2(118.47,110.87)
  IN4 w0.089: v2(118.47,110.87) 118.47,111.4 118.1,111.76 118.1,111.77 117.44,112.43 113.34,112.43 113.07,112.16 112.37,112.16
  IN4 w0.109: 112.37,112.16 110.47,112.16 109.57,111.26 109.57,111 109.57,111 109.57,110.88 109.57,110.88 109.57,110.69 108.01,109.13 104.66,109.13 102.99,107.46 102.99,101.94 102.43,101.38 100.86,101.38 100.32,101.91 100.32,104.84 97.3,107.86 97.3,113.43 95.1,115.63 92.13,115.63 90.67,117.09 90.67,123.48 97.82,130.63 98.71,130.63 99.24,131.16 99.24,133.01 98.81,133.45 98.81,135.35 99.92,136.46 101.54,136.46 104.78,139.69 107.24,139.69 107.97,140.43 108.48,140.43 109.3,141.25 109.3,142.04 109.52,142.26 111.25,142.26 v2(111.76,142.77)
  BOTTOM w0.102: v2(111.76,142.77) 111.76,143.42 112.21,143.87 112.21,145.1 D65.2
PANEL_ID: length 3.9
  TOP w0.102: v2(206.81,110.36) 206.37,110.8 R3754.2 C1465.1 204.96,111.36 v1(205.31,111.71)
  BOTTOM w0.102: v2(206.81,110.36) 206.81,110.36 U51.A10
PBA_GPU_SEL#: length 55.7
  IN2 w0.127: v2(188.39,144) 187.92,143.53 183.62,143.53 182.22,144.93 179.81,144.93 v2(179.56,144.67)
  IN3 w0.127: v2(181.78,118.05) 181.78,122.96 181.53,123.22 181.53,123.86 182.03,124.36 182.03,125.01 181.57,125.47 180.73,125.47 180.48,125.72 180.48,126.54 181.14,127.21 181.14,129.77 180.66,130.26 178.92,130.26 177.98,131.2 177.98,134.5 177.27,135.21 177.27,139.34 176.76,139.85 176.76,141.75 177.91,142.9 178.41,142.9 178.82,143.31 178.82,143.96 179.07,144.2 179.09,144.2 v2(179.56,144.67)
  BOTTOM w0.102: U46.A15 182.55,117.74 182.19,118.1 182.03,118.1 182.03,118.11 181.83,118.11 v2(181.78,118.05) ; U629.54 183.22,136.91 183.45,137.13 183.45,137.56 183.73,137.84 185.67,137.84 187.62,139.8 v1(187.62,140.7) 187.62,143.23 v2(188.39,144)
PBAT_PRES#: length 476.9
  TOP w0.102: JIO2.64 54.26,37.85 v2(54.72,38.31) ; PR2.2 249.71,8.35 249.25,7.89 PD5.1 248.49,8.95 249.28,9.74 249.72,9.74 250.47,10.48 250.47,11.18 251.12,11.83 251.75,11.83 PD3.2 ; PD3.2 252.65,11.71 252.65,12.16 v3(252.94,12.45) 253.34,12.85 254.93,12.85 v2(255.12,12.66) ; PD3.2 252.59,11 PR3.7
  TOP w0.254: PR728.1 270.92,27.19 270.6,26.87 269.71,26.87 268.71,25.86 267.12,25.86 v2(267.06,25.93)
  IN1 w0.109: v2(252.07,34.69) 252.44,34.32 252.88,34.32 253.44,34.88 253.44,35.33 257.64,39.54 257.64,46.2 253.24,50.6 249.97,50.6 249.86,50.71 245.85,50.71 242.68,53.88 242.68,65.63 241.31,66.99 240.97,66.99 239.94,68.03 239.94,68.74 236.85,71.83 236.85,72.28 231.52,77.61 226.76,77.61 219.99,84.37 219.99,95.98 220.96,96.95 220.96,98.33 219.47,99.82 219.09,99.82 217.89,101.02 217.68,101.02 214.6,104.11 214.1,104.11 213.77,104.45 213.53,104.69 213.53,105.22 212.6,106.14 211.48,106.14 211.29,106.34 211.29,106.54 210.37,107.46 210.35,107.46 209.22,108.59 209.22,109.79 209.69,110.27 209.69,110.68 208.07,112.3 206.12,112.3 205.26,113.16 200.54,113.16 199.63,114.06 199.63,117.52 v2(199.62,117.52)
  IN2 w0.127: v2(54.72,38.31) 54.97,38.06 56.87,38.06 57.74,37.19 59.57,37.19 60.12,37.75 61.18,37.75 61.29,37.64 67.34,37.64 69.31,39.61 70.02,39.61 70.34,39.92 70.34,41.09 75.06,45.82 78.74,45.82 86.16,53.23 87.37,53.23 94.92,60.79 94.92,72.09 97.15,74.31 97.15,75.23 98.68,76.76 98.68,77.47 99.46,78.25 101.62,78.25 103.96,80.6 104.98,80.6 106.45,82.06 107.76,82.06 108.9,83.21 113.73,83.21 114.34,83.81 116.13,83.81 116.77,83.18 122.59,83.18 123.2,82.57 125.16,82.57 127.16,84.58 130.57,84.58 131.6,83.55 133.98,83.55 134.65,82.87 137.45,82.87 139.99,80.33 145.75,80.33 146.99,81.58 152.43,81.58 156.47,85.62 157.4,85.62 158.16,84.86 159.11,84.86 160.51,83.46 166.22,83.46 166.79,82.89 168.51,82.89 169.64,84.02 174.04,84.02 174.48,83.59 177.52,83.59 177.78,83.33 181,83.33 182.35,84.68 v2(182.35,85.22) ; v2(252.07,34.69) 252.57,35.19 253.04,35.19 253.85,34.37 255.4,34.37 256.75,35.72 256.75,42.08 254.94,43.89 254.94,46.48 255.57,47.12 255.57,48.65 254.96,49.26 254.96,54.17 253.69,55.45 250.6,55.45 246.01,60.04 246.01,67.71 243.54,70.18 238.85,70.18 232.73,76.29 220.15,76.29 219.52,75.66 214.87,75.66 v2(213.66,74.44)
  IN3 w0.127: v2(182.35,85.22) 182.35,85.4 182.7,85.75 186.85,85.75 190.78,81.82 190.78,80.97 192.18,79.57 192.18,77.92 192.54,77.57 192.79,77.57 194.08,76.28 195.31,76.28 195.73,75.86 211,75.86 212.42,74.44 v2(213.66,74.44) ; v2(252.07,34.69) 252.71,35.33 253.12,35.33 253.7,34.74 253.7,32.73 255.69,30.74 257.21,30.74 258,31.53 263.13,31.53 265.24,29.42 265.24,28.51 267.06,26.69 v2(267.06,25.93) 267.06,25.16 260.97,19.08 260.97,18.07 260.98,18.06 260.98,17.16 256.47,12.66 v2(255.12,12.66)
  IN4 w0.109: v2(196.13,117.31) 196.13,117.45 197.04,118.36 199.36,118.36 199.53,118.19 199.53,117.61 v2(199.62,117.52)
  BOTTOM w0.102: v2(196.13,117.31) 196.75,116.69 U51.A49
PBAT_SMBCLK: length 199
  TOP w0.102: PR3.5 253.59,8.6 253.45,8.74 253.45,8.99 253.56,9.1 254.3,9.1 254.55,9.35 254.55,10.31 253.95,10.9 253.95,11.11 254.17,11.32 PD2.2 254.35,11.57 253.97,11.96 253.97,12.11 v2(254.14,12.29)
  IN1 w0.109: v2(239.95,104.01) 240.11,104.18 240.79,104.18 241.05,103.92 241.05,103.29 240.68,102.93 238.59,102.93 237.55,103.97 234.8,103.97 233.07,105.7 232.33,105.7 230.25,107.79 230.25,108.02 226.74,111.53 223.71,111.53 222.82,112.42 220.39,112.42 220.18,112.2 215.6,112.2 215.18,111.78 212.96,111.78 212.75,111.57 210.62,111.57 209.78,112.42 208.69,112.42 208.36,112.75 208.36,113.98 208.32,114.02 208.32,114.7 207.88,115.15 207.37,115.15 206.03,116.48 205.84,116.48 205.34,116.48 204.91,116.05 201.38,116.05 200.6,116.82 200.6,117.23 200.61,117.24 v2(200.61,117.28)
  IN3 w0.127: v2(197.25,122.26) 197.18,122.19 196.72,122.19 196.53,122.39 196.53,122.65 196.77,122.88 200.35,122.88 200.83,122.41 200.83,118.55 200.99,118.39 200.99,118.02 201.03,117.98 201.03,116.06 200.81,115.84 200.67,115.84 200.56,115.95 200.56,117.19 200.61,117.24 v2(200.61,117.28)
  BOTTOM w0.102: v2(200.61,117.28) 200.61,117.2 200.25,116.84 U51.A56 ; RP5.7 198.16,122.09 197.89,122.36 197.35,122.36 v2(197.25,122.26) ; v2(239.95,104.01) 240.06,104.12 240.68,104.12 241.05,103.75 241.05,102.81 241.56,102.3 241.56,101.65 245.24,97.96 245.24,97.71 245.58,97.36 245.58,97.02 246.03,96.57 246.03,95.63 245.05,94.65 244.92,94.65 243.78,93.51 243.78,91.43 243.04,90.7 243.04,89.24 242.17,88.37 242.17,82.32 245.67,78.81 245.67,77.74 246.8,76.61 246.8,69.9 246.69,69.78 246.69,68.19 246.05,67.55 246.05,60.57 250.45,56.18 257.12,56.18 257.44,56.5 259.54,56.5 262.6,53.44 262.6,45.46 264.52,43.54 264.52,40.41 265.92,39.01 267.59,39.01 268.03,38.58 268.03,37.59 265.41,34.97 264.3,34.97 261.68,32.35 261.68,29.57 262.63,28.61 262.63,27.38 264.44,25.57 264.44,20.22 257.57,13.34 256.81,13.34 254.89,11.42 254.26,11.42 254.01,11.67 254.01,12.16 v2(254.14,12.29)
PBAT_SMBDAT: length 203
  TOP w0.102: PR3.6 253.09,8.65 253.22,8.79 253.22,9.09 253.46,9.33 254.2,9.33 254.32,9.45 254.32,10.21 253.72,10.81 253.72,11.13 253.53,11.32 PD2.3 253.35,11.57 253.74,11.96 253.74,12.11 v2(253.56,12.29)
  IN1 w0.102: v2(239.95,104.59) 240.08,104.46
  IN1 w0.109: v2(200.17,114.58) 200.17,115.67 200.24,115.75 200.34,115.81 200.6,116.07 201.02,116.07 201.28,115.81 205.01,115.81 205.44,116.24 205.94,116.24 207.27,114.91 207.78,114.91 208.09,114.6 208.09,113.92 208.12,113.88 208.12,112.65 208.59,112.18 209.68,112.18 210.52,111.34 212.85,111.34 213.06,111.54 215.28,111.54 215.7,111.97 220.27,111.97 220.49,112.18 222.72,112.18 223.61,111.29 226.64,111.29 230.01,107.92 230.01,107.69 232.23,105.47 232.97,105.47 234.7,103.73 237.45,103.73 238.49,102.69 240.78,102.69 241.28,103.19 241.28,104.02 240.89,104.41 240.12,104.41 240.08,104.46
  IN3 w0.127: v2(200.17,114.58) 200.17,114.58 200.17,115.18 200.58,115.59 200.92,115.59 201.29,115.96 201.29,118.08 201.24,118.13 201.24,118.47 201.25,118.48 201.08,118.65 201.08,122.51 200.46,123.14 196.66,123.14 196.28,122.76 196.28,122.28 196.62,121.94 196.73,121.94 v2(197,121.67)
  BOTTOM w0.102: v2(197,121.67) 197.11,121.78 RP5.8 ; U51.B59 200.17,115.55 v2(200.17,114.58) ; v2(239.95,104.59) 240.19,104.35 240.78,104.35 241.28,103.85 241.28,102.9 241.79,102.39 241.79,101.74 245.47,98.06 245.47,97.8 245.81,97.46 245.81,97.11 246.26,96.67 246.26,95.54 245.14,94.42 245.01,94.42 244.01,93.42 244.01,91.34 243.27,90.6 243.27,89.15 242.4,88.27 242.4,82.41 245.9,78.91 245.9,77.84 247.03,76.71 247.03,69.8 246.92,69.69 246.92,68.09 246.28,67.46 246.28,60.67 250.54,56.41 257.02,56.41 257.34,56.73 259.64,56.73 262.83,53.54 262.83,45.55 264.75,43.63 264.75,40.5 266.01,39.24 267.69,39.24 268.25,38.67 268.25,37.49 265.5,34.74 264.4,34.74 261.91,32.25 261.91,29.66 262.86,28.7 262.86,27.47 264.67,25.67 264.67,20.12 257.66,13.11 256.9,13.11 255.12,11.33 254.98,11.2 254.17,11.2 253.99,11.38 253.79,11.58 253.79,12.06 v2(253.56,12.29)
