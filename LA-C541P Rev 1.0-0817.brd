# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Nets (continued)
DDR_A_MA16: CPU1.AH4 JDIMM1.152 JDIMM2.152
DDR_A_ODT0: CPU1.AD3 JDIMM2.155
DDR_A_ODT1: CPU1.AE4 JDIMM2.161
DDR_A_ODT2: CPU1.AE1 JDIMM1.155
DDR_A_ODT3: CPU1.AD4 JDIMM1.161
DDR_A_PARITY: CPU1.AG3 JDIMM1.143 JDIMM2.143
DDR_B_ACT#: CPU1.AT9 JDIMM3.114 JDIMM4.114
DDR_B_ALERT#: CPU1.AR8 JDIMM3.116 JDIMM4.116
DDR_B_BA0: CPU1.AH8 JDIMM3.150 JDIMM4.150
DDR_B_BA1: CPU1.AH9 JDIMM3.145 JDIMM4.145
DDR_B_BG0: CPU1.AR9 JDIMM3.115 JDIMM4.115
DDR_B_BG1: CPU1.AR7 JDIMM3.113 JDIMM4.113
DDR_B_CB0: CPU1.AW11 JDIMM3.104 JDIMM4.104
DDR_B_CB1: CPU1.AY11 JDIMM3.88 JDIMM4.88
DDR_B_CB2: CPU1.AY8 JDIMM3.91 JDIMM4.91
DDR_B_CB3: CPU1.AW8 JDIMM3.92 JDIMM4.92
DDR_B_CB4: CPU1.AY10 JDIMM3.87 JDIMM4.87
DDR_B_CB5: CPU1.AW10 JDIMM3.105 JDIMM4.105
DDR_B_CB6: CPU1.AY7 JDIMM3.100 JDIMM4.100
DDR_B_CB7: CPU1.AW7 JDIMM3.101 JDIMM4.101
DDR_B_CKE0: CPU1.AT8 JDIMM4.109
DDR_B_CKE1: CPU1.AT10 JDIMM4.110
DDR_B_CKE2: CPU1.AT7 JDIMM3.109
DDR_B_CKE3: CPU1.AT11 JDIMM3.110
DDR_B_CLK0: CPU1.AM9 JDIMM4.137
DDR_B_CLK1: CPU1.AM7 JDIMM4.138
DDR_B_CLK2: CPU1.AM11 JDIMM3.137
DDR_B_CLK3: CPU1.AJ10 JDIMM3.138
DDR_B_CLK#0: CPU1.AN9 JDIMM4.139
DDR_B_CLK#1: CPU1.AM8 JDIMM4.140
DDR_B_CLK#2: CPU1.AM10 JDIMM3.139
DDR_B_CLK#3: CPU1.AJ11 JDIMM3.140
DDR_B_CS#0: CPU1.AF11 JDIMM4.149
DDR_B_CS#1: CPU1.AE7 JDIMM4.157
DDR_B_CS#2: CPU1.AF10 JDIMM3.149
DDR_B_CS#3: CPU1.AE10 JDIMM3.157
DDR_B_D0: CPU1.BT11 JDIMM3.8 JDIMM4.7
DDR_B_D1: CPU1.BR11 JDIMM3.7 JDIMM4.8
DDR_B_D2: CPU1.BT8 JDIMM3.16 JDIMM4.17
DDR_B_D3: CPU1.BR8 JDIMM3.21 JDIMM4.20
DDR_B_D4: CPU1.BP11 JDIMM3.3 JDIMM4.4
DDR_B_D5: CPU1.BN11 JDIMM3.4 JDIMM4.3
DDR_B_D6: CPU1.BP8 JDIMM3.17 JDIMM4.16
DDR_B_D7: CPU1.BN8 JDIMM3.20 JDIMM4.21
DDR_B_D8: CPU1.BL12 JDIMM3.24 JDIMM4.25
DDR_B_D9: CPU1.BL11 JDIMM3.29 JDIMM4.28
DDR_B_D10: CPU1.BL8 JDIMM3.25 JDIMM4.24
DDR_B_D11: CPU1.BJ8 JDIMM3.38 JDIMM4.37
DDR_B_D12: CPU1.BJ11 JDIMM3.37 JDIMM4.38
DDR_B_D13: CPU1.BJ10 JDIMM3.41 JDIMM4.42
DDR_B_D14: CPU1.BL7 JDIMM3.28 JDIMM4.29
DDR_B_D15: CPU1.BJ7 JDIMM3.42 JDIMM4.41
DDR_B_D16: CPU1.BG11 JDIMM3.50 JDIMM4.49
DDR_B_D17: CPU1.BG10 JDIMM3.46 JDIMM4.45
DDR_B_D18: CPU1.BG8 JDIMM3.45 JDIMM4.46
DDR_B_D19: CPU1.BF8 JDIMM3.59 JDIMM4.58
DDR_B_D20: CPU1.BF11 JDIMM3.63 JDIMM4.62
DDR_B_D21: CPU1.BF10 JDIMM3.62 JDIMM4.63
DDR_B_D22: CPU1.BG7 JDIMM3.49 JDIMM4.50
DDR_B_D23: CPU1.BF7 JDIMM3.58 JDIMM4.59
DDR_B_D24: CPU1.BB11 JDIMM3.84 JDIMM4.83
DDR_B_D25: CPU1.BC11 JDIMM3.67 JDIMM4.66
DDR_B_D26: CPU1.BB8 JDIMM3.80 JDIMM4.79
DDR_B_D27: CPU1.BC8 JDIMM3.70 JDIMM4.71
DDR_B_D28: CPU1.BC10 JDIMM3.66 JDIMM4.67
DDR_B_D29: CPU1.BB10 JDIMM3.79 JDIMM4.80
DDR_B_D30: CPU1.BC7 JDIMM3.71 JDIMM4.70
DDR_B_D31: CPU1.BB7 JDIMM3.83 JDIMM4.84
DDR_B_D32: CPU1.AA11 JDIMM3.187 JDIMM4.186
DDR_B_D33: CPU1.AA10 JDIMM3.183 JDIMM4.182
DDR_B_D34: CPU1.AC11 JDIMM3.173 JDIMM4.174
DDR_B_D35: CPU1.AC10 JDIMM3.169 JDIMM4.170
DDR_B_D36: CPU1.AA7 JDIMM3.182 JDIMM4.183
DDR_B_D37: CPU1.AA8 JDIMM3.186 JDIMM4.187
DDR_B_D38: CPU1.AC8 JDIMM3.170 JDIMM4.169
DDR_B_D39: CPU1.AC7 JDIMM3.174 JDIMM4.173
DDR_B_D40: CPU1.W8 JDIMM3.191 JDIMM4.190
DDR_B_D41: CPU1.W7 JDIMM3.195 JDIMM4.194
DDR_B_D42: CPU1.V10 JDIMM3.203 JDIMM4.204
DDR_B_D43: CPU1.V11 JDIMM3.208 JDIMM4.207
DDR_B_D44: CPU1.W11 JDIMM3.190 JDIMM4.191
DDR_B_D45: CPU1.W10 JDIMM3.194 JDIMM4.195
DDR_B_D46: CPU1.V7 JDIMM3.207 JDIMM4.208
DDR_B_D47: CPU1.V8 JDIMM3.204 JDIMM4.203
DDR_B_D48: CPU1.R11 JDIMM3.211 JDIMM4.212
DDR_B_D49: CPU1.P11 JDIMM3.228 JDIMM4.229
DDR_B_D50: CPU1.P7 JDIMM3.225 JDIMM4.224
DDR_B_D51: CPU1.R8 JDIMM3.212 JDIMM4.211
DDR_B_D52: CPU1.R10 JDIMM3.215 JDIMM4.216
DDR_B_D53: CPU1.P10 JDIMM3.224 JDIMM4.225
DDR_B_D54: CPU1.R7 JDIMM3.216 JDIMM4.215
DDR_B_D55: CPU1.P8 JDIMM3.229 JDIMM4.228
DDR_B_D56: CPU1.L11 JDIMM3.245 JDIMM4.246
DDR_B_D57: CPU1.M11 JDIMM3.233 JDIMM4.232
DDR_B_D58: CPU1.L7 JDIMM3.246 JDIMM4.245
DDR_B_D59: CPU1.M8 JDIMM3.232 JDIMM4.233
DDR_B_D60: CPU1.L10 JDIMM3.249 JDIMM4.250
DDR_B_D61: CPU1.M10 JDIMM3.237 JDIMM4.236
DDR_B_D62: CPU1.M7 JDIMM3.236 JDIMM4.237
DDR_B_D63: CPU1.L8 JDIMM3.250 JDIMM4.249
DDR_B_DQS0: CPU1.BR9 JDIMM3.13 JDIMM4.13
DDR_B_DQS1: CPU1.BJ9 JDIMM3.34 JDIMM4.34
DDR_B_DQS2: CPU1.BF9 JDIMM3.55 JDIMM4.55
DDR_B_DQS3: CPU1.BB9 JDIMM3.76 JDIMM4.76
DDR_B_DQS4: CPU1.AA9 JDIMM3.179 JDIMM4.179
DDR_B_DQS5: CPU1.V9 JDIMM3.200 JDIMM4.200
DDR_B_DQS6: CPU1.P9 JDIMM3.221 JDIMM4.221
DDR_B_DQS7: CPU1.L9 JDIMM3.242 JDIMM4.242
DDR_B_DQS8: CPU1.AW9 JDIMM3.97 JDIMM4.97
DDR_B_DQS#0: CPU1.BP9 JDIMM3.11 JDIMM4.11
DDR_B_DQS#1: CPU1.BL9 JDIMM3.32 JDIMM4.32
DDR_B_DQS#2: CPU1.BG9 JDIMM3.53 JDIMM4.53
DDR_B_DQS#3: CPU1.BC9 JDIMM3.74 JDIMM4.74
DDR_B_DQS#4: CPU1.AC9 JDIMM3.177 JDIMM4.177
DDR_B_DQS#5: CPU1.W9 JDIMM3.198 JDIMM4.198
DDR_B_DQS#6: CPU1.R9 JDIMM3.219 JDIMM4.219
DDR_B_DQS#7: CPU1.M9 JDIMM3.240 JDIMM4.240
DDR_B_DQS#8: CPU1.AY9 JDIMM3.95 JDIMM4.95
DDR_B_DRAMRST#: CD123.1 CD124.1 JDIMM3.108 JDIMM4.108 RD15.2
DDR_B_MA0: CPU1.AJ9 JDIMM3.144 JDIMM4.144
DDR_B_MA1: CPU1.AK6 JDIMM3.133 JDIMM4.133
DDR_B_MA2: CPU1.AK5 JDIMM3.132 JDIMM4.132
DDR_B_MA3: CPU1.AL5 JDIMM3.131 JDIMM4.131
DDR_B_MA4: CPU1.AL6 JDIMM3.128 JDIMM4.128
DDR_B_MA5: CPU1.AM6 JDIMM3.126 JDIMM4.126
DDR_B_MA6: CPU1.AN7 JDIMM3.127 JDIMM4.127
DDR_B_MA7: CPU1.AN10 JDIMM3.122 JDIMM4.122
DDR_B_MA8: CPU1.AN8 JDIMM3.125 JDIMM4.125
DDR_B_MA9: CPU1.AR11 JDIMM3.121 JDIMM4.121
DDR_B_MA10: CPU1.AH7 JDIMM3.146 JDIMM4.146
DDR_B_MA11: CPU1.AN11 JDIMM3.120 JDIMM4.120
DDR_B_MA12: CPU1.AR10 JDIMM3.119 JDIMM4.119
DDR_B_MA13: CPU1.AF9 JDIMM3.158 JDIMM4.158
DDR_B_MA14: CPU1.AH11 JDIMM3.151 JDIMM4.151
DDR_B_MA15: CPU1.AF8 JDIMM3.156 JDIMM4.156
DDR_B_MA16: CPU1.AH10 JDIMM3.152 JDIMM4.152
DDR_B_ODT0: CPU1.AF7 JDIMM4.155
DDR_B_ODT1: CPU1.AE8 JDIMM4.161
DDR_B_ODT2: CPU1.AE9 JDIMM3.155
DDR_B_ODT3: CPU1.AE11 JDIMM3.161
DDR_B_PARITY: CPU1.AJ7 JDIMM3.143 JDIMM4.143
DDR_PG_CTRL: CPU1.BT13 UD1.2
DDR_RCOMP0: CPU1.G1 RD18.2
DDR_RCOMP1: CPU1.H1 RD21.2
DDR_RCOMP2: CPU1.J2 RD22.2
DDR_XDP_WAN_SMBCLK: JDIMM1.253 JDIMM2.253 JDIMM3.253 JDIMM4.253 JXDP1.53 QH4.1 R502.2 U88.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254 JDIMM2.254 JDIMM3.254 JDIMM4.254 JXDP1.51 QH4.4 R501.2 U88.4
DE0_A_UN8: RN54.2 RN103.1 UN8.6
DE0_A_UN9: RN59.2 RN120.1 UN9.6
DE0_B_UN8: RN52.2 RN102.1 UN8.13
DE0_B_UN9: RN62.2 RN119.1 UN9.13
DE1_A_UN8: RN50.2 RN101.1 UN8.8
DE1_A_UN9: RN61.2 RN118.1 UN9.8
DE1_B_UN8: RN99.2 RN100.1 UN8.9
DE1_B_UN9: RN116.2 RN117.1 UN9.9
DETECT_PWR_EN: JIO2.56 U46.B3
DGPU_ALERT#: Q5.1 RP3.5 U46.A42
DGPU_HOLD_RST#: R19.2 R51.1 U16.1 UH1.AL36
DGPU_PEX_RST#: D95.1 JMXM1.184 Q4.2 Q5.2 R19.1 R3750.1 U16.4
DGPU_PEX_RST#_D: C1470.1 D95.2 R71.2 R72.1 U14.1 U25.1 U27.1
DGPU_PWR_EN: JMXM1.44 U46.B45
DGPU_PWROK: JMXM1.42 R72.2 R135.1 R1977.2 U46.A56 UH1.AJ38
DGPU_SELECT: QV1.1 RV46.1 RV47.2 U630.54
DGPU_SELECT#: QV1.2 RV46.2 RV49.2 U3.1 U46.B14
DH_1.2V: PQ201.4 PU200.17
DIFFOUT_3PH_A: PC1114.2 PR1131.2 PU1100.4
DIFFOUT_3PH_B: PR1134.1 PR1136.2 PU1100.35
DIMM1_SA0: JDIMM1.256 RD17.2 RD30.1
DIMM1_SA1: JDIMM1.260 RD13.2 RD29.1
DIMM1_SA2: JDIMM1.166 RD8.2 RD28.1
DIMM2_SA0: JDIMM2.256 RD26.2 RD35.1
DIMM2_SA1: JDIMM2.260 RD20.2 RD36.1
DIMM2_SA2: JDIMM2.166 RD19.2 RD31.1
DIMM3_SA0: JDIMM3.256 RD38.2 RD40.1
DIMM3_SA1: JDIMM3.260 RD37.2 RD42.1
DIMM3_SA2: JDIMM3.166 RD27.2 RD39.1
DIMM4_SA0: JDIMM4.256 RD53.2 RD55.1
DIMM4_SA1: JDIMM4.260 RD52.2 RD56.1
DIMM4_SA2: JDIMM4.166 RD51.2 RD54.1
DIMM_TYPE: RH358.1 UH1.AL44
DISP_ON: D64.1 D65.1 D69.1 JEDP1.19 R1138.1
DK_AC_OFF: PR1014.1 PU1001.25
DK_AC_OFF_EN: PR1020.1 PU1001.22
DK_CSS_GC: PR714.1 PU1001.11
DK_PWR_BAR: PR1007.2 PU1001.33
DL_1.2V: PQ202.4 PU200.15
DMI_CRX_PTX_N0: CPU1.E8 UH1.C27
DMI_CRX_PTX_N1: CPU1.F6 UH1.B28
DMI_CRX_PTX_N2: CPU1.E5 UH1.B29
DMI_CRX_PTX_N3: CPU1.J9 UH1.B30
DMI_CRX_PTX_P0: CPU1.D8 UH1.B27
DMI_CRX_PTX_P1: CPU1.E6 UH1.A28
DMI_CRX_PTX_P2: CPU1.D5 UH1.C29
DMI_CRX_PTX_P3: CPU1.J8 UH1.A30
DMI_CTX_PRX_N0: CPU1.A8 UH1.L27
DMI_CTX_PRX_N1: CPU1.B6 UH1.E24
DMI_CTX_PRX_N2: CPU1.A5 UH1.G27
DMI_CTX_PRX_N3: CPU1.B4 UH1.L29
DMI_CTX_PRX_P0: CPU1.B8 UH1.N27
DMI_CTX_PRX_P1: CPU1.C6 UH1.G24
DMI_CTX_PRX_P2: CPU1.B5 UH1.E26
DMI_CTX_PRX_P3: CPU1.D4 UH1.K29
DMIC0: C1468.1 D22.3 JEDP1.13 JIO1.49 R362.1
DMIC0_R: C365.2 R362.2
DMIC_CLK: C1467.1 D22.2 JEDP1.11 JIO1.47 R361.1
DMIC_CLK_R: R361.2 U8.30
DOCK_5V_IS: JIO2.65 U46.A3
DOCK_AC_OFF: JDOCK1.2 PD1010.1 PR1031.2
DOCK_AC_OFF_EC: PR1018.1 PR1020.2 U46.A63
DOCK_DCIN_IS+: JDOCK1.134 PQ703.1 PR715.1
DOCK_DCIN_IS-: JDOCK1.136 PR713.2
DOCK_DET#: D32.2 R755.2 U46.B41
DOCK_DET_R#: D32.1 JDOCK1.142 JDOCK1.144
DOCK_HP_DET: JIO1.85 U46.A7
DOCK_LOM_ACTLED_YEL#: JDOCK1.100 U32.19
DOCK_LOM_SPD10LED_GRN#: JDOCK1.3 U32.40
DOCK_LOM_SPD100LED_ORG#: JDOCK1.4 U32.20
DOCK_MIC_DET: JIO1.87 U46.B8
DOCK_POR_RST#: C737.1 JDOCK1.140 RP7.8 U51.A21
DOCK_PSID: JDOCK1.135 PD6.2 PD6.3 PU1.1
DOCK_PWR_BTN#: C733.1 JDOCK1.139 R825.2
DOCK_PWR_SW#: C734.1 R819.2 R825.1 U51.A63
DOCK_TNY_SMB_CLK: JDOCK1.127 JIO2.73 R841.2 U51.B4
DOCK_TNY_SMB_DAT: JDOCK1.129 JIO2.75 R838.2 U51.A3
DOCK_TNY_SMBUS_ALRT#: JDOCK1.133 JIO2.71 PQ1.3 R763.2 U46.A51
DOCKED: U32.13 U46.A38
DP1_DEMUX_CFG0: RV42.2 UV2.59
DP1_DEMUX_PC10: RV33.2 RV39.1 UV2.56
DP1_DEMUX_PC11: RV32.2 RV37.1 UV2.55
DP1_DEMUX_PC20: RV31.2 RV38.1 UV2.54
DP1_DEMUX_PC21: RV30.2 RV36.1 UV2.53
DP1_DEMUX_PEQ: RV29.2 RV35.1 UV2.8
DP1_DEMUX_PI0: RV44.2 UV2.60
DP1_DEMUX_PI1: RV34.2 RV40.1 UV2.1
DP1_DEMUX_SW: RV43.2 UV2.18
DP1_GPU_SEL#: U46.B49 U631.54
DP1_MUX_CEXT: C97.2 U629.47
DP1_MUX_IN1_AEQ#: R117.1 U629.59
DP1_MUX_IN1_PEQ: R119.1 R121.1 U629.52
DP1_MUX_IN2_AEQ#: R118.1 U629.58
DP1_MUX_IN2_PEQ: R120.1 R122.1 U629.51
DP1_MUX_PC0: R98.1 R115.1 U629.38
DP1_MUX_PC1: R99.1 R116.1 U629.55
DP1_MUX_PI0: R123.1 R124.1 U629.56
DP1_MUX_REXT: R96.2 U629.34
DP2_GPU_SEL#: U46.B7 U636.54
DP2_MUX_CEXT: C99.2 U631.47
DP2_MUX_IN1_AEQ#: R149.1 U631.59
DP2_MUX_IN1_PEQ: R125.1 R146.1 U631.52
DP2_MUX_IN2_AEQ#: R151.1 U631.58
DP2_MUX_IN2_PEQ: R126.1 R147.1 U631.51
DP2_MUX_PC0: R102.1 R128.1 U631.38
DP2_MUX_PC1: R104.1 R150.1 U631.55
DP2_MUX_PI0: R148.1 R152.1 U631.56
DP2_MUX_REXT: R97.2 U631.34
DP3_MUX_CEXT: C100.2 U636.47
DP3_MUX_IN1_AEQ#: R159.1 U636.59
DP3_MUX_IN1_PEQ: R153.1 R156.1 U636.52
DP3_MUX_IN2_AEQ#: R161.1 U636.58
DP3_MUX_IN2_PEQ: R154.1 R157.1 U636.51
DP3_MUX_PC0: R105.1 R155.1 U636.38
DP3_MUX_PC1: R107.1 R160.1 U636.55
DP3_MUX_PI0: R158.1 R162.1 U636.56
DP3_MUX_REXT: R106.2 U636.34
DPC_CA_DET: JDOCK1.6 RV45.2 UV2.43
DPC_CA_DET_IN: C1344.1 Q353.2 UV2.4
DPC_CA_DET_Q: Q353.3 Q355.2 Q355.5 Q364.2 Q364.5 R2189.2
DPD_CA_DET: JDOCK1.5 Q347.2 R492.2 U629.48
DPD_CA_DET_Q: Q343.2 Q343.5 Q347.3 Q365.2 Q365.5 R721.2
DRON: PU1100.17 PU1200.2 PU1201.2 PU1202.2 PU1400.2 PU1401.2 PU1402.2 PU1700.2
DSCHRG_MOSFET_GC: PR1004.2 PU1001.29
EC5048_TX: R862.2 U46.B2
EC5048_TX_R: JDEG2.9 R849.2 R862.1 R863.1
EC_32KHZ_ECE5048: U46.B35 U51.B2
EC_FPM_EN: JUSH1.22 U51.B62
EDP_AUXN: C555.1 CPU1.B26
EDP_AUXN_C: C555.2 U630.27
EDP_AUXP: C558.1 CPU1.C26
EDP_AUXP_C: C558.2 U630.28
EDP_COMP: CPU1.D37 RC1.2
EDP_IN1_AEQ#: R140.1 U630.59
EDP_IN1_PEQ: R127.1 R137.1 U630.52
EDP_IN2_AEQ#: R142.1 U630.58
EDP_IN2_PEQ: R133.1 R138.1 U630.51
EDP_MUX_PC0: R100.1 R136.1 U630.38
EDP_MUX_PC1: R109.1 R141.1 U630.55
EDP_MUX_PI0: R139.1 R143.1 U630.56
EDP_TXN0: C563.1 CPU1.E29
EDP_TXN0_C: C563.2 U630.2
EDP_TXN1: C567.1 CPU1.E28
EDP_TXN1_C: C567.2 U630.5
EDP_TXN2: C571.1 CPU1.B29
EDP_TXN2_C: C571.2 U630.7
EDP_TXN3: C572.1 CPU1.B28
EDP_TXN3_C: C572.2 U630.10
EDP_TXP0: C561.1 CPU1.D29
EDP_TXP0_C: C561.2 U630.1
EDP_TXP1: C565.1 CPU1.F28
EDP_TXP1_C: C565.2 U630.4
EDP_TXP2: C569.1 CPU1.A29
EDP_TXP2_C: C569.2 U630.6
EDP_TXP3: C570.1 CPU1.C28
EDP_TXP3_C: C570.2 U630.9
EDRAM_OPIO_RCOMP: CPU1.BR25 RC228.2
EDRAM_OPIO_RCOMP_ED2: CPU1.BP25 RC229.2
EN_+1VSP: PC800.1 PR804.2 PR809.2 PU800.3
EN_DK_PWRBAR: PR1027.1 PR1028.1 PU1001.17
EN_DOCK_PWR_BAR: PR1027.2 U46.B37
EN_EDRAMP: PC507.1 PR507.1 PR510.1 PU500.5
EN_EOPIOP: PC1806.1 PR1807.1 PR1809.1 PU1800.5
EN_I2S_NB_CODEC#: JIO1.45 U46.B36
EN_INVPWR: Q22.2 RP7.6 U51.A25
EN_PIC_LDO: JIO2.61 U46.A47
ENVDD_PCH: D92.2 U51.A7 UH1.W42
EQ0_A_UN8: RN106.1 RN108.2 UN8.23
EQ0_A_UN9: RN121.2 RN125.1 UN9.23
EQ0_B_UN8: RN60.1 RN114.2 UN8.11
EQ0_B_UN9: RN55.1 RN129.2 UN9.11
EQ1_A_UN8: RN107.1 RN109.2 UN8.22
EQ1_A_UN9: RN122.2 RN126.1 UN9.22
EQ1_B_UN8: RN51.1 RN115.2 UN8.21
EQ1_B_UN9: RN57.1 RN130.2 UN9.21
EQ2_A_UN8: RN104.2 RN105.1 UN8.19
EQ2_A_UN9: RN123.2 RN124.1 UN9.19
EQ2_B_UN8: RN110.2 RN111.1 UN8.16
EQ2_B_UN9: RN127.2 RN128.1 UN9.16
ERC1: PC1007.1 PU1001.3
ERC2: PC1009.1 PU1001.13
ERC3: PC1008.1 PU1001.12
FAN1_PWM: JFAN1.3 R22.1 R28.1 R407.2
FAN1_PWM_AAC: R28.2 U8.2
FAN1_PWM_EC: R22.2 R25.2 U51.A24
FAN1_PWM_EC_AAC: R25.1 U8.4
FAN1_TACH_EC: R13.2 R23.2 U51.B22
FAN1_TACH_EC_AAC: R23.1 U8.26
FAN1_TACH_FB: JFAN1.2 R13.1 R30.1 R408.2
FAN1_TACH_FB_AAC: R30.2 U8.24
FAN2_PWM: D90.1 R21.1 R27.1 R213.2 R409.2
FAN2_PWM_AAC: R27.2 U8.3
FAN2_PWM_D: D90.2 JFAN2.3 R213.1 R403.2
FAN2_PWM_EC: R21.2 R26.2 U51.A23
FAN2_PWM_EC_AAC: R26.1 U8.5
FAN2_TACH_EC: R12.2 R24.2 U51.B23
FAN2_TACH_EC_AAC: R24.1 U8.27
FAN2_TACH_FB: JFAN2.2 R12.1 R29.1 R405.2
FAN2_TACH_FB_AAC: R29.2 U8.25
FB_2.5V: PC402.2 PR404.2 PR405.1 PU400.1
FB_3PH_A: PC1113.2 PC1115.2 PR1130.1 PR1131.1 PU1100.5
FB_3PH_B: PC1116.2 PC1117.1 PR1136.1 PR1137.1 PU1100.34
FB_3V: PR100.2 PR102.2 PU101.4
FB_5V: PR101.1 PR104.1 PU101.2
FB_+1VSP: PR807.1 PR808.1 PU800.4
FB_+V0.95SP: PR307.1 PR309.2 PR310.1 PU300.4
FFS_INT2: Q29.2 R504.2 U88.11 UH1.AN41
FFS_INT2_Q: JSATA2.22 R386.2 U639.4
FFS_INT2_QR: Q29.3 R386.1 R506.2 U639.3
FIVR_EN_R: JXDP1.45 RC126.2 RC132.1 RC217.2
FWP#: R872.2 R879.2 U51.B65
GC6_FB_EN: JMXM1.79 UH1.AW27
GC6_THM_ON: RH342.1 U46.A48
GPIO_PSID_SELECT: PU1.6 U46.A6
GPIOL0: R3741.1 U46.B60
GPP_A14: RH95.1 UH1.BC18
GPP_B23: QH5.3 RH347.1 RH353.2 UH1.AT27
GPP_B23_Q: QH5.1 RH329.1 RH353.1
GPP_C5: RH78.2 UH1.BA40
GPP_C8: RH207.2 UH1.BA41
GPP_D14: RC76.1 UH1.AK44
GPP_D16: RC75.1 UH1.AJ43
GPP_F23: RH214.1 UH1.V44
GPU_EVENT#: D94.1 RH345.2 UH1.AR24
GPU_EVENT#_D: D94.2 JMXM1.78
GPU_PWR_LEVEL: R782.1 U17.2 U46.A52
GPU_SMBCLK_R: JMXM1.70 Q295.4 R1.2
GPU_SMBDAT_R: JMXM1.68 Q295.1 R2.2
GREEN_DOCK: JDOCK1.59 JMXM1.198
H_CATERR#: CPU1.BM30 RC172.1
H_PECI: CPU1.BT34 R953.2 RH73.2
H_PM_DOWN: RC168.1 UH1.AH2
H_PM_DOWN_R: CPU1.BP31 RC168.2
H_PM_SYNC: CPU1.BM34 RC167.2
H_PM_SYNC_R: RC167.1 UH1.AJ4
H_PROCHOT#: PQ1074.6 PR725.1 PR1103.2 PR1110.2 PR1607.2 RC158.1 RC180.2 U51.A46
H_PROCHOT#_R: CPU1.BR30 RC158.2
H_PWRGD: CPU1.BT31 UH1.AM3
H_SKTOCC#: CPU1.BR33 RC319.2
H_THERMTRIP#: CPU1.J31 RC169.2
H_VCCST_PWRGD_XDP: JXDP1.39 RC124.2
HDA_BIT_CLK: RH46.2 UH1.BA9
HDA_BIT_CLK_R: CH268.2 JIO1.73 RH46.1
HDA_RST#: RH50.2 UH1.BD8
HDA_RST#_R: JIO1.81 RH50.1
HDA_SDIN0: JIO1.75 UH1.BE7
HDA_SDOUT: RH45.2 RH328.2 UH1.BB7
HDA_SDOUT_R: JIO1.77 RH45.1
HDA_SYNC: RH48.2 UH1.BD9
HDA_SYNC_R: JIO1.79 RH48.1
HDD_DET#: JSATA2.20 RH324.2 UH1.AG39
HDD_FALL_INT: R503.2 U88.12 UH1.AW17
HDD_IFDET: JSATA2.19 R317.1 U6.2
HOST_DEBUG_TX: JDEG2.8 R848.2 U51.B44
HOST_SD_WP#: JIO1.71 UH1.AU44
HSYNC_DOCK: JDOCK1.65 JMXM1.192
HW_GPS_DISABLE#: DZ2.1 R779.2 U46.A35
HW_GPS_DISABLE#_R: DZ2.2 JNGFF2.18
I2C_1_SCL: R3758.1 RZ37.2 UH1.AR41
I2C_1_SCL_R: JKBTP1.2 R3758.2 RZ117.2
I2C_1_SDA: R3752.1 RZ36.2 UH1.AR44
I2C_1_SDA_R: JKBTP1.3 R3752.2 RZ116.2
I_ADP: PR716.1 R134.1
I_ADP_R: R134.2 U51.A12
I_BATT: PR726.1 U51.B61
ILIM_3PH_A: PR1138.2 PU1100.7
ILIM_3PH_B: PR1139.1 PU1100.32
ILMT_0.95V: PR306.2 PR308.1 PU300.3
IMVP_VR_ON: PR507.2 PR1198.2 PR1807.2 PU1600.40 RC327.2 UC5.4 UC6.2
IMVP_VR_ON_EC: RC327.1 U51.A1 UC5.1
IRQ_SERIRQ: RH340.1 U46.B21 U51.A28 UH1.BA17
ITP_PMODE_CPU: RC144.2 T192.1(TP-1) UH1.AT2
JDIMM1_EVENT#: JDIMM1.134 RD3.1
JDIMM2_EVENT#: JDIMM2.134 RD4.1
JDIMM3_EVENT#: JDIMM3.134 RD5.1
JDIMM4_EVENT#: JDIMM4.134 RD12.1
JTAG_CLK: JDEG2.4 R860.2 U51.B56
JTAG_RST#: C735.1 JTAG1.1 R836.1 R1981.2 U51.B47
JTAG_TDI: JDEG2.2 R858.2 U51.A51
JTAG_TDO: JDEG2.5 R861.2 U51.B55
JTAG_TMS: JDEG2.3 R859.2 U51.A53
KB_DET#: JKBTP1.20 RC74.1 UH1.BD22
LAN_ACTLED_YEL#: Q325.1 U32.17
LAN_ACTLED_YEL#_Q: Q325.6 R1171.1
LAN_DISABLE#_R: R549.2 R555.2 R557.1 U31.3 U46.B53
LAN_MDIN0: R69.1 U31.14
LAN_MDIN0_L: R69.2 U32.11
LAN_MDIN1: R67.1 U31.18
LAN_MDIN1_L: R67.2 U32.9
LAN_MDIN2: R65.1 U31.21
LAN_MDIN2_L: R65.2 U32.6
LAN_MDIN3: R63.1 U31.24
LAN_MDIN3_L: R63.2 U32.2
LAN_MDIP0: R70.1 U31.13
LAN_MDIP0_L: R70.2 U32.12
LAN_MDIP1: R68.1 U31.17
LAN_MDIP1_L: R68.2 U32.10
LAN_MDIP2: R66.1 U31.20
LAN_MDIP2_L: R66.2 U32.7
LAN_MDIP3: R64.1 U31.23
LAN_MDIP3_L: R64.2 U32.3
LAN_TEST_EN: R561.1 U31.30
LAN_WAKE#: R556.1 RH93.1 U51.B27 UH1.BD11
LAN_WAKE#_R: R556.2 R559.1 U31.2
LCD_CBL_DET#: JEDP1.20 RC79.1 UH1.AT44
LCD_TST: JEDP1.24 RP4.2 U46.A36
LCD_VCC_TEST_EN: D93.2 U46.A40
LED_10_GRN#: Q327.3 R378.2 U32.41
LED_10_GRN#_Q: Q327.1 R1170.1
LED_100_ORG#: Q325.4 R377.2 U32.18
LED_100_ORG#_Q: Q325.3 R1167.1
LED_SATA_DIAG_OUT#: D62.1 U46.A10
LG_3V: PQ102.4 PU101.11
LG_5V: PQ103.4 PU101.15
LG_+1VSP: PQ801.4 PU800.6
LGATE_CHG: PQ705.4 PU700.23
LID_CL#: JPB1.5 R807.1 U58.2
LID_CL_SIO#: C716.1 R805.2 R807.2 U46.B54
LOM_ACTLED_YEL#: U31.26 U32.15
LOM_SPD10LED_GRN#: U15.2 U31.25 U32.42
LOM_SPD100LED_ORG#: U15.1 U31.27 U32.16
LP#_EDRAMP: PR500.1 PR501.1 PU500.6
LP#_EOPIOP: PR1800.1 PR1801.1 PU1800.6
LPC_AD0: JLPDE1.3 U46.A27 U51.A30 UH1.AT22
LPC_AD1: JLPDE1.4 U46.A26 U51.B32 UH1.AV22
LPC_AD2: JLPDE1.5 U46.B26 U51.A31 UH1.AT19
LPC_AD3: JLPDE1.6 U46.B25 U51.B33 UH1.BD16
LPC_FRAME#: JLPDE1.7 U46.A21 U51.B31 UH1.BE16
LPC_LDRQ1#: R783.1 U46.A22
LPS_PROTECT#: JIO2.67 U46.B66
LPSS_UART2_RXD: JUART1.3 RH352.2 RH355.2 UH1.AR45
LPSS_UART2_TXD: JUART1.2 RH351.2 RH354.2 UH1.AR39
LX_2.5V: PL400.1 PR403.1 PU400.6
LX_CHG: PC734.1 PL701.1 PQ704.1 PQ704.2 PQ704.3 PQ705.5 PR724.1 PU700.27
M2_SLOT2_PCIE#_SATA: RH318.2 U46.A45 UH1.AD31
M2_SLOT3_PEDET: QN5.1 R363.1 R372.1 UH1.AG36
M_REXT_UN8: RN53.1 UN8.10
M_REXT_UN9: RN58.1 UN9.10
MASK_BASE_LEDS#: Q359.2 U58.4
MASK_SATA_LED#: Q74.5 U46.B9
ME_FWP: RC301.1 RH328.1 SW2.3
ME_FWP_EC: RC301.2 SW2.1 U46.A64
ME_RESET#: RH70.1 UC3.2
ME_SUS_PWR_ACK: RH84.2 RH327.1 U51.A8 UH1.BD19
MEC_XTAL1: C743.1 U51.A61 Y6.1
MEC_XTAL2: C741.1 R1068.2 Y6.2
MEC_XTAL2_R: R1068.1 U51.A62
MEDIACARD_IRQ#: JIO1.67 UH1.AL39
MEM_SMBCLK: QH4.6 RH56.2 UH1.AW44
MEM_SMBDATA: QH4.3 RH65.2 UH1.BB43
MID1_CA_DET: JIO2.59 RV28.2 U631.48 UV2.33
MID2_CA_DET: JIO2.84 Q367.2 RV48.1 U636.48
MID2_CA_DET_Q: Q367.3 Q369.2 Q369.5 R3746.2
MSCLK: JDEG2.6 R847.2 U51.B43
MSDATA: JDEG2.7 R850.2 R869.2 U51.A40
MUX_CET: C98.2 U630.47
MUX_REXT: R101.2 U630.34
MXM_ALERT#: JMXM1.58 Q5.3 R4.2
MXM_BIA_PWM: JMXM1.63 U3.2
MXM_CLK_REQ#: JMXM1.182 R1978.2
MXM_DP_HDMI_HPD: D7.1 D8.1 D18.1 RP4.4 U46.B4
MXM_DPA_AUXN: C1437.1 JMXM1.307 Q355.4 UV2.23
MXM_DPA_AUXN_C: C1437.2 UV2.25
MXM_DPA_AUXP: C1438.1 JMXM1.309 Q355.1 UV2.22
MXM_DPA_AUXP_C: C1438.2 UV2.24
MXM_DPA_HPD: D8.2 U27.2 UV2.3
MXM_DPA_HPD_GATE: JMXM1.304 R60.1 U27.4
MXM_DPA_N0: C540.1 JMXM1.283
MXM_DPA_N0_C: C540.2 UV2.7
MXM_DPA_N1: C550.1 JMXM1.289
MXM_DPA_N1_C: C550.2 UV2.10
MXM_DPA_N2: C553.1 JMXM1.295
MXM_DPA_N2_C: C553.2 UV2.13
MXM_DPA_N3: C575.1 JMXM1.301
MXM_DPA_N3_C: C575.2 UV2.16
MXM_DPA_P0: C545.1 JMXM1.285
MXM_DPA_P0_C: C545.2 UV2.6
MXM_DPA_P1: C551.1 JMXM1.291
MXM_DPA_P1_C: C551.2 UV2.9
MXM_DPA_P2: C573.1 JMXM1.297
MXM_DPA_P2_C: C573.2 UV2.12
MXM_DPA_P3: C577.1 JMXM1.303
MXM_DPA_P3_C: C577.2 UV2.15
MXM_DPB_AUXN: C627.1 JMXM1.298 R3747.2 U636.22
MXM_DPB_AUXN_C: C627.2 U636.27
MXM_DPB_AUXP: C601.1 JMXM1.300 R3745.2 U636.23
MXM_DPB_AUXP_C: C601.2 U636.28
MXM_DPB_HPD: D18.2 U14.2 U636.3
MXM_DPB_HPD_GATE: JMXM1.302 R758.1 U14.4
MXM_DPB_N0: C585.1 JMXM1.274
MXM_DPB_N0_C: C585.2 U636.2
MXM_DPB_N1: C589.1 JMXM1.280
MXM_DPB_N1_C: C589.2 U636.5
MXM_DPB_N2: C592.1 JMXM1.286
MXM_DPB_N2_C: C592.2 U636.7
MXM_DPB_N3: C595.1 JMXM1.292
MXM_DPB_N3_C: C595.2 U636.10
MXM_DPB_P0: C587.1 JMXM1.276
MXM_DPB_P0_C: C587.2 U636.1
MXM_DPB_P1: C590.1 JMXM1.282
MXM_DPB_P1_C: C590.2 U636.4
MXM_DPB_P2: C594.1 JMXM1.288
MXM_DPB_P2_C: C594.2 U636.6
MXM_DPB_P3: C596.1 JMXM1.294
MXM_DPB_P3_C: C596.2 U636.9
MXM_DPC_AUXN: C531.1 JMXM1.253 R132.2 U629.22
MXM_DPC_AUXN_C: C531.2 U629.27
MXM_DPC_AUXP: C532.1 JMXM1.255 R129.2 U629.23
MXM_DPC_AUXP_C: C532.2 U629.28
MXM_DPC_HPD: D7.2 U25.2 U629.3
MXM_DPC_HPD_GATE: JMXM1.262 R519.2 U25.4
MXM_DPC_N0: C525.1 JMXM1.229
MXM_DPC_N0_C: C525.2 U629.2
MXM_DPC_N1: C527.1 JMXM1.235
MXM_DPC_N1_C: C527.2 U629.5
MXM_DPC_N2: C529.1 JMXM1.241
MXM_DPC_N2_C: C529.2 U629.7
MXM_DPC_N3: C528.1 JMXM1.247
MXM_DPC_N3_C: C528.2 U629.10
MXM_DPC_P0: C523.1 JMXM1.231
MXM_DPC_P0_C: C523.2 U629.1
MXM_DPC_P1: C524.1 JMXM1.237
MXM_DPC_P1_C: C524.2 U629.4
MXM_DPC_P2: C526.1 JMXM1.243
MXM_DPC_P2_C: C526.2 U629.6
MXM_DPC_P3: C530.1 JMXM1.249
MXM_DPC_P3_C: C530.2 U629.9
MXM_EDP_AUXN: C568.1 JMXM1.258
MXM_EDP_AUXN_C: C568.2 U630.29
MXM_EDP_AUXP: C566.1 JMXM1.260
MXM_EDP_AUXP_C: C566.2 U630.30
MXM_EDP_HPD: JMXM1.264 U630.13
MXM_EDP_N0: C537.1 JMXM1.234
MXM_EDP_N0_C: C537.2 U630.12
MXM_EDP_N1: C556.1 JMXM1.240
MXM_EDP_N1_C: C556.2 U630.15
MXM_EDP_N2: C559.1 JMXM1.246
MXM_EDP_N2_C: C559.2 U630.17
MXM_EDP_N3: C562.1 JMXM1.252
MXM_EDP_N3_C: C562.2 U630.20
MXM_EDP_P0: C549.1 JMXM1.236
MXM_EDP_P0_C: C549.2 U630.11
MXM_EDP_P1: C557.1 JMXM1.242
MXM_EDP_P1_C: C557.2 U630.14
MXM_EDP_P2: C560.1 JMXM1.248
MXM_EDP_P2_C: C560.2 U630.16
MXM_EDP_P3: C564.1 JMXM1.254
MXM_EDP_P3_C: C564.2 U630.19
MXM_ENVDD: D93.3 JMXM1.59
MXM_OVERT#: JMXM1.56 Q4.3 R10.2
MXM_PANEL_BKEN: D64.2 JMXM1.61
MXM_PRESENTL#: JMXM1.310 RH317.2 UH1.M44
MXM_PRESENTR#: JMXM1.38 RH91.2 UH1.T45
MXM_PWR_LEVEL: JMXM1.54 PQ1074.3 R37.2 U17.4
MXM_VGA_DIS#: R1971.1 U46.B16
NB_PSID: PD4.2 PD4.3 PJPDC1.2 PL3.2
NB_PSID_TS5A63157: PR8.1 PR9.2 PU1.3
NRB_BIT: RH331.2 UH1.BD28
NXRES: JDEG3.3 U8.32
OA_M1: C141.2 R373.1 R414.2 U8.41
OA_M2: C143.2 R375.1 R376.2 U8.38
OA_OUT1: C141.1 C1420.2 R414.1 U8.40
OA_OUT2: C143.1 R376.1 U8.39
P0_7: R413.2 U8.31
P33ALW: PR1025.1 PU1001.18
P33ALW2: PR1022.2 PU1001.9
P50ALW: PR1012.1 PU1001.27
PANEL_BKEN_EC: D69.2 U46.B38
PANEL_BKEN_PCH: D65.2 UH1.W35
PANEL_ID: C1465.1 R3754.2 U51.A10
PBA_GPU_SEL#: U46.A15 U629.54
PBAT_PRES#: JIO2.64 PD3.2 PD5.1 PR2.2 PR3.7 PR728.1 U51.A49
PBAT_SMBCLK: PD2.2 PR3.5 RP5.7 U51.A56
PBAT_SMBDAT: PD2.3 PR3.6 RP5.8 U51.B59
PBATT+: PD702.2 PL2.2 PL6.2 PQ1002.1 PQ1002.2 PQ1002.3 PQ1003.1 PQ1003.2 PQ1003.3 PR1008.1
PBATT+_C: PBATT1.8 PBATT1.9 PC4.1 PL2.1 PL6.1
PBATT_IN_SS: PD1002.2 PD1002.3 PQ1003.5 PQ1004.5 PR1003.1 PR1005.1
PCH_2_CPU_TRIGGER: CPU1.H23 RH42.2
PCH_2_CPU_TRIGGER_R: RH42.1 UH1.AL2
PCH_AAC_SMBCLK: R41.2 UH1.AR38
PCH_AAC_SMBDAT: R40.2 UH1.AT42
PCH_ALW_ON: PR809.1 R417.1 RP7.7 U51.A34
PCH_BATLOW#: RH94.1 UH1.BD13
PCH_CL_CLK1: JNGFF1.34 UH1.AV2
PCH_CL_DATA1: JNGFF1.32 UH1.AV3
PCH_CL_RST1#: JNGFF1.30 UH1.AW2
PCH_CPU_BCLK_D: RH161.2 UH1.G2
PCH_CPU_BCLK_D#: RH166.2 UH1.H2
PCH_CPU_BCLK_R_D: CPU1.B31 RH161.1
PCH_CPU_BCLK_R_D#: CPU1.A32 RH166.1
PCH_CPU_NSSC_CLK_D: RH169.2 UH1.G1
PCH_CPU_NSSC_CLK_D#: RH170.2 UH1.F1
PCH_CPU_PCIBCLK_D: RH167.1 UH1.J2
PCH_CPU_PCIBCLK_D#: RH168.1 UH1.J1
PCH_CPU_PCIBCLK_R_D: CPU1.D35 RH167.2
PCH_CPU_PCIBCLK_R_D#: CPU1.C36 RH168.2
PCH_DPB_CTRL_CLK: RH222.1 U629.25 UH1.BA5
PCH_DPB_CTRL_DATA: RH223.1 U629.24 UH1.BC4
PCH_DPB_HPD: U629.13 UH1.AW4
PCH_DPC_CTRL_CLK: RH220.1 U631.25 UH1.BB3
PCH_DPC_CTRL_DATA: RH221.1 U631.24 UH1.BD6
PCH_DPC_HPD: U631.13 UH1.AY2
PCH_DPD_CTRL_CLK: RH224.1 U636.25 UH1.BE5
PCH_DPD_CTRL_DATA: RH225.1 U636.24 UH1.BE6
PCH_DPD_HPD: U636.13 UH1.AV4
PCH_DPWROK: CH266.1 R802.1 RH215.1 RH308.1 UH1.AV11
PCH_INTRUDER_HDR#: RH198.2 UH1.BE11
PCH_JTAG_TCK: JXDP1.55 RH313.2 T188.1(TP-1) UH1.AN3
PCH_JTAG_TDI: RC308.2 RH314.2 T187.1(TP-1) UH1.AP2
PCH_JTAG_TDO: RC309.2 RH315.2 T186.1(TP-1) UH1.AP1
PCH_JTAG_TMS: RC307.2 RH312.2 T183.1(TP-1) UH1.AR2
PCH_JTAGX: RC143.2 RC166.1 T182.1(TP-1) UH1.AR3
PCH_PCIE_WAKE#: RH92.1 U51.B46 UH1.BC13
PCH_PECI: RH73.1 RH74.1 UH1.AL3
PCH_PLTRST#: RH187.1 RH194.1 RH195.1 RH210.1 RH211.1 U638.1 U638.2 UH1.BB27
PCH_PLTRST#_AND: RH196.1 RH197.1 RH212.1 RH337.1 RH346.1 U638.4
PCH_PLTRST#_EC: JLPDE1.8 JNGFF1.44 JNGFF2.42 JNGFF3.50 RH337.2 U46.B22 U51.B30
PCH_PWROK: PR1114.2 PU1100.45 PU1600.6 UH1.AW11
PCH_RSMRST#: R892.2 U51.A45 UC4.1
PCH_RSMRST#_R: RC124.1 RC154.2 RC318.1 RH215.2 T191.1(TP-1) UH1.BA11
PCH_RTCRST#: CH40.2 CMOS1.2 JAPS1.9 RH200.2 UH1.BC10
PCH_RTCX1: RH43.2 RH44.1 UH1.BC9
PCH_RTCX1_R: CH4.2 RH43.1 YH1.1
PCH_RTCX2: CH5.2 RH44.2 UH1.BD10 YH1.2
PCH_SATA_LED#: D97.1 R383.2 UH1.AD44
PCH_SMB_ALERT#: RH61.2 UH1.BB41
PCH_SPI_CLK: JSPI1.8 RH181.2 UH1.BC31
PCH_SPI_CLK_0_R: R899.1 RE1.1 U52.6
PCH_SPI_CLK_1_R: R897.1 R3755.1 U53.6
PCH_SPI_CLK_R1: JSPI1.7 R897.2 R899.2 RH181.1 RZ26.1
PCH_SPI_CS#0: JSPI1.10 RH182.2 UH1.BD31
PCH_SPI_CS#0_R1: JSPI1.9 R7.1 RH182.1
PCH_SPI_CS#0_R2: R7.2 U52.1
PCH_SPI_CS#1: JSPI1.2 RH177.2 UH1.AW31
PCH_SPI_CS#1_R1: JSPI1.1 R936.1 RH177.1
PCH_SPI_CS#1_R2: R936.2 U53.1
PCH_SPI_CS#2: RZ17.1 UH1.AT31
PCH_SPI_CS#2_R: RZ17.2 RZ80.1 RZ84.1 U637.20
PCH_SPI_D0: JSPI1.4 RC128.1 RC133.1 RH178.2 UH1.BB29
PCH_SPI_D0_0_R: R901.1 U52.5
PCH_SPI_D0_1_R: R900.1 U53.5
PCH_SPI_D0_R1: JSPI1.3 R900.2 R901.2 RH178.1 RZ29.1
PCH_SPI_D1: JSPI1.6 RH179.2 UH1.BE30
PCH_SPI_D1_0_R: R8.2 U52.2
PCH_SPI_D1_1_R: R895.2 U53.2
PCH_SPI_D1_R1: JSPI1.5 R8.1 R895.1 RH179.1 RZ30.1
PCH_SPI_D2: JSPI1.12 RH180.2 RH183.2 UH1.BC29
PCH_SPI_D2_0_R: R9.2 R3664.2 U52.3
PCH_SPI_D2_1_R: R3665.2 R3667.2 U53.3
PCH_SPI_D2_R1: JSPI1.11 R9.1 R3667.1 RH183.1
PCH_SPI_D2_XDP: RC127.2 RH180.1
PCH_SPI_D3: JSPI1.14 RH184.2 RH334.1 RH335.1 UH1.BD30
PCH_SPI_D3_0_R: R3668.2 R3669.1 U52.7
PCH_SPI_D3_1_R: R3666.2 R3670.1 U53.7
PCH_SPI_D3_R1: JSPI1.13 R3669.2 R3670.2 RH184.1
PCH_THERMTRIP#: Q28.3 RC169.1 RC326.1 RD3.2 RD4.2 RD5.2 RD12.2 RH75.2
PCH_THERMTRIP#_R: RH75.1 UH1.AJ3
PCH_XDP_CLK_DN: JXDP1.42 RH154.2
PCH_XDP_CLK_DN_R: RH154.1 UH1.L1
PCH_XDP_CLK_DP: JXDP1.40 RH155.2
PCH_XDP_CLK_DP_R: RH155.1 UH1.L2
PCH_XDP_PRDY#: RC314.2 UH1.AT4
PCH_XDP_PREQ#: RC315.2 UH1.AT3
PCI_CLK_LPC0: RH96.1 RH97.1 UH1.BC17
PCI_CLK_LPC1: RH98.1 RH99.1 UH1.AV19
PCIE_PRX_C_DTX_N4: C459.1 U31.39
PCIE_PRX_C_DTX_N15: JSATA2.11 RN132.1
PCIE_PRX_C_DTX_N16: JSATA2.5 RN134.1
PCIE_PRX_C_DTX_P4: C458.1 U31.38
PCIE_PRX_C_DTX_P15: JSATA2.12 RN131.1
PCIE_PRX_C_DTX_P16: JSATA2.6 RN133.1
PCIE_PRX_C_RD_DTX_N15: CN76.2 UN8.4
PCIE_PRX_C_RD_DTX_N16: CN80.2 UN9.4
PCIE_PRX_C_RD_DTX_P15: CN69.2 UN8.5
PCIE_PRX_C_RD_DTX_P16: CN74.2 UN9.5
PCIE_PRX_DTX_N2: JNGFF1.35 UH1.E17
PCIE_PRX_DTX_N3: JIO1.42 UH1.L17
PCIE_PRX_DTX_N4: C459.2 UH1.E20
PCIE_PRX_DTX_N5: JIO2.120 UH1.K19
PCIE_PRX_DTX_N6: JIO2.132 UH1.G22
PCIE_PRX_DTX_N7: JIO2.144 UH1.L22
PCIE_PRX_DTX_N8: JIO2.156 UH1.K24
PCIE_PRX_DTX_N9: JNGFF3.43 UH1.G31
PCIE_PRX_DTX_N10: JNGFF3.29 UH1.G29
PCIE_PRX_DTX_N11: JNGFF3.17 UH1.L31
PCIE_PRX_DTX_N12: JNGFF3.5 UH1.G33
PCIE_PRX_DTX_N15: CN76.1 UH1.F41
PCIE_PRX_DTX_N16: CN80.1 UH1.D43
PCIE_PRX_DTX_N17: JNGFF2.35 UH1.H42
PCIE_PRX_DTX_N18: UH1.K37 UZ29.14
PCIE_PRX_DTX_P2: JNGFF1.33 UH1.G17
PCIE_PRX_DTX_P3: JIO1.40 UH1.K17
PCIE_PRX_DTX_P4: C458.2 UH1.G19
PCIE_PRX_DTX_P5: JIO2.122 UH1.L19
PCIE_PRX_DTX_P6: JIO2.134 UH1.E22
PCIE_PRX_DTX_P7: JIO2.146 UH1.K22
PCIE_PRX_DTX_P8: JIO2.158 UH1.L24
PCIE_PRX_DTX_P9: JNGFF3.41 UH1.H31
PCIE_PRX_DTX_P10: JNGFF3.31 UH1.E29
PCIE_PRX_DTX_P11: JNGFF3.19 UH1.K31
PCIE_PRX_DTX_P12: JNGFF3.7 UH1.H33
PCIE_PRX_DTX_P15: CN69.1 UH1.E41
PCIE_PRX_DTX_P16: CN74.1 UH1.E42
PCIE_PRX_DTX_P17: JNGFF2.33 UH1.H40
PCIE_PRX_DTX_P18: UH1.G37 UZ29.15
PCIE_PRX_RD_DTX_N15: RN132.2 UN8.15
PCIE_PRX_RD_DTX_N16: RN134.2 UN9.15
PCIE_PRX_RD_DTX_P15: RN131.2 UN8.14
PCIE_PRX_RD_DTX_P16: RN133.2 UN9.14
PCIE_PRX_SW_DTX_N18: JNGFF2.21 UZ29.4
PCIE_PRX_SW_DTX_P18: JNGFF2.23 UZ29.3
PCIE_PTX_C_DRX_N2: CZ58.2 JNGFF1.29
PCIE_PTX_C_DRX_N4: C461.2 U31.42
PCIE_PTX_C_DRX_N9: CN85.2 JNGFF3.47
PCIE_PTX_C_DRX_N10: CN88.2 JNGFF3.35
PCIE_PTX_C_DRX_N11: CN91.2 JNGFF3.23
PCIE_PTX_C_DRX_N12: CN95.2 JNGFF3.11
PCIE_PTX_C_DRX_N15: CN72.1 JSATA2.9
PCIE_PTX_C_DRX_N16: CN81.1 JSATA2.3
PCIE_PTX_C_DRX_N17: CZ1.2 JNGFF2.39
PCIE_PTX_C_DRX_N18: JNGFF2.27 RZ118.2
PCIE_PTX_C_DRX_P2: CZ3.2 JNGFF1.27
PCIE_PTX_C_DRX_P4: C460.2 U31.41
PCIE_PTX_C_DRX_P9: CN83.2 JNGFF3.49
PCIE_PTX_C_DRX_P10: CN87.2 JNGFF3.37
PCIE_PTX_C_DRX_P11: CN92.2 JNGFF3.25
PCIE_PTX_C_DRX_P12: CN97.2 JNGFF3.13
PCIE_PTX_C_DRX_P15: CN64.1 JSATA2.8
PCIE_PTX_C_DRX_P16: CN66.1 JSATA2.2
PCIE_PTX_C_DRX_P17: CZ2.2 JNGFF2.41
PCIE_PTX_C_DRX_P18: JNGFF2.29 RZ119.2
PCIE_PTX_C_RD_DRX_N15: CN63.2 UN8.2
PCIE_PTX_C_RD_DRX_N16: CN65.2 UN9.2
PCIE_PTX_C_RD_DRX_P15: CN70.2 UN8.1
PCIE_PTX_C_RD_DRX_P16: CN79.2 UN9.1
PCIE_PTX_C_SW_DRX_N18: CZ92.2 UZ29.12
PCIE_PTX_C_SW_DRX_P18: CZ91.2 UZ29.13
PCIE_PTX_DRX_N2: CZ58.1 UH1.B19
PCIE_PTX_DRX_N3: JIO1.36 UH1.B20
PCIE_PTX_DRX_N4: C461.1 UH1.B21
PCIE_PTX_DRX_N5: JIO2.114 UH1.D22
PCIE_PTX_DRX_N6: JIO2.126 UH1.B22
PCIE_PTX_DRX_N7: JIO2.138 UH1.C23
PCIE_PTX_DRX_N8: JIO2.150 UH1.C24
PCIE_PTX_DRX_N9: CN85.1 UH1.C31
PCIE_PTX_DRX_N10: CN88.1 UH1.C32
PCIE_PTX_DRX_N11: CN91.1 UH1.C33
PCIE_PTX_DRX_N12: CN95.1 UH1.B35
PCIE_PTX_DRX_N15: CN63.1 UH1.B39
PCIE_PTX_DRX_N16: CN65.1 UH1.A41
PCIE_PTX_DRX_N17: CZ1.1 UH1.E45
PCIE_PTX_DRX_N18: CZ92.1 UH1.G45
PCIE_PTX_DRX_P2: CZ3.1 UH1.C19
PCIE_PTX_DRX_P3: JIO1.34 UH1.C20
PCIE_PTX_DRX_P4: C460.1 UH1.A21
PCIE_PTX_DRX_P5: JIO2.116 UH1.C22
PCIE_PTX_DRX_P6: JIO2.128 UH1.A23
PCIE_PTX_DRX_P7: JIO2.140 UH1.B23
PCIE_PTX_DRX_P8: JIO2.152 UH1.B24
PCIE_PTX_DRX_P9: CN83.1 UH1.B31
PCIE_PTX_DRX_P10: CN87.1 UH1.B32
PCIE_PTX_DRX_P11: CN92.1 UH1.B33
PCIE_PTX_DRX_P12: CN97.1 UH1.A35
PCIE_PTX_DRX_P15: CN70.1 UH1.A39
PCIE_PTX_DRX_P16: CN79.1 UH1.A40
PCIE_PTX_DRX_P17: CZ2.1 UH1.F45
PCIE_PTX_DRX_P18: CZ91.1 UH1.G44
PCIE_PTX_RD_DRX_N15: CN72.2 UN8.17
PCIE_PTX_RD_DRX_N16: CN81.2 UN9.17
PCIE_PTX_RD_DRX_P15: CN64.2 UN8.18
PCIE_PTX_RD_DRX_P16: CN66.2 UN9.18
PCIE_PTX_SW_DRX_N18: RZ118.1 UZ29.8
PCIE_PTX_SW_DRX_P18: RZ119.1 UZ29.7
PCIE_WAKE#: JIO2.102 JNGFF1.47 JNGFF2.46 JNGFF3.54 R759.2 R1972.2 U46.B10
PCIECOMP: RH192.1 UH1.C17
PCIECOMP#: RH192.2 UH1.B18
PD_ACE_DET#: R388.1 RE77.2 U46.A60
PD_ACE_DET#_R: JIO2.34 R388.2
PECI_EC_R: C292.1 R953.1 U51.A48
PEDET: JNGFF3.61 QN5.2 R372.2
PEG_COMP: CPU1.G2 RC2.2
PEG_CRX_C_GTX_N0: CC1.2 JMXM1.177
PEG_CRX_C_GTX_N1: CC2.2 JMXM1.171
PEG_CRX_C_GTX_N2: CC3.2 JMXM1.165
PEG_CRX_C_GTX_N3: CC4.2 JMXM1.157
PEG_CRX_C_GTX_N4: CC5.2 JMXM1.151
PEG_CRX_C_GTX_N5: CC6.2 JMXM1.145
PEG_CRX_C_GTX_N6: CC7.2 JMXM1.139
PEG_CRX_C_GTX_N7: CC8.2 JMXM1.133
PEG_CRX_C_GTX_N8: CC9.2 JMXM1.127
PEG_CRX_C_GTX_N9: CC10.2 JMXM1.121
PEG_CRX_C_GTX_N10: CC11.2 JMXM1.115
PEG_CRX_C_GTX_N11: CC12.2 JMXM1.109
PEG_CRX_C_GTX_N12: CC13.2 JMXM1.103
PEG_CRX_C_GTX_N13: CC14.2 JMXM1.97
PEG_CRX_C_GTX_N14: CC15.2 JMXM1.91
PEG_CRX_C_GTX_N15: CC16.2 JMXM1.85
PEG_CRX_C_GTX_P0: CC17.2 JMXM1.179
PEG_CRX_C_GTX_P1: CC18.2 JMXM1.173
PEG_CRX_C_GTX_P2: CC19.2 JMXM1.167
PEG_CRX_C_GTX_P3: CC20.2 JMXM1.159
PEG_CRX_C_GTX_P4: CC21.2 JMXM1.153
PEG_CRX_C_GTX_P5: CC22.2 JMXM1.147
PEG_CRX_C_GTX_P6: CC23.2 JMXM1.141
PEG_CRX_C_GTX_P7: CC24.2 JMXM1.135
PEG_CRX_C_GTX_P8: CC25.2 JMXM1.129
PEG_CRX_C_GTX_P9: CC26.2 JMXM1.123
PEG_CRX_C_GTX_P10: CC27.2 JMXM1.117
PEG_CRX_C_GTX_P11: CC28.2 JMXM1.111
PEG_CRX_C_GTX_P12: CC29.2 JMXM1.105
PEG_CRX_C_GTX_P13: CC30.2 JMXM1.99
PEG_CRX_C_GTX_P14: CC31.2 JMXM1.93
PEG_CRX_C_GTX_P15: CC32.2 JMXM1.87
PEG_CRX_GTX_N0: CC1.1 CPU1.E10
PEG_CRX_GTX_N1: CC2.1 CPU1.E11
PEG_CRX_GTX_N2: CC3.1 CPU1.E12
PEG_CRX_GTX_N3: CC4.1 CPU1.E13
PEG_CRX_GTX_N4: CC5.1 CPU1.E14
PEG_CRX_GTX_N5: CC6.1 CPU1.E15
PEG_CRX_GTX_N6: CC7.1 CPU1.E16
PEG_CRX_GTX_N7: CC8.1 CPU1.E17
PEG_CRX_GTX_N8: CC9.1 CPU1.F18
PEG_CRX_GTX_N9: CC10.1 CPU1.D19
PEG_CRX_GTX_N10: CC11.1 CPU1.F20
PEG_CRX_GTX_N11: CC12.1 CPU1.D21
PEG_CRX_GTX_N12: CC13.1 CPU1.F22
PEG_CRX_GTX_N13: CC14.1 CPU1.D23
PEG_CRX_GTX_N14: CC15.1 CPU1.F24
PEG_CRX_GTX_N15: CC16.1 CPU1.D25
PEG_CRX_GTX_P0: CC17.1 CPU1.F10
PEG_CRX_GTX_P1: CC18.1 CPU1.D11
PEG_CRX_GTX_P2: CC19.1 CPU1.F12
PEG_CRX_GTX_P3: CC20.1 CPU1.D13
PEG_CRX_GTX_P4: CC21.1 CPU1.F14
PEG_CRX_GTX_P5: CC22.1 CPU1.D15
PEG_CRX_GTX_P6: CC23.1 CPU1.F16
PEG_CRX_GTX_P7: CC24.1 CPU1.D17
PEG_CRX_GTX_P8: CC25.1 CPU1.E18
PEG_CRX_GTX_P9: CC26.1 CPU1.E19
PEG_CRX_GTX_P10: CC27.1 CPU1.E20
PEG_CRX_GTX_P11: CC28.1 CPU1.E21
PEG_CRX_GTX_P12: CC29.1 CPU1.E22
PEG_CRX_GTX_P13: CC30.1 CPU1.E23
PEG_CRX_GTX_P14: CC31.1 CPU1.E24
PEG_CRX_GTX_P15: CC32.1 CPU1.E25
PEG_CTX_C_GRX_N0: CC44.1 JMXM1.176
PEG_CTX_C_GRX_N1: CC45.1 JMXM1.170
PEG_CTX_C_GRX_N2: CC53.1 JMXM1.164
PEG_CTX_C_GRX_N3: CC73.1 JMXM1.156
PEG_CTX_C_GRX_N4: CC46.1 JMXM1.150
PEG_CTX_C_GRX_N5: CC74.1 JMXM1.144
PEG_CTX_C_GRX_N6: CC47.1 JMXM1.138
PEG_CTX_C_GRX_N7: CC56.1 JMXM1.132
PEG_CTX_C_GRX_N8: CC75.1 JMXM1.126
PEG_CTX_C_GRX_N9: CC48.1 JMXM1.120
PEG_CTX_C_GRX_N10: CC59.1 JMXM1.114
PEG_CTX_C_GRX_N11: CC76.1 JMXM1.108
PEG_CTX_C_GRX_N12: CC49.1 JMXM1.102
PEG_CTX_C_GRX_N13: CC62.1 JMXM1.96
PEG_CTX_C_GRX_N14: CC77.1 JMXM1.90
PEG_CTX_C_GRX_N15: CC50.1 JMXM1.84
PEG_CTX_C_GRX_P0: CC67.1 JMXM1.178
PEG_CTX_C_GRX_P1: CC68.1 JMXM1.172
PEG_CTX_C_GRX_P2: CC51.1 JMXM1.166
PEG_CTX_C_GRX_P3: CC52.1 JMXM1.158
PEG_CTX_C_GRX_P4: CC69.1 JMXM1.152
PEG_CTX_C_GRX_P5: CC54.1 JMXM1.146
PEG_CTX_C_GRX_P6: CC55.1 JMXM1.140
PEG_CTX_C_GRX_P7: CC70.1 JMXM1.134
PEG_CTX_C_GRX_P8: CC57.1 JMXM1.128
PEG_CTX_C_GRX_P9: CC58.1 JMXM1.122
PEG_CTX_C_GRX_P10: CC71.1 JMXM1.116
PEG_CTX_C_GRX_P11: CC60.1 JMXM1.110
PEG_CTX_C_GRX_P12: CC61.1 JMXM1.104
PEG_CTX_C_GRX_P13: CC72.1 JMXM1.98
PEG_CTX_C_GRX_P14: CC63.1 JMXM1.92
PEG_CTX_C_GRX_P15: CC64.1 JMXM1.86
PEG_CTX_GRX_N0: CC44.2 CPU1.B10
PEG_CTX_GRX_N1: CC45.2 CPU1.B11
PEG_CTX_GRX_N2: CC53.2 CPU1.B12
PEG_CTX_GRX_N3: CC73.2 CPU1.B13
PEG_CTX_GRX_N4: CC46.2 CPU1.B14
PEG_CTX_GRX_N5: CC74.2 CPU1.B15
PEG_CTX_GRX_N6: CC47.2 CPU1.B16
PEG_CTX_GRX_N7: CC56.2 CPU1.B17
PEG_CTX_GRX_N8: CC75.2 CPU1.C18
PEG_CTX_GRX_N9: CC48.2 CPU1.A19
PEG_CTX_GRX_N10: CC59.2 CPU1.C20
PEG_CTX_GRX_N11: CC76.2 CPU1.A21
PEG_CTX_GRX_N12: CC49.2 CPU1.C22
PEG_CTX_GRX_N13: CC62.2 CPU1.A23
PEG_CTX_GRX_N14: CC77.2 CPU1.C24
PEG_CTX_GRX_N15: CC50.2 CPU1.A25
PEG_CTX_GRX_P0: CC67.2 CPU1.C10
PEG_CTX_GRX_P1: CC68.2 CPU1.A11
PEG_CTX_GRX_P2: CC51.2 CPU1.C12
PEG_CTX_GRX_P3: CC52.2 CPU1.A13
PEG_CTX_GRX_P4: CC69.2 CPU1.C14
PEG_CTX_GRX_P5: CC54.2 CPU1.A15
PEG_CTX_GRX_P6: CC55.2 CPU1.C16
PEG_CTX_GRX_P7: CC70.2 CPU1.A17
PEG_CTX_GRX_P8: CC57.2 CPU1.B18
PEG_CTX_GRX_P9: CC58.2 CPU1.B19
PEG_CTX_GRX_P10: CC71.2 CPU1.B20
PEG_CTX_GRX_P11: CC60.2 CPU1.B21
PEG_CTX_GRX_P12: CC61.2 CPU1.B22
PEG_CTX_GRX_P13: CC72.2 CPU1.B23
PEG_CTX_GRX_P14: CC63.2 CPU1.B24
PEG_CTX_GRX_P15: CC64.2 CPU1.B25
PGOOD_3V_5V: PR107.1 PR108.2 PU101.7
PLTRST_CPU#: CPU1.BP35 UH1.AK2
PLTRST_GPU#: RH195.2 U16.2
PLTRST_HDD#: JSATA2.17 RH212.2
PLTRST_LAN#: RH194.2 U31.36
PLTRST_MMI#: JIO1.69 RH211.2
PLTRST_TBT#: JIO2.100 RH197.2
PLTRST_TPM#: RH187.2 RH346.2 U637.17
PLTRST_USH#: CZ57.1 JUSH1.6 RH210.2 RH359.2
PLTRST_USH#_EC: RH359.1 U46.A62
PM_LANPHY_ENABLE: R555.1 RH338.1 UH1.AR15
PM_RSMRST#_AND: RC154.1 UC4.4
PME#: T178.1(TP-1) UH1.BD17
POA_WAKE#: JUSH1.23 R880.2 U51.B68
POWER_SW#_MB: C759.1 C1354.1 JAPS1.11 JPB1.1 PWRSW1.1 R811.2 SW1.2 SW1.4
POWER_SW_IN#: C1352.1 R810.2 R811.1 U51.B67
PROCHOT_GATE: PU105.2 R415.2 R416.1 U46.A61
PS_ID: PT1.1(TP-1) PU1.4 U51.B24
PSID_DISABLE#: PR13.2 U46.A37
PWD_UN8: RN78.2 UN8.3
PWD_UN9: RN79.2 UN9.3
PWM1_1PH/ICCMAX1: PR1120.1 PU1100.44 PU1700.4
PWM1_3PH_A/ICCMAX3A: PR1155.1 PU1100.18 PU1200.4
PWM1_3PH_B/ICCMAX3B: PR1152.1 PU1100.23 PU1400.4
PWM2_3PH_A/ADDR: PR1156.1 PU1100.19 PU1201.4
PWM2_3PH_B/DOSC1: PR1159.1 PU1100.22 PU1401.4
PWM3_3PH_A/VBOOT: PR1157.1 PU1100.20 PU1202.4
PWM3_3PH_B/DOSC3: PR1158.1 PU1100.21 PU1402.4
PWR_SRC_ON: JIO2.66 U46.B13
RED_DOCK: JDOCK1.53 JMXM1.196
REM_DIODE1_N: C273.2 C339.1 C1343.1 Q16.3 Q26.1 Q26.2 U51.B13
REM_DIODE1_P: C273.1 C339.2 C1343.2 Q16.1 Q16.2 Q26.3 U51.A13
REM_DIODE2_N: C291.2 C340.2 C1350.1 Q17.1 Q17.2 Q27.3 U51.B14
REM_DIODE2_P: C291.1 C340.1 C1350.2 Q17.3 Q27.1 Q27.2 U51.A14
REM_DIODE3_N: C272.2 C1351.1 Q14.3 U51.A15
REM_DIODE3_P: C272.1 C1351.2 Q14.1 Q14.2 U51.B16
REM_DIODE4_N: C288.2 C1346.1 Q15.3 U51.A16
REM_DIODE4_P: C288.1 C1346.2 Q15.1 Q15.2 U51.B17
RES_BIAS: R562.1 U31.12
RESET_OUT#: R843.2 RC129.1 RH199.1 U51.B39 UH1.AY1
RF_+1VSP: PR806.1 PU800.5
RJ45_MDIN0: JLOM1.2 T156.23
RJ45_MDIN1: JLOM1.6 T156.19
RJ45_MDIN2: JLOM1.5 T156.17
RJ45_MDIN3: JLOM1.8 T156.13
RJ45_MDIP0: JLOM1.1 T156.24
RJ45_MDIP1: JLOM1.3 T156.20
RJ45_MDIP2: JLOM1.4 T156.18
RJ45_MDIP3: JLOM1.7 T156.14
RTD3_CIO_PWR_EN: JIO2.90 U46.A49 UH1.R39
RTD3_USB_PWR_EN: JIO2.92 U46.B11
RUN_ON: QE2.2 R881.1 R3730.2 U51.B9 UZ22.3 UZ23.3
RUN_ON#: QE2.5 QE2.6 RE68.2
RUN_ON_AND: PC312.1 PR303.1 PU300.1 U9.4
RUN_ON_R: R881.2 UZ20.3 UZ20.5
RUNPWROK: QE2.3 RE67.2 U46.A4 U51.B26
S3_1.2V: PR208.2 PU200.7
S5_1.2V: PC215.1 PR206.2 PU200.8
SATA_EXP_IFDET: RH321.2 U6.4 U639.6 UH1.AD35 UN8.20 UN9.20
SATA_LED#: D97.2 D98.2 D99.2 D100.2 Q74.4
SATA_PRX_C_DTX_N1: C698.2 JDOCK1.56
SATA_PRX_C_DTX_P1: C697.2 JDOCK1.54
SATA_PRX_DTX_N1: C698.1 UH1.D39
SATA_PRX_DTX_P1: C697.1 UH1.E37
SATA_PTX_C_DRX_N1: C700.1 JDOCK1.62
SATA_PTX_C_DRX_P1: C699.1 JDOCK1.60
SATA_PTX_DRX_N1: C700.2 UH1.B38
SATA_PTX_DRX_P1: C699.2 UH1.C38
SATA_SIDE_LED: JLED1.5 R943.2
SATAE_LED#: D100.1 R387.2 U639.1
SATAGP1: RH323.2 UH1.AG35
SATAGP5: RH325.2 UH1.AD38
SATAGP6: RH326.2 UH1.AC43
SATAGP7: RH322.2 UH1.AB44
SBIOS_TX: R863.2 RH71.2 UH1.AV44
SIM_DET: JNGFF2.58 RZ113.2
SIM_DET_R: JSIM1.1 RZ113.1
SIO_EXT_SCI#: RH339.2 U51.A33 UH1.AV29
SIO_EXT_SMI#: RH310.1 U51.A6 UH1.AF41
SIO_EXT_WAKE#: R797.1 RH309.2 UH1.AN44
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.2 U51.B58 UH1.AT13
SIO_RCIN#: RH213.1 U51.A27 UH1.AT17
SIO_SLP_A#: JAPS1.6 QH5.2 R877.1 U51.B28 UH1.BC15
SIO_SLP_LAN#: RH204.1 U51.B37 UH1.AV15 UZ25.5
SIO_SLP_S0#: JAPS1.15 RZ83.1 UC1.1 UH1.BC26
SIO_SLP_S3#: JAPS1.2 JIO2.96 Q370.2 RC329.1 RC330.1 U9.1 U51.A35 UC5.2 UH1.AW15
SIO_SLP_S3#_UZ30: RC330.2 UC7.4 UZ30.4
SIO_SLP_S4#: JAPS1.5 PR206.1 PR401.2 RC303.1 U51.B36 UC7.2 UH1.BD15
SIO_SLP_S5#: JAPS1.4 JIO2.62 U51.A18 UH1.BA13
SIO_SLP_SUS#: PR804.1 PR900.1 R374.2 U51.B52 UC7.1
SIO_SLP_SUS#_R: R374.1 R418.1 UH1.BB13
SIO_SLP_WLAN#: R820.1 U46.A14 UH1.AV13
SKL_CNL#: CPU1.BN1 RC171.2
SL_BAT_PRES#: PR1023.1 PU1001.21
SLICE_BAT_ON: PR1016.2 RP4.3 U46.A31
SLICE_BAT_PRES#: JDOCK1.141 JDOCK1.143 PD1100.1 PR33.1 PR1023.2 R2158.2 U46.B33
SLOT2_CONFIG_0: JNGFF2.13 RP9.8 U46.B12
SLOT2_CONFIG_1: JNGFF2.61 RP9.7 U46.A18 UZ29.9
SLOT2_CONFIG_2: JNGFF2.67 RP9.6 U46.A44
SLOT2_CONFIG_3: JNGFF2.1 RP9.5 U46.B34
SLOT2_SATA_LED#: D98.1 JNGFF2.10 R384.2
SLOT3_SATA_LED#: D99.1 JNGFF3.10 R385.2
SLOT3_SSD_PWR_EN: U46.B32 UZ21.3
SML0_SMBCLK: RH67.2 U31.28 UH1.AY44
SML0_SMBDATA: RH77.2 U31.31 UH1.BB39
SML1_SMBCLK: RH80.2 U51.B6 UH1.AW42
SML1_SMBDATA: RH81.2 U51.A5 UH1.AW45
SNB_0.95V: PC301.1 PR305.2
SNUB_1.35V: PC212.1 PR202.2
SNUB_3V: PC111.1 PR111.2
SNUB_5V: PC114.1 PR112.2
SNUB_CHG: PC717.1 PR724.2
SOFT_START_GC: PR20.2 PU1001.2
SPI_CLKTPM: RZ26.2 RZ35.2 U637.19
SPI_DINTPM: RZ30.2 U637.24
SPI_DOTPM: RZ29.2 U637.21
SPKR: JIO1.55 RH86.2 UH1.BD26
SRTCRST#: CH41.2 RH201.2 UH1.BB10
SS1_ON: JIO2.54 U46.B63
STSTART_DCBLOCK_GC: PQ1005.4 PR1002.1 PU1001.16
SUSACK#: R837.2 RH84.1 U51.B7 UH1.BB19
SUSCLK: JNGFF1.42 JNGFF2.60 R360.2 RH83.2 UH1.AN15
SUSCLK_R: JNGFF3.60 R360.1
SW1: PC110.2 PL102.1 PQ101.1 PQ101.2 PQ101.3 PQ103.5 PR112.1 PU101.18
SW1_3PH_A: PL1200.2 PR1143.1 PR1154.1
SW1_3PH_B: PL1400.2 PR1145.2 PR1160.2
SW1_EDP_AUXN: C373.1 R339.2 U630.31
SW1_EDP_AUXN_C: C373.2 JEDP1.29
SW1_EDP_AUXP: C371.1 R336.2 U630.32
SW1_EDP_AUXP_C: C371.2 JEDP1.28
SW1_EDP_HPD: JEDP1.25 R103.2 R222.2 U630.44
SW1_EDP_N0: C380.1 U630.45
SW1_EDP_N0_C: C380.2 JEDP1.38
SW1_EDP_N1: C378.1 U630.42
SW1_EDP_N1_C: C378.2 JEDP1.36
SW1_EDP_N2: C376.1 U630.39
SW1_EDP_N2_C: C376.2 JEDP1.34
SW1_EDP_N3: C374.1 U630.36
SW1_EDP_N3_C: C374.2 JEDP1.32
SW1_EDP_P0: C379.1 U630.46
SW1_EDP_P0_C: C379.2 JEDP1.39
SW1_EDP_P1: C377.1 U630.43
SW1_EDP_P1_C: C377.2 JEDP1.37
SW1_EDP_P2: C375.1 U630.40
SW1_EDP_P2_C: C375.2 JEDP1.35
SW1_EDP_P3: C372.1 U630.37
SW1_EDP_P3_C: C372.2 JEDP1.33
SW1_LAN0_MDIN0: T156.2 U32.25
SW1_LAN0_MDIN1: T156.6 U32.29
SW1_LAN0_MDIN2: T156.8 U32.34
SW1_LAN0_MDIN3: T156.12 U32.38
SW1_LAN0_MDIP0: T156.1 U32.24
SW1_LAN0_MDIP1: T156.5 U32.28
SW1_LAN0_MDIP2: T156.7 U32.33
SW1_LAN0_MDIP3: T156.11 U32.37
SW1_LAN1_MDIN0: JDOCK1.106 U32.23
SW1_LAN1_MDIN1: JDOCK1.112 U32.27
SW1_LAN1_MDIN2: JDOCK1.124 U32.32
SW1_LAN1_MDIN3: JDOCK1.130 U32.36
SW1_LAN1_MDIP0: JDOCK1.104 U32.22
SW1_LAN1_MDIP1: JDOCK1.110 U32.26
SW1_LAN1_MDIP2: JDOCK1.122 U32.31
SW1_LAN1_MDIP3: JDOCK1.128 U32.35
SW2: PC109.1 PL101.2 PQ100.1 PQ100.2 PQ100.3 PQ102.5 PR111.1 PU101.8
SW2_3PH_A: PL1201.2 PR1146.1 PR1161.1
SW2_3PH_B: PL1401.2 PR1147.2 PR1162.2
SW2_DP_AUXN: JDOCK1.35 Q365.4 U629.31
SW2_DP_AUXP: JDOCK1.33 Q365.1 U629.32
SW2_DP_HPD: C695.1 JDOCK1.39 R757.1 U629.44
SW2_DP_N0: C367.2 U629.45
SW2_DP_N0_C: C367.1 R2165.1
SW2_DP_N0_R: JDOCK1.11 R2165.2
SW2_DP_N1: C369.2 U629.42
SW2_DP_N1_C: C369.1 R2167.1
SW2_DP_N1_R: JDOCK1.17 R2167.2
SW2_DP_N2: C425.2 U629.39
SW2_DP_N2_C: C425.1 R2169.1
SW2_DP_N2_R: JDOCK1.23 R2169.2
SW2_DP_N3: C427.2 U629.36
SW2_DP_N3_C: C427.1 R2171.1
SW2_DP_N3_R: JDOCK1.29 R2171.2
SW2_DP_P0: C366.2 U629.46
SW2_DP_P0_C: C366.1 R2164.1
SW2_DP_P0_R: JDOCK1.9 R2164.2
SW2_DP_P1: C368.2 U629.43
SW2_DP_P1_C: C368.1 R2166.1
SW2_DP_P1_R: JDOCK1.15 R2166.2
SW2_DP_P2: C424.2 U629.40
SW2_DP_P2_C: C424.1 R2168.1
SW2_DP_P2_R: JDOCK1.21 R2168.2
SW2_DP_P3: C426.2 U629.37
SW2_DP_P3_C: C426.1 R2170.1
SW2_DP_P3_R: JDOCK1.27 R2170.2
SW3_3PH_A: PL1202.2 PR1148.1 PR1163.1
SW3_3PH_B: PL1402.2 PR1149.2 PR1164.2
SW3_DP1_AUXN: JDOCK1.36 Q364.4 UV2.27
SW3_DP1_AUXP: JDOCK1.34 Q364.1 UV2.26
SW3_DP1_HPD: C696.1 JDOCK1.40 R2160.1 UV2.48
SW3_DP1_N0: C438.2 UV2.49
SW3_DP1_N0_C: C438.1 R2173.2
SW3_DP1_N0_R: JDOCK1.12 R2173.1
SW3_DP1_N1: C440.2 UV2.46
SW3_DP1_N1_C: C440.1 R2175.2
SW3_DP1_N1_R: JDOCK1.18 R2175.1
SW3_DP1_N2: C442.2 UV2.44
SW3_DP1_N2_C: C442.1 R2177.2
SW3_DP1_N2_R: JDOCK1.24 R2177.1
SW3_DP1_N3: C444.2 UV2.41
SW3_DP1_N3_C: C444.1 R2179.2
SW3_DP1_N3_R: JDOCK1.30 R2179.1
SW3_DP1_P0: C431.2 UV2.50
SW3_DP1_P0_C: C431.1 R2172.2
SW3_DP1_P0_R: JDOCK1.10 R2172.1
SW3_DP1_P1: C439.2 UV2.47
SW3_DP1_P1_C: C439.1 R2174.2
SW3_DP1_P1_R: JDOCK1.16 R2174.1
SW3_DP1_P2: C441.2 UV2.45
SW3_DP1_P2_C: C441.1 R2176.2
SW3_DP1_P2_R: JDOCK1.22 R2176.1
SW3_DP1_P3: C443.2 UV2.42
SW3_DP1_P3_C: C443.1 R2178.2
SW3_DP1_P3_R: JDOCK1.28 R2178.1
SW3_DP2_AUXN: U631.22 U631.27 UV2.29
SW3_DP2_AUXP: U631.23 U631.28 UV2.28
SW3_DP2_HPD: U631.3 UV2.38
SW3_DP2_N0: C1463.1 UV2.39
SW3_DP2_N0_C: C1463.2 U631.2
SW3_DP2_N1: C1458.1 UV2.36
SW3_DP2_N1_C: C1458.2 U631.5
SW3_DP2_N2: C1464.1 UV2.34
SW3_DP2_N2_C: C1464.2 U631.7
SW3_DP2_N3: C1459.1 UV2.31
SW3_DP2_N3_C: C1459.2 U631.10
SW3_DP2_P0: C1460.1 UV2.40
SW3_DP2_P0_C: C1460.2 U631.1
SW3_DP2_P1: C1457.1 UV2.37
SW3_DP2_P1_C: C1457.2 U631.4
SW3_DP2_P2: C1461.1 UV2.35
SW3_DP2_P2_C: C1461.2 U631.6
SW3_DP2_P3: C1462.1 UV2.32
SW3_DP2_P3_C: C1462.2 U631.9
SW4_DP_AUXN: JIO2.131 R381.1 U631.31
SW4_DP_AUXP: JIO2.133 U631.32
SW4_DP_HPD: JIO2.88 U631.44
SW4_DP_N0: JIO2.155 U631.45
SW4_DP_N1: JIO2.149 U631.42
SW4_DP_N2: JIO2.143 U631.39
SW4_DP_N3: JIO2.137 U631.36
SW4_DP_P0: JIO2.157 U631.46
SW4_DP_P1: JIO2.151 U631.43
SW4_DP_P2: JIO2.145 U631.40
SW4_DP_P3: JIO2.139 U631.37
SW5_DP_AUXN: JIO2.101 U636.31
SW5_DP_AUXP: JIO2.103 U636.32
SW5_DP_HPD: JIO2.86 U636.44
SW5_DP_N0: JIO2.125 U636.45
SW5_DP_N1: JIO2.119 U636.42
SW5_DP_N2: JIO2.113 U636.39
SW5_DP_N3: JIO2.107 U636.36
SW5_DP_P0: JIO2.127 U636.46
SW5_DP_P1: JIO2.121 U636.43
SW5_DP_P2: JIO2.115 U636.40
SW5_DP_P3: JIO2.109 U636.37
SW_1.2V: PC206.1 PL201.2 PQ201.1 PQ201.2 PQ201.3 PQ202.5 PR202.1 PU200.16
SW_1PH: PL1700.2 PR1102.2
SW_+1VSP: PC804.1 PL800.1 PQ800.1 PQ800.2 PQ800.3 PQ801.5 PR805.1 PU800.8
SW_+V0.95SP: PL301.1 PR305.1 PR312.2 PU300.10
SW_EDRAMP: PC500.2 PL501.1 PR504.1 PU500.8
SW_EOPIOP: PC1800.2 PL1801.1 PR1804.1 PU1800.8
SWV_CLK: JDEG3.4 U8.14
SWV_IO: JDEG3.5 U8.13
SYS_LED_MASK#: Q74.2 Q325.2 Q325.5 Q327.2 R775.2 U46.B48 U58.1
SYS_PWROK_R: CC36.1 JXDP1.47 RC5.2 RC128.2 RC129.2
SYS_RESET#: JAPS1.13 RH66.2 UC3.4 UH1.AW1
SYSPWR_PRES: R874.1 R876.1 U51.A59
TB_STAT#: PQ707.2 PR757.1 PU700.16 U46.B15
TBT_CIO_PLUG_EVENT#: JIO2.94 RH341.2 UH1.U41
TBT_FORCE_PWR: JIO2.98 UH1.P43
TBT_PWR_EN: JIO2.82 U46.A23
TCABLE_ID: JIO2.77 U51.B8
TDOCK_BATLOW#: JIO2.69 U46.B58
TDOCK_PWR_BTN#: JIO2.60 R870.2 U51.B63
THERMATRIP2#: C327.1 Q28.1 R396.2 U51.B34
THERMATRIP3#: Q4.1 R11.2 U51.A2
THSEL_STRAP: R1069.1 U51.B29
TOUCH_SCREEN_DET#: JTS1.5 R382.2 UH1.BD24
TOUCH_SCREEN_PD#: JTS1.4 R426.2 UH1.AE44
TOUCHPAD_INTR#: JKBTP1.5 UH1.BC23
TP_LAN_JTAG_TCK: R546.2 U31.35
TP_LAN_JTAG_TDI: T142.1(TP-1) U31.32
TP_LAN_JTAG_TDO: T143.1(TP-1) U31.34
TP_LAN_JTAG_TMS: R545.2 U31.33
TP_SKL_E30: CPU1.E30 RC179.1 T17.1(TP-1)
TP_SKL_F30: CPU1.F30 RC178.1 T16.1(TP-1)
TPM_GPIO4: RZ80.2 U637.13
TPM_LPM#: QZ2.1 RZ82.1 U637.3
TPM_PIRQ#: RZ69.2 U637.18 UH1.AN38
TRIN_DOCK_DET: JIO2.79 U46.A59
TRIP_+1VSP: PR802.2 PU800.2
TSENSE_3PH_A: PC1127.1 PR1165.1 PU1100.14
TSENSE_3PH_B: PC1129.1 PR1166.1 PU1100.25
TSENSE_PSYS: PR730.1 PR744.1 PR1153.1 PU1100.24
UG_3V: PQ100.4 PU101.10
UG_5V: PQ101.4 PU101.16
UG_+1VSP: PQ800.4 PU800.9
UGATE_CHG: PQ704.4 PU700.26
UIM_CLK: CZ66.1 JNGFF2.24 JSIM1.5
UIM_DATA: CZ65.1 JNGFF2.26 JSIM1.4
UIM_RESET: CZ67.1 JNGFF2.22 JSIM1.7
UPD_EN1_4#: JIO2.63 U46.A2
UPD_GPU_SMBCLK: JIO2.72 Q295.3 R822.2 U51.B49
UPD_GPU_SMBDAT: JIO2.74 Q295.6 R829.2 U51.B48
UPD_SMBUS_ALERT#: JIO2.70 R3740.1 U46.A58
USB2_COMP: RH193.1 UH1.AG3
USB2_ID: RH357.1 UH1.AG2
USB2_VBUSSENSE: RH356.1 UH1.AD10
USB3_PRX_DTX_N1: JIO2.91 UH1.B7
USB3_PRX_DTX_N2: UH1.C8 UZ29.18
USB3_PRX_DTX_N3: JIO1.10 UH1.B10
USB3_PRX_DTX_N4: JIO1.3 UH1.E11
USB3_PRX_DTX_N5: JIO1.25 UH1.G13
USB3_PRX_DTX_N6: JDOCK1.84 UH1.K15
USB3_PRX_DTX_P1: JIO2.89 UH1.A7
USB3_PRX_DTX_P2: UH1.B8 UZ29.19
USB3_PRX_DTX_P3: JIO1.12 UH1.A9
USB3_PRX_DTX_P4: JIO1.5 UH1.G11
USB3_PRX_DTX_P5: JIO1.27 UH1.H13
USB3_PRX_DTX_P6: JDOCK1.86 UH1.K13
USB3_PTX_C_DRX_N2: CZ25.2 UZ29.16
USB3_PTX_C_DRX_P2: CZ26.2 UZ29.17
USB3_PTX_DRX_N1: JIO2.97 UH1.C11
USB3_PTX_DRX_N2: CZ25.1 UH1.B12
USB3_PTX_DRX_N3: JIO1.4 UH1.C13
USB3_PTX_DRX_N4: JIO1.9 UH1.A14
USB3_PTX_DRX_N5: JIO1.31 UH1.B14
USB3_PTX_DRX_N6: JDOCK1.90 UH1.B15
USB3_PTX_DRX_P1: JIO2.95 UH1.B11
USB3_PTX_DRX_P2: CZ26.1 UH1.A12
USB3_PTX_DRX_P3: JIO1.6 UH1.D13
USB3_PTX_DRX_P4: JIO1.11 UH1.B13
USB3_PTX_DRX_P5: JIO1.33 UH1.C14
USB3_PTX_DRX_P6: JDOCK1.92 UH1.C15
USB20_N1: JIO2.85 UH1.AF5
USB20_N2: JIO1.16 UH1.AD5
USB20_N3: JIO1.15 UH1.AG8
USB20_N4: JIO1.28 UH1.AE1
USB20_N5: JDOCK1.68 UH1.AC2
USB20_N6: JNGFF1.5 UH1.AF2
USB20_N7: JDOCK1.74 UH1.AB3
USB20_N8: JNGFF2.9 UH1.AL8
USB20_N9: L11.4 R429.1 UH1.AA1
USB20_N9_R: D20.2 JTS1.2 L11.3 R429.2
USB20_N10: JUSH1.19 UH1.AJ8
USB20_N11: L10.1 R427.1 UH1.W2
USB20_N11_R: D21.2 JEDP1.15 L10.2 R427.2
USB20_P1: JIO2.83 UH1.AG7
USB20_P2: JIO1.18 UH1.AD7
USB20_P3: JIO1.17 UH1.AG10
USB20_P4: JIO1.30 UH1.AE2
USB20_P5: JDOCK1.66 UH1.AC3
USB20_P6: JNGFF1.3 UH1.AF3
USB20_P7: JDOCK1.72 UH1.AB2
USB20_P8: JNGFF2.7 UH1.AL7
USB20_P9: L11.1 R430.1 UH1.AA2
USB20_P9_R: D20.3 JTS1.3 L11.2 R430.2
USB20_P10: JUSH1.18 UH1.AJ7
USB20_P11: L10.4 R428.1 UH1.W3
USB20_P11_R: D21.3 JEDP1.16 L10.3 R428.2
USB_OC0#: JIO2.80 RPH6.4 UH1.AD43
USB_OC1#: JIO1.22 RPH6.1 UH1.AD42
USB_OC2#: JIO1.19 RPH6.2 UH1.AD39
USB_OC3#: JIO1.24 RPH6.3 UH1.AC44
USB_PWR_SHR_LFT_EN#: JIO2.78 RE72.2 U46.A8
USB_PWR_SHR_RHT_EN1#: JIO1.48 RE69.2 U46.B44
USB_PWR_SHR_RHT_EN2#: JIO1.52 RE70.2 U46.A33
USB_PWR_SHR_RHT_EN3#: JIO1.56 RE71.2 U46.B17
USB_PWR_SHR_VBUS_LFT_EN: JIO2.76 RE73.2 U46.B50
USB_PWR_SHR_VBUS_RHT_EN1: JIO1.46 RE74.2 U46.B18
USB_PWR_SHR_VBUS_RHT_EN2: JIO1.50 RE75.2 U46.A11
USB_PWR_SHR_VBUS_RHT_EN3: JIO1.54 RE76.2 U46.A12
USH_DET#: DZ3.2 R379.2 RZ76.1 U46.A16
USH_DET#_R: DZ3.1 JUSH1.1 RZ76.2
USH_PWR_STATE#: JUSH1.5 RZ10.2 U46.A34
USH_SMBCLK: JUSH1.16 Q366.3 U51.A50
USH_SMBDAT: JUSH1.15 Q366.6 U51.B53
VCT_LAN_R1: R553.2 R558.1 U31.6
VGA_ID: R800.2 R803.1 U46.B59
VID0_EDRAM_VR: PR512.2 PR514.1 PU500.4
VID0_EOPIO_VR: PR1812.2 PR1814.1 PU1800.4
VID1_EDRAM_VR: PR511.1 PR513.2 PU500.3
VID1_EOPIO_VR: PR1811.1 PR1813.2 PR1815.1 PU1800.3
VLDOIN_1.2V: PJP201.2 PU200.19
VR_SVID_ALERT#: PR1115.1 PR1199.2 PR1609.1 RC155.2 RC156.1
VR_SVID_CLK: CPU1.BH32 PR1104.2 PR1117.2 PR1611.1
VR_SVID_DATA: CPU1.BH29 PR1105.1 PR1113.2 PR1608.1 RC157.2
VRALERT#: RH203.1 UH1.BD23
VSET_5085: C320.1 R425.1 U51.A17
VSN_1PH: PC1140.2 PR1107.2 PU1100.51
VSN_3PH_A: PC1110.2 PR1123.2 PU1100.2
VSP_1PH: PC1105.2 PR1109.2 PU1100.52
VSP_3PH_A: PC1109.2 PR1121.2 PU1100.1
VSYNC_DOCK: JDOCK1.67 JMXM1.190
WLAN_DISBL#: U15.4 U46.B68
WLAN_WIGIG60GHZ_DIS#: D31.1 U46.A1
WLAN_WIGIG60GHZ_DIS#_R: D31.2 JNGFF1.48
WWAN_PWR_EN: JNGFF2.6 RZ3.2
WWAN_RADIO_DIS#: DZ1.1 RE14.2 U46.A53
WWAN_RADIO_DIS#_R: DZ1.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.15 R773.2 U46.B43
XCLK_RBIAS: RH171.2 UH1.E1
XDP_DBRESET#: CC35.1 JXDP1.48 RC316.1 RH66.1 UC3.1
XDP_OBS0: CPU1.BR27 RC312.1
XDP_OBS0_R: JXDP1.21 RC312.2
XDP_OBS1: CPU1.BT27 RC313.1
XDP_OBS1_R: JXDP1.23 RC313.2
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XTAL24_IN_R: CH13.1 RH153.2 UH1.A6 YH2.3
XTAL24_OUT_R: CH14.1 RH152.2 YH2.1
XTAL24_OUT_R1: RH152.1 RH153.1 UH1.A5
XTALI: C471.1 U31.10 Y3.1
XTALO: R1144.2 U31.9
XTALO_R: C470.1 R1144.1 Y3.3
Z2805: R574.1 T156.22
Z2806: R573.1 T156.16
Z2807: R572.1 T156.21
Z2808: R571.1 T156.15
Z4012: PD1.2 PR1.2
Z4304: PBATT1.7 PR3.4
Z4305: PBATT1.6 PR3.3
Z4306: PBATT1.5 PR3.2
N265433: PQ8.1 PQ8.2
N16717680: PC9.1 PQ5.4 PQ8.4 PR16.2 PR20.1 PR22.1
N16751240: PQ701.4 PR700.2 PR766.2
N16759370: PQ703.2 PQ706.2 PR709.2 PR712.2 PR714.2
N16952683: Q370.3 R399.1 R435.2
N16952696: Q28.2 R399.2
N17075286: Q343.1 R129.1
N17075290: Q343.4 R132.1
N17075402: PQ2.3 PR7.2 PR9.1
N17205976: JDEG2.1 R864.2
N17319754: PC1004.1 PQ1003.4 PR1004.1
N17649391: PBATT1.3 PD3.3
N17684555: PC1005.1 PR1005.2
N17708032: PC5.1 PQ1.2 PR33.2
N17708061: PD5.2 PQ1.1
N17794318: PC1001.2 PQ1001.4 PR1002.2 PR1033.2
N18381813: Q347.5 Q347.6 R722.2
N19516037: CZ9.1 RZ35.1
N19876513: PQ706.1 PR713.1 PR715.2
N19877490: PQ702.1 PR701.3
N19877495: PQ700.1 PR701.2
N20195902: PD1010.2 PR1014.2
N20196027: PD1100.2 PQ1011.2 PR1030.1 PR1032.1
N20202315: PQ1011.1 PQ1072.2 PR1099.2
N20202318: PD1010.3 PQ1072.1 PR1032.2
N20354491: PR400.2 PU400.2
N20966390: PL3.1 PQ2.1 PR7.1 PR10.2
N20966408: PQ3.2 PR10.1 PR12.2
N20966410: PQ2.2 PQ3.1 PR11.2 PR13.1
N21631508: PQ1004.4 PR1009.1
N22506578: PR1008.2 PU1001.28
N22982928: Q87.1 R944.2
N23873950: JMXM1.55 R1970.2
N26820574: PD701.1 PD702.1 PR717.1
N26820768: PC711.1 PR718.1 PR719.1 PU700.6
N26821061: PR706.2 PU700.3
N26821286: PR721.2 PU700.5
N26821586: PC721.2 PR716.2 PU700.7
N26821595: PC720.2 PR726.2 PU700.8
N26821696: PR725.2 PU700.10
N26821932: PR728.2 PU700.15
N26822164: PR761.2 PU700.20
N26822183: PR762.2 PU700.19
