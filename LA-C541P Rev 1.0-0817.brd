# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDIN0: length 16
  TOP w0.089: R69.1 236.31,111.63 237.33,110.61 239.45,110.61 240.42,111.57 240.42,112.78 241.48,113.85 v4(244.39,113.85) 244.76,113.85 246.83,111.77 247.4,111.77 247.43,111.74 U31.14
LAN_MDIN0_L: length 5.1
  TOP w0.089: U32.11 234.83,116.73 234.97,116.59 v4(234.97,115.91) 234.97,115.51 235.71,114.77 236.72,114.77 236.81,114.69 236.81,114.27 236.43,113.89 R69.2
LAN_MDIN1: length 15.3
  TOP w0.089: R67.1 234.4,109.77 234.4,109.51 234.93,108.99 237.21,108.99 237.85,109.62 240.83,109.62 241.07,109.39 v4(244.06,109.39) 246.44,109.39 247.2,110.14 U31.18
LAN_MDIN1_L: length 6.4
  TOP w0.089: U32.9 233.83,116.64 233.9,116.56 233.9,115.18 234.59,114.5 v4(234.59,114.13) 234.59,111.92 234.17,111.5 R67.2
LAN_MDIN2: length 20
  TOP w0.089: R65.1 232.4,112.18 232.4,109.42 234,107.82 237.61,107.82 238.21,108.41 v4(241.37,108.41) 246.84,108.41 247.37,108.94 U31.21
LAN_MDIN2_L: length 3.8
  TOP w0.089: U32.6 232.33,116.8 232.39,116.73 232.39,115.59 232.58,115.4 v4(232.58,115.04) 232.58,114.36 232.13,113.91 R65.2
LAN_MDIN3: length 20
  TOP w0.089: R63.1 230.17,109.87 230.17,109.77 232.44,107.5 232.99,107.5 233.06,107.43 233.61,106.88 238,106.88 238.56,107.44 v4(245.59,107.44) 247.22,107.44 247.53,107.74 U31.24
LAN_MDIN3_L: length 6.5
  TOP w0.089: U32.2 230.33,116.83 230.4,116.75 230.4,116.5 230.89,116.01 230.89,113.54 230.55,113.21 ; 230.55,113.21 230.38,113.04 230.38,111.93 230,111.55 R63.2 ; 230.55,113.21 v4(230.55,113.27)
LAN_MDIP0: length 16.1
  TOP w0.089: U31.13 247.43,112.14 247.4,112.11 246.98,112.11 v4(245.99,113.1) 244.9,114.19 241.34,114.19 240.07,112.92 240.07,111.72 239.31,110.95 237.47,110.95 236.66,111.77 236.66,111.87 236.78,112 237.21,112 R70.1
LAN_MDIP0_L: length 5.1
  TOP w0.089: R70.2 237.59,113.89 237.15,114.33 237.15,114.83 236.87,115.11 v4(236.57,115.11) 235.85,115.11 235.31,115.65 235.31,116.8 235.33,116.81 U32.12
LAN_MDIP1: length 15.2
  TOP w0.089: R68.1 234.93,110.11 234.75,109.92 234.75,109.65 235.07,109.33 237.07,109.33 237.71,109.96 v4(239.94,109.96) 240.98,109.96 241.21,109.73 246.3,109.73 247.06,110.49 247.47,110.49 247.53,110.54 U31.17
LAN_MDIP1_L: length 6.4
  TOP w0.089: R68.2 235.38,111.5 234.93,111.96 v4(234.93,112.78) 234.93,114.64 234.25,115.32 234.25,116.56 234.33,116.64 U32.10
LAN_MDIP2: length 20
  TOP w0.089: R66.1 232.86,112.52 232.74,112.4 232.74,109.56 234.14,108.16 237.47,108.16 238.07,108.76 v4(242.76,108.76) 246.7,108.76 247.23,109.29 247.4,109.29 247.45,109.34 U31.20
LAN_MDIP2_L: length 3.8
  TOP w0.089: R66.2 233.38,113.92 232.92,114.37 232.92,115.54 232.73,115.73 232.73,116.64 232.83,116.73 U32.7
LAN_MDIP3: length 20
  TOP w0.089: R64.1 230.66,110.16 230.52,110.01 230.52,109.91 232.58,107.84 233.13,107.84 233.4,107.57 233.75,107.22 237.86,107.22 238.42,107.78 v4(244.07,107.78) 247.08,107.78 247.39,108.09 247.57,108.09 247.63,108.14 U31.23
LAN_MDIP3_L: length 6.5
  TOP w0.089: U32.3 230.83,116.83 230.75,116.75 230.75,116.64 231.23,116.15 v4(231.23,115.91) 231.23,113.4 230.73,112.9 230.73,111.97 231.14,111.55 R64.2
LAN_TEST_EN: length 2.1
  TOP w0.102: U31.30 v1(250.93,105.81) 250.93,104.95 R561.1
LAN_WAKE#: length 187.5
  TOP w0.102: v2(198.73,131.84) 199.68,130.89 199.68,129.39 199.66,129.37 199.66,122.69 199.38,122.41 199.38,121.43 199.49,121.33 199.49,119.94 198.42,118.87 198.42,116.84 199.74,115.52 199.74,114.35 199.88,114.21 199.88,113.46 199.51,113.09 199.51,110.92 199.31,110.71 199.31,109.07 200.56,107.82 200.56,107.78 v2(200.55,107.78) ; v2(129.39,126.87) 129.39,126.07 129.8,125.66 129.88,125.66 129.96,125.58 130.08,125.58 130.15,125.51 130.15,125.19 129.6,124.63 129.6,124.24 129.52,124.16 129.52,123.79 129.77,123.54 UH1.BD11 ; v2(257.53,114.36) 257.53,114.38 R556.1 ; v2(236.77,105.46) 236.36,105.05 234.04,105.05 229.94,109.15 229.05,109.15 228.8,109.4 228.71,109.4 228.3,109.81 226.61,109.81 225.98,109.18 v2(225.98,108.96)
  IN1 w0.109: v2(257.53,114.36) 257.52,114.35 256.56,114.35 255.29,113.08 248.84,113.08 247.99,113.92 239.33,113.92 v2(238.92,113.51)
  IN2 w0.127: v2(200.55,107.78) 200.95,107.39 200.95,106.22 202.94,104.22 203.41,104.22 203.72,103.91 205.83,103.91 206.16,104.24 212.18,104.24 212.52,103.9 215.96,103.9 216.66,104.6 218.54,104.6 219.23,105.3 220.16,105.3 221.64,106.78 221.64,107.08 222.1,107.54 222.7,107.54 223.07,107.91 223.74,107.91 224.56,107.08 225.01,107.08 225.47,107.54 225.47,108.45 v2(225.98,108.96) ; v2(198.73,131.84) 196.31,131.84 195.55,131.08 190.06,131.08 189.04,130.07 187.27,130.07 186.22,131.12 184.48,131.12 184.06,130.7 179.32,130.7 178.94,131.09 167.79,131.09 166.17,132.7 165.05,132.7 164.09,133.66 160.03,133.66 159.58,134.11 156.51,134.11 156.16,134.46 154.33,134.46 153.37,135.43 150.47,135.43 149.81,134.77 146.55,134.77 145.28,133.5 145.01,133.5 143.59,132.07 142.41,132.07 140.72,130.39 139.95,130.39 138.82,131.52 136.25,131.52 134.92,130.19 134.56,129.83 134.56,129.2 132.77,127.42 131.7,127.42 130.89,128.22 130.55,128.22 129.39,127.06 v2(129.39,126.87)
  IN3 w0.127: v2(238.92,113.51) 238.75,113.34 238.75,111.07 237.82,110.14 237.82,107.41 236.77,106.36 v2(236.77,105.46)
  BOTTOM w0.102: v2(200.55,107.78) 200.43,107.78 200.12,107.48 200.12,107.34 200.12,107.34 200.12,106.98 200,106.86 U51.B27 ; v2(129.39,126.87) 129.07,127.18 v1(129.07,128.29) 129.07,129.41 RH93.1
LAN_WAKE#_R: length 5.6
  TOP w0.102: R556.2 R559.1 255.67,115.4 v1(255.07,114.8) 255.07,114.18 254.7,113.81 253.34,113.81 252.93,113.4 U31.2
LCD_CBL_DET#: length 35.1
  TOP w0.089: 112.37,119.83 112.55,119.66 113.45,119.66 UH1.AT44
  TOP w0.102: JEDP1.20 117.9,142.58 117.77,142.51 114.34,142.51 111.74,139.91 v2(111.74,138.78) ; 112.37,119.83 v2(112.07,120.14)
  IN4 w0.109: v2(111.74,138.78) 111.74,138.3 107,133.56 107,126.97 112.07,121.9 112.07,121.2 112.27,121 112.27,120.34 v2(112.07,120.14)
  BOTTOM w0.089: RC79.1 112.37,120.67
  BOTTOM w0.102: v2(111.74,138.78) 111.74,138.48 v1(111.94,138.27) ; 112.37,120.67 112.07,120.37 v2(112.07,120.14)
LCD_TST: length 122.7
  TOP w0.102: v2(181.11,104.58) 181.11,104.62 179.51,106.22 179.51,107.65 180.13,108.27 180.13,109.36 178.67,110.82 178.67,110.84 177.7,111.81 177.69,111.81 176.54,112.95 176.54,114.26 176.59,114.31 176.59,116.49 174.88,118.2 174.88,118.43 174.04,119.27 171.83,119.27 v2(171.6,119.04) ; JEDP1.24 116.12,143.94 116.12,145.32 117.28,146.48 120.21,146.48 v2(121.07,147.34)
  IN1 w0.109: v2(121.07,147.34) 121.61,147.87 123,147.87 125.61,145.26 125.61,144.18 127.76,142.03 134.96,142.03 136.16,143.23 137.05,143.23 137.77,143.95 150.8,143.95 152.06,145.21 v2(152.06,145.75)
  IN2 w0.127: v2(172.13,143.52) 172.13,143.75 171.9,143.97 169.4,143.97 168.32,145.05 166.12,145.05 165.15,146.02 159.93,146.02 159.52,145.61 158.32,145.61 157.61,146.32 152.63,146.32 v2(152.06,145.75)
  IN3 w0.127: v2(171.6,119.04) 171.36,119.28 171.36,125.96 168.39,128.92 168.39,132.49 170.96,135.06 170.96,141.98 172.13,143.15 v2(172.13,143.52)
  BOTTOM w0.102: v2(181.11,104.58) 181.55,105.03 U46.A36 ; v2(171.6,119.04) 171.58,119.05 169.43,119.05 v1(169.27,118.89) 169.27,116.03 170.1,115.21 170.41,115.21 170.6,115.02 170.6,114.52 170.75,114.38 RP4.2
LCD_VCC_TEST_EN: length 116.4
  IN1 w0.109: v2(152,146.71) 151.61,146.32 151.61,145.09 150.7,144.18 137.67,144.18 136.95,143.47 136.07,143.47 134.86,142.27 127.86,142.27 125.85,144.28 125.85,145.36 122.64,148.57 v2(119.6,148.57)
  IN2 w0.127: v2(169.37,106.16) 169.75,106.16 170.79,107.21 172.44,107.21 172.86,107.63 173.36,107.63 173.59,107.4 173.59,107.08 172.93,106.42 172.93,105.95 173.43,105.45 177.78,105.45 178.47,104.76 178.47,104.42 v2(178.9,103.99) ; v2(167.3,146.13) 167.3,146.86 166.74,147.42 158.78,147.42 158.2,146.83 152.12,146.83 v2(152,146.71)
  IN3 w0.127: v2(167.3,146.13) 166.98,145.81 166.98,139.15 164.55,136.71 164.55,127.14 167.19,124.5 167.19,123.16 167.36,123 167.36,118.91 167.14,118.68 167.14,118.34 167.36,118.12 167.36,110.2 168.34,109.21 168.34,108.8 169.57,107.56 169.57,106.37 v2(169.37,106.16)
  BOTTOM w0.102: U46.A40 179.55,104.95 179.36,104.76 179.37,104.75 179.37,104.42 179.36,104.41 179.36,104.3 179.05,103.99 v2(178.9,103.99) ; D93.2 122.3,148.57 v2(119.6,148.57)
LED_10_GRN#: length 11.9
  TOP w0.102: U32.41 228.51,118.79 v2(228.39,118.92) ; v2(228.58,124.16) 228.32,124.16 228.01,123.85 Q327.3 227.57,123.58 227.38,123.77 227.38,124.55 226.98,124.96 v1(226.7,124.96) 226.67,124.93 226.67,123.99 226.8,123.85 R378.2
  IN1 w0.109: v2(228.39,118.92) 228.37,118.92 227.85,119.44 227.85,123.69 228.32,124.16 v2(228.58,124.16)
LED_10_GRN#_Q: length 37.9
  TOP w0.102: Q327.1 229.91,128.86 229.72,129.06 229.72,130.51 230.86,131.66 230.86,132.54 v1(232.59,134.27) 234.23,135.91 234.23,135.97 v2(234.29,135.97) ; R1170.1 251.69,145.37 v2(251.76,145.44)
  IN2 w0.109: v2(251.76,145.44) 248.84,142.51 237.72,142.51 237.09,141.88 237.09,139.97 234.29,137.18 v2(234.29,135.97)
LED_100_ORG#: length 7.6
  TOP w0.102: U32.18 240.01,118.29 240.17,118.45 240.17,118.92 239.95,119.15 239.95,119.66 240.28,119.99 241.08,119.99 Q325.4 241.65,120.37 R377.2 241.78,121.47 v1(241.91,121.61)
LED_100_ORG#_Q: length 47.1
  TOP w0.102: v2(250.8,143.6) R1167.1 ; Q325.3 241.65,117.16 241.79,117.03 242.51,117.03 242.74,117.25 v1(242.74,117.5) 242.74,117.79 242.37,118.16 242.37,122.05 242.29,122.13 240.28,122.13 239.64,122.77 239.06,122.77 238.17,123.65 238.17,124.29 v2(238.1,124.35)
  IN1 w0.109: v2(234.8,135.4) 234.8,129.24 238.1,125.94 v2(238.1,124.35)
  IN2 w0.109: v2(234.8,135.4) 234.8,137.35 237.34,139.89 237.34,141.75 237.87,142.28 249.48,142.28 v2(250.8,143.6)
LED_SATA_DIAG_OUT#: length 225.2
  TOP w0.102: v2(302.02,7.77) 301.4,7.14 D62.1
  IN2 w0.127: v2(179.56,117.52) 179.61,117.52 180.37,118.29 181.06,118.29 181.59,118.82 181.59,119.26 182.23,119.9 188.61,119.9 189.08,120.37 191.37,120.37 193.1,122.1 193.87,122.1 194.32,122.56 196.59,122.56 196.98,122.95 199.81,122.95 199.82,122.93 201.2,122.93 202.31,124.04 204.89,124.04 205.49,123.45 216.88,123.45 218.01,124.58 219.19,124.58 220.2,123.57 221.73,123.57 222.84,122.46 222.84,120.76 224.19,119.41 224.19,117.4 226.27,115.32 226.27,113.48 226.46,113.28 226.68,113.28 227.89,112.07 v2(228.91,112.07)
  IN4 w0.109: v2(296.08,22.56) 296.17,22.47 296.17,21.2 300.02,17.35 301.2,16.16 301.2,8.59 v2(302.02,7.77)
  BOTTOM w0.102: U46.A10 179.97,116.3 179.97,117.12 v2(179.56,117.52) ; v2(228.91,112.07) 239.06,112.07 246.68,104.45 246.68,103.63 247.05,103.26 247.57,103.26 247.92,102.91 247.92,102.22 249.39,100.74 249.39,95.2 247.07,92.87 247.07,92.49 247.04,92.47 244.72,90.15 244.72,88.03 245.14,87.61 245.14,82.55 245.14,81.79 248.64,78.29 248.64,68.16 247.25,66.76 247.25,61.07 250.93,57.38 256.64,57.38 257.06,57.81 259.93,57.81 263.79,53.94 263.79,52.03 v1(267.81,48.02) 273.99,41.83 280.62,41.83 282.25,40.21 290.28,40.21 291.63,38.85 291.63,25.67 294.42,22.88 295.76,22.88 v2(296.08,22.56)
LG_3V:
  vias: v2(341.72,26.07) v2(342.3,26.12) v2(352.51,29.87) v2(353.32,29.89)
LG_5V:
  vias: v1(351.9,36.67) v2(352.32,37.61) v2(352.32,36.98) v2(353.15,33.04) v2(353.15,32.41)
LG_+1VSP: length 6
  IN4 w1.016: 98.16,119.21 98.99,120.04 98.99,123.11 99.55,123.67 99.55,124.63
  vias: v1(98.1,125.24) v2(98.63,125.19) v2(98.68,118.74) v2(98.68,118.03) v2(99.22,125.22)
LGATE_CHG: length 14.6
  IN4 w1.016: 275.82,29.04 275.33,28.54 275.33,24.97 278.76,21.55 283.06,21.55 283.89,22.37
  vias: v1(287.53,22.75) v2(276.2,30.18) v2(276.33,30.75) v2(285.02,23.15) v2(285.62,23.15)
LID_CL#: length 251.7
  TOP w0.102: v2(297.41,22.05) 299.42,20.05 299.42,18.11 299.73,17.8 299.73,17.14 303.52,13.35 305.49,13.35 306.16,12.68 U58.2 ; 286.94,41.12 287.85,41.12 289.38,39.59 289.38,38.51 289.18,38.31 v2(289.18,37.8) ; R807.1 173.91,107.4 173.35,106.84 v2(173.35,106.13)
  TOP w0.508: 286.94,41.12 286,42.06 JPB1.5
  IN2 w0.127: v2(221.66,80.98) 221.66,80.98 218.1,84.54 215.26,84.54 212.83,86.97 212.83,87.65 211.31,89.17 211.31,89.54 209.97,90.88 209.97,91.49 209.17,92.29 209.17,94.27 208.91,94.53 206.56,94.53 203.6,97.48 203.14,97.48 202.99,97.63 201.98,97.63 201.02,98.6 200.13,98.6 199.61,99.12 196.35,99.12 195.83,98.6 194.33,98.6 192.7,100.22 192.22,100.22 190.43,102.01 189.66,102.01 188.89,102.78 185.99,102.78 184.7,104.07 184.7,104.61 183.83,105.48 178.11,105.48 177.88,105.71 173.76,105.71 v2(173.35,106.13)
  IN3 w0.127: v2(297.41,22.05) 298.56,22.05 300.08,23.58 306.6,23.58 308.42,25.4 310.54,25.4 311.45,26.31 311.45,31.49 309.16,33.78 309.16,37.02 306.85,39.33 292.59,39.33 291.52,38.26 289.64,38.26 v2(289.18,37.8) 288.93,37.55 287,37.55 285.69,38.86 285.69,40.44 273.59,52.53 273.2,52.53 260.06,65.67 260.06,69.23 256.01,73.28 256.01,87.08 256.46,87.52 256.46,88.43 256.01,88.88 255.41,88.88 253.06,91.23 249.7,91.23 249.33,91.6 248.06,91.6 246.3,93.37 243.56,93.37 242.61,92.41 239.88,92.41 239.37,91.9 236.45,91.9 235.21,93.15 230.4,93.15 v2(230.36,93.19)
  BOTTOM w0.102: v2(221.66,80.98) 222.43,80.21 v1(222.79,80.21) 223.9,80.21 225.43,81.74 225.43,91.23 226.04,91.84 229.01,91.84 v2(230.36,93.19)
LID_CL_SIO#: length 5.3
  TOP w0.102: R807.2 175.29,108.36 v2(175.43,108.22) v1(175.07,107.86) 174.82,107.62 R805.2 C716.1
  BOTTOM w0.102: U46.B54 174.97,107.76 v2(175.43,108.22)
LOM_ACTLED_YEL#: length 21.5
  TOP w0.102: v2(237.41,115.53) 236.83,116.11 U32.15 ; U31.26 249.33,105.89 v2(249.47,105.75)
  IN2 w0.127: v2(249.47,105.75) 249.47,106.13 248.25,107.35 244.02,107.35 240.9,110.47 240.9,113.81 239.18,115.53 v2(237.41,115.53)
LOM_SPD10LED_GRN#: length 36.1
  TOP w0.102: v2(225.28,115.02) 225.34,114.96 U15.2 226.99,114.96 227.28,115.25 227.28,116.01 227.75,116.48 v1(227.75,116.93) 227.75,117.75 228.29,118.29 U32.42 ; U31.25 248.93,106.16 v2(248.84,106.07)
  IN2 w0.127: v2(248.84,106.07) 247.81,107.09 243.91,107.09 240.64,110.36 240.64,112.54 v2(238.93,114.26)
  IN4 w0.109: v2(238.93,114.26) 228.58,114.26 227.82,115.02 v2(225.28,115.02)
LOM_SPD100LED_ORG#: length 36
  TOP w0.102: v2(249.98,106.07) 249.73,106.31 U31.27 ; U15.1 225.39,115.61 v2(225.28,115.72) ; U32.16 v2(237.33,116.24) 237.66,116.24 v1(237.98,115.92)
  IN2 w0.127: v2(249.98,106.07) 248.44,107.6 244.12,107.6 241.15,110.57 241.15,114.12 239.03,116.24 v2(237.33,116.24)
  IN4 w0.109: v2(237.33,116.24) 236.64,116.92 235.94,116.92 234.67,115.65 228.39,115.65 228.13,115.4 225.59,115.4 v2(225.28,115.72)
LP#_EDRAMP: length 4.5
  TOP w0.102: v1(77.96,5.47) PR501.1
  TOP w0.254: PR501.1 76.14,5.47 PR500.1 75.35,6.24 74.78,6.24 74.47,6.55 PU500.6
LP#_EOPIOP: length 5.5
  TOP w0.102: v1(61.67,4.57) 60.94,5.3 PR1801.1
  TOP w0.254: PU1800.6 57.35,6.59 57.64,6.31 58.28,6.31 PR1800.1 PR1801.1
LPC_AD0: length 161.1
  TOP w0.089: v2(125.19,119.4) UH1.AT22
  TOP w0.102: v2(184.85,131.59) 185.53,131.59 186.67,130.45 186.67,128.5 v1(186.25,128.07) 185.73,127.55 183.99,127.55 182.97,126.53 182.97,125.57 185.6,122.93 185.6,116.92 185.76,116.76 185.76,116.48 186.45,115.78 186.45,115.68 186.86,115.27 186.86,114.55 185.98,113.67 185.9,113.67 185.85,113.63 185.22,113.63 184.65,113.06 184.65,110.43 185.49,109.59 v2(185.49,109.58) ; v2(207.94,128.04) 208.09,127.88 208.09,123.43 210.23,121.3 210.23,119.75 210.32,119.66 210.32,117.94 210.51,117.75 211.7,117.75 211.94,117.51 211.94,114.81 212.46,114.29 212.46,111.4 212.37,111.31 212.37,111.31 212.33,111.27 212.33,109.3 211.83,108.8 v2(211.43,108.8)
  IN2 w0.089: 128.26,126.2 128.26,126.08 127.68,125.5 127.68,124.86 124.83,122.01 124.83,119.76 v2(125.19,119.4)
  IN2 w0.127: v2(197.46,104.89) 196.63,105.72 195.09,105.72 194.49,105.12 193.12,105.12 192.85,105.38 192.85,105.65 192.38,106.12 191.42,106.12 189.69,107.84 188.26,107.84 186.97,109.13 185.93,109.13 185.49,109.56 v2(185.49,109.58) ; 128.26,126.2 128.25,126.21 128.25,126.56 130.17,128.48 130.98,128.48 130.99,128.47 131,128.47 131.8,127.67 132.67,127.67 134.31,129.31 134.31,129.94 134.66,130.29 136.14,131.77 138.93,131.77 140.06,130.64 140.61,130.64 142.39,132.42 143.57,132.42 144.91,133.75 145.17,133.75 146.44,135.02 149.71,135.02 150.37,135.68 153.47,135.68 154.44,134.71 156.27,134.71 156.62,134.36 159.69,134.36 160.14,133.91 164.2,133.91 165.15,132.95 166.28,132.95 167.89,131.34 179.04,131.34 179.43,130.96 183.96,130.96 184.59,131.59 v2(184.85,131.59)
  IN4 w0.127: v2(211.43,108.8) 211.43,108.5 209.44,106.51 208.47,106.51 207.77,105.81 205.31,105.81 204.93,106.19 204.1,106.19 203.57,105.66 198.24,105.66 v2(197.46,104.89)
  BOTTOM w0.102: v2(185.49,109.58) 185.43,109.51 U46.A27 ; JLPDE1.3 205.51,128.18 205.66,128.04 v2(207.94,128.04) ; v2(197.46,104.89) 197.46,105.18 197.75,105.46 U51.A30
LPC_AD1: length 150.8
  TOP w0.089: UH1.AV22 v2(125.19,120.16)
  TOP w0.102: v2(210.94,109.3) 211.18,109.54 211.18,110.76 212.01,111.59 212.01,113.71 210.82,114.89 210.82,116.79 209.86,117.76 209.86,119.32 208.97,120.21 v1(208.97,121.23) 208.97,121.91 207.64,123.24 207.64,126.24 207.18,126.7 207.18,128.3 207.31,128.43 207.31,128.73 v2(207.3,128.73)
  IN1 w0.109: v2(185.01,130.16) 185.22,129.94 185.22,128.83 184.74,128.35 184.74,118.78 185.01,118.51 185.01,117.54 184.59,117.13 184.59,110.63 185.23,110 185.65,110 v2(186.08,109.57)
  IN2 w0.089: v2(125.19,120.16) 125.65,120.62 125.65,122.34 127.02,123.72 128.57,123.72 129.39,124.54 130.22,124.54 131.17,125.5 131.7,125.5 132.4,126.2
  IN2 w0.127: 132.4,126.2 132.85,126.65 133.12,126.65 135.32,128.86 135.32,129.51 136.56,130.75 138.51,130.75 139.64,129.62 141.03,129.62 142.14,130.73 144.15,130.73 145.94,132.52 145.94,132.95 146.72,133.73 151.68,133.73 152.22,133.19 153.49,133.19 153.91,132.77 154.91,132.77 155.39,132.28 155.39,132.19 155.89,131.69 157.45,131.69 158.79,133.03 159.58,133.03 159.71,132.89 163.78,132.89 164.73,131.94 165.86,131.94 167.47,130.32 178.62,130.32 179.01,129.94 184.78,129.94 185,130.16 v2(185.01,130.16) ; v2(186.08,109.57) 186.24,109.74 186.24,109.75 186.49,110 186.83,110 188.45,108.38 190.06,108.38 191.06,107.37 192.48,107.37 193.6,108.49 194.25,108.49 195.98,106.76 197.06,106.76 v2(197.46,107.17)
  IN4 w0.127: v2(197.46,107.17) 197.46,107.06 198.61,105.91 203.46,105.91 203.99,106.45 205.04,106.45 205.42,106.07 207.56,106.07 208.51,107.02 209.28,107.02 210.94,108.67 v2(210.94,109.3)
  BOTTOM w0.102: v2(186.08,109.57) 185.63,110.01 U46.A26 ; JLPDE1.4 205.51,128.68 205.9,128.29 206.86,128.29 v2(207.3,128.73) ; U51.B32 197.5,107.14 197.47,107.17 v2(197.46,107.17)
LPC_AD2: length 161.3
  TOP w0.089: UH1.AT19 125.96,119.61 v2(126.23,119.4)
  TOP w0.102: v2(182.6,111.07) 182.6,111.24 183.84,112.48 183.84,112.89 185.04,114.09 185.68,114.09 186.06,114.47 186.13,114.47 186.41,114.74 186.41,115.08 186,115.49 186,115.59 185.55,116.03 185.01,116.03 184.72,116.33 184.72,116.79 185.09,117.16 185.09,121.91 v1(184.54,122.46) 182.51,124.49 182.51,126.72 183.8,128.01 184.7,128.01 v2(185.87,129.18) ; v2(211.69,109.37) 212.1,109.78 212.1,111.36 212.13,111.39 212.23,111.49 212.23,113.8 211.05,114.98 211.05,116.88 210.09,117.85 210.09,119.42 209.91,119.6 209.91,119.61 209.3,120.21 209.3,121.9 207.87,123.34 207.87,126.33 207.41,126.79 207.41,128.2 207.65,128.44 207.71,128.44 v2(207.94,128.67)
  IN2 w0.089: 133.38,126.2 133.12,126.2 132.35,125.43 132.35,125.04 132.05,124.73 130.91,124.73 130.35,124.18 129.53,124.18 128.69,123.34 127.3,123.34 126.92,122.95 126.92,120.08 v2(126.23,119.4)
  IN2 w0.127: v2(185.87,129.18) 185.36,128.67 178.1,128.67 176.95,129.82 167.26,129.82 165.65,131.43 164.52,131.43 163.66,132.29 160.91,132.29 159.99,131.36 157.84,131.36 157.08,130.6 154.09,130.6 151.47,133.22 146.93,133.22 146.45,132.73 146.45,132.03 143.62,129.2 142.29,129.2 142.12,129.37 141.5,129.37 141.24,129.12 139.42,129.12 138.29,130.25 136.77,130.25 135.83,129.3 135.83,128.65 133.38,126.2 ; v2(196.31,104.7) 195.99,104.38 194.12,104.38 193.76,104.74 193.13,104.74 192.6,105.28 192.6,105.54 192.3,105.84 191.34,105.84 189.59,107.59 188.15,107.59 186.87,108.87 185.46,108.87 183.71,110.62 183.05,110.62 v2(182.6,111.07)
  IN4 w0.127: v2(211.69,109.37) 211.69,109.3 211.85,109.14 211.85,108.41 209.7,106.26 208.58,106.26 207.88,105.56 205.46,105.56 205.26,105.35 204.4,105.35 204.38,105.37 198.31,105.37 197.88,104.95 197.88,104.71 197.64,104.47 196.54,104.47 v2(196.31,104.7)
  BOTTOM w0.102: U51.A31 197.25,105.34 196.96,105.05 196.96,104.99 196.67,104.7 v2(196.31,104.7) ; v2(182.6,111.07) 182.62,111.07 182.81,110.88 182.83,110.88 183.07,110.64 183.77,110.64 U46.B26 ; JLPDE1.5 205.13,129.18 205.34,129.39 207.22,129.39 v2(207.94,128.67)
LPC_AD3: length 155
  TOP w0.089: UH1.BD16 127.5,123.57 127.27,123.79 127.27,124.27 128.06,125.07 v2(128.06,125.09)
  TOP w0.102: v2(210.34,108.67) 210.34,108.64 210.59,108.39 211.8,108.39 212.56,109.14 212.56,111.17 212.6,111.22 212.69,111.31 212.69,114.38 212.17,114.9 212.17,117.77 212.01,117.94 211.23,118.71 211.23,119.07 210.52,119.78 210.52,121.33 208.45,123.4 208.45,129.37 v2(207.81,130) ; v2(183.24,111.05) 183.24,111.42 184.07,112.25 184.07,112.8 185.12,113.86 185.76,113.86 185.81,113.9 185.89,113.9 186.63,114.65 186.63,115.18 186.22,115.59 186.22,115.69 185.53,116.38 185.53,116.67 185.37,116.82 185.37,122.52 v1(183.37,124.53) 182.74,125.16 182.74,126.62 183.89,127.78 185.17,127.78 186.44,129.06 186.44,130.1 v2(185.85,130.7)
  IN2 w0.089: v2(128.06,125.09) 128.06,125.18 129.09,126.2 131.68,126.2
  IN2 w0.127: v2(183.24,111.05) 183.25,111.03 184.31,111.03 185.09,110.25 187.03,110.25 188.65,108.63 190.17,108.63 191.17,107.63 192.37,107.63 193.49,108.75 194.5,108.75 196.07,107.18 v2(196.56,107.18) ; 131.68,126.2 132.57,127.08 132.64,127.16 132.9,127.16 134.81,129.08 134.81,129.73 136.35,131.26 138.72,131.26 139.85,130.13 140.82,130.13 141.93,131.24 143.34,131.24 144,131.89 144,132.12 145.12,133.24 145.38,133.24 146.5,134.36 154.08,134.36 154.23,134.21 156.05,134.21 156.41,133.85 159.47,133.85 159.93,133.4 163.99,133.4 164.94,132.44 166.07,132.44 167.68,130.83 178.83,130.83 179.22,130.45 184.17,130.45 184.55,130.83 185.39,130.83 185.52,130.7 v2(185.85,130.7)
  IN4 w0.127: v2(196.56,107.18) 196.69,107.31 197.01,107.31 197.29,107.59 197.64,107.59 197.88,107.34 197.88,107.22 198.94,106.17 203.36,106.17 203.89,106.7 204.56,106.7 205.15,107.3 208.07,107.3 208.23,107.46 209.27,107.46 210.34,108.53 v2(210.34,108.67)
  BOTTOM w0.102: v2(207.81,130) 207.43,129.62 206.42,129.62 206.36,129.68 JLPDE1.6 ; U46.B25 183.25,111.26 183.24,111.27 v2(183.24,111.05) ; v2(196.56,107.18) 197,106.74 U51.B33
LPC_FRAME#: length 147.2
  TOP w0.089: v2(128.24,124.56) 127.85,124.56 127.5,124.21 UH1.BE16
  TOP w0.102: v2(209.66,108.73) 210.89,109.96 210.89,111.54 210.58,111.84 210.58,114.48 209.45,115.61 209.45,117.19 209.17,117.47 209.17,119.04 208.17,120.04 208.17,121.04 206.91,122.3 206.91,124.57 205.69,125.79 205.69,129.67 206.05,130.03 v2(207.12,130.03)
  IN1 w0.109: v2(186.05,111.79) 186.05,112.14 186.54,112.63 186.54,113.26 186.29,113.51 186.29,114.63 186.41,114.74 186.41,115.81 185.45,116.78 185.45,118.41 184.98,118.87 184.98,128.25 185.46,128.73 185.46,129.66 185.82,130.02 v2(185.82,130.11)
  IN2 w0.089: 132.04,126.2 131.52,125.67 131.03,125.67 130.28,124.92 129.2,124.92 128.84,124.56 v2(128.24,124.56)
  IN2 w0.127: v2(197.87,107.94) 197.66,108.15 196.59,108.15 196.58,108.16 196.57,108.16 195.05,109.67 194.06,109.67 193.97,109.76 193.35,109.76 192.72,109.13 188.95,109.13 186.99,111.09 186.38,111.09 186.05,111.42 v2(186.05,111.79) ; v2(185.82,130.11) 185.75,130.11 185.29,130.58 184.65,130.58 184.27,130.2 179.11,130.2 178.73,130.58 167.57,130.58 165.96,132.19 164.84,132.19 163.88,133.15 159.82,133.15 159.69,133.28 158.68,133.28 158.35,132.95 155.27,132.95 154.27,133.95 154.12,133.95 153.98,134.1 146.73,134.1 145.69,133.05 145.69,132.62 144.04,130.98 142.03,130.98 140.93,129.88 139.74,129.88 138.61,131.01 136.46,131.01 135.07,129.62 135.07,128.96 133.01,126.91 132.75,126.91 132.67,126.83 132.04,126.2
  IN4 w0.109: v2(209.66,108.73) 209.27,108.35 206.45,108.35 205.69,109.11
  IN4 w0.127: v2(197.87,107.94) 197.87,107.84 198.33,107.39 198.33,107.14 199.04,106.42 202.29,106.42 202.8,106.93 202.8,108.8 203.17,109.17 203.65,109.17 203.81,109.33 205.47,109.33 205.69,109.11
  BOTTOM w0.102: JLPDE1.7 v1(206.02,130.18) 206.96,130.18 v2(207.12,130.03) ; U51.B31 198,106.73 198.3,107.03 198.3,107.67 198.04,107.94 v2(197.87,107.94) ; U46.A21 185.25,112.51 185.3,112.57 185.69,112.57 185.93,112.33 185.93,111.91 v2(186.05,111.79)
LPC_LDRQ1#: length 3.2
  TOP w0.102: v2(185.51,112.15) 185.66,112.29 v1(186.12,112.29) 186.3,112.29 186.5,112.49 187.42,112.49 R783.1
  BOTTOM w0.102: U46.A22 185.38,112.01 v2(185.51,112.15)
LPS_PROTECT#: length 178.3
  TOP w0.102: v2(59.76,40.76) 59.76,40.34 59.69,40.27 v1(59.69,39.92) 59.69,39.38 59.32,39.01 56.84,39.01 56.68,38.85 JIO2.67
  IN2 w0.127: v2(175.43,91.33) 174.98,90.89 174.98,90.45 174.01,89.48 162.97,89.48 162.21,90.24 156.46,90.24 151.37,85.15 144.66,85.15 143.91,85.9 139.24,85.9 138.77,86.37 137.43,86.37 136.67,87.14 132.61,87.14 131.97,87.78 125.2,87.78 124.29,88.69 111.75,88.69 110.25,87.19 107.54,87.19 106.08,85.73 105.31,85.73 104.65,85.07 102.28,85.07 100.72,83.51 99.24,83.51 90.87,75.15 90.87,62.75 78.12,49.99 74.28,49.99 71.44,47.16 71.44,46.14 71.15,45.85 69.52,45.85 64.74,41.08 60.05,41.08 59.76,40.79 v2(59.76,40.76)
  IN3 w0.127: v2(176.07,113.24) 174.73,111.9 174.73,105.97 175.36,105.34 175.36,99.33 175.07,99.05 175.07,94.29 175.43,93.94 v2(175.43,91.33)
  BOTTOM w0.102: U46.B66 175.55,113.76 v2(176.07,113.24)
LPSS_UART2_RXD: length 8
  TOP w0.102: UH1.AR45 111.57,118.87 111.33,118.64 v2(111.33,118.49)
  BOTTOM w0.089: RH352.2 113.16,116.89 112.37,116.89
  BOTTOM w0.102: JUART1.3 110.49,119.7 RH355.2 111.08,118.74 v2(111.33,118.49) 111.54,118.27 v1(111.54,117.68) 111.54,117.06 111.72,116.89 112.37,116.89
LPSS_UART2_TXD: length 14.7
  TOP w0.089: UH1.AR39 115.84,119.36 v2(116.18,119.7)
  IN2 w0.127: v2(110.74,118.4) 110.74,118.6 111.33,119.2 115.68,119.2 v2(116.18,119.7)
  BOTTOM w0.089: RH354.2 113.77,118.89 114.13,119.25 114.58,119.25 114.91,119.58 114.91,119.93 115.22,120.24 115.65,120.24 v2(116.18,119.7)
  BOTTOM w0.102: RH351.2 111.38,116.09 111.06,116.41 111.06,118.08 v2(110.74,118.4) 110.23,118.9 JUART1.2
LX_2.5V:
  vias: v1(20.47,53.39)
LX_CHG: length 13.8
  IN1 w1.016: 277.73,23.13 276.65,23.13 275.25,24.53 275.25,30.12 274.75,30.62 274.75,33.53 275.52,34.3 275.81,34.3 275.95,34.44
  vias: v1(282.2,27.94) v2(277.22,34.79) v2(277.82,34.77) v2(278.69,23.57) v2(278.72,22.96)
M2_SLOT2_PCIE#_SATA: length 83.4
  TOP w0.089: UH1.AD31 v2(120.04,114.29)
  IN2 w0.089: 141.76,110 136.53,110 133.67,112.87 127.23,112.87 126.98,113.11 125.03,113.11 124.76,113.38 124.76,113.63 124.51,113.88 124.26,113.88 123.99,114.14 123.99,114.39 123.76,114.62 120.62,114.62 120.28,114.29 v2(120.04,114.29)
  IN2 w0.127: 141.76,110 146.71,110 147.19,109.52 147.4,109.52 148.67,109.52 148.84,109.68 150.58,109.68 151.02,109.24 151.36,109.24 152.09,109.96 152.95,109.96 153.74,110.75 164.19,110.75 164.6,110.33 166.34,110.33 v2(166.79,109.88)
  BOTTOM w0.089: v2(120.04,114.29) 118.27,112.53 116.21,112.53 116.02,112.72 v1(115.65,112.72) 115.01,112.72 114.84,112.56 112.37,112.56
  BOTTOM w0.102: RH318.2 106.82,113.69 107.95,112.56 112.37,112.56 ; U46.A45 177.05,103.98 175.45,102.38 174.48,102.38 172.6,104.26 168.98,104.26 168.17,105.07 168.17,105.29 167.14,106.31 167.14,108.08 166.35,108.88 166.35,109.43 v2(166.79,109.88)
M2_SLOT3_PEDET: length 166.9
  TOP w0.089: UH1.AG36 v2(117.7,115.33)
  TOP w0.102: QN5.1 19.91,26.82 19.15,27.58 R372.1 R363.1 v1(20.01,30.88) 20.01,34.76 23.78,38.53 23.78,40.64 25.3,42.16 26.59,42.16 27.66,43.24 v2(27.66,44.85)
  IN2 w0.089: v2(117.7,115.33) 117.34,114.97 112.81,114.97 112.37,115.4
  IN2 w0.127: v2(27.66,44.85) 29.57,44.85 34.59,49.88 41.51,49.88 44.12,47.26 49.63,47.26 50.3,47.93 53.63,47.93 53.72,48.03 54.63,48.03 56.87,50.26 56.88,50.26 56.89,50.27 57.23,50.27 57.24,50.26 64.37,50.26 67.57,53.46 71.64,53.46 72.23,54.06 75.34,54.06 86.81,65.53 86.81,77.35 101.16,91.71 104.33,91.71 104.65,92.03 104.65,93.38 104.38,93.65 104.38,96.81 102.5,98.69 102.5,104.25 102.11,104.64 102.11,108.37 104.52,110.78 104.52,111.12 105.96,112.56 105.96,113.1 108.78,115.92 111.85,115.92 112.37,115.4
M_REXT_UN8: length 3.7
  TOP w0.102: UN8.10 24.26,28.88 23.94,29.19 23.69,29.19 v1(23.4,29.48) 22.89,29.99 RN53.1
M_REXT_UN9: length 3.4
  TOP w0.102: RN58.1 32.72,29 32.92,28.8 34.83,28.8 34.98,28.95 UN9.10
MASK_BASE_LEDS#: length 5.6
  TOP w0.102: Q359.2 301.96,9.81 v1(301.96,8.94) 302.14,8.76 303,8.76 303.29,8.47 303.64,8.47 303.93,8.76 304.74,8.76 305.51,9.53 U58.4
MASK_SATA_LED#: length 216.1
  TOP w0.102: v2(179.04,113.99) 179.04,113.45 v1(178.73,113.14) ; Q74.5 307.89,7.45 309.25,8.81 309.25,9.67 v2(308.95,9.96)
  IN2 w0.127: v2(301.1,32.29) 300.9,32.09 298.56,32.09 295.46,35.18 295.46,36.06 292.21,39.31 291.14,39.31 288.65,41.8 283.15,41.8 279.41,45.54 276.99,45.54 258.57,63.96 258.57,65.51 256.58,67.5 256.58,69.54 249.78,76.35 247.14,76.35 245.75,77.74 245.75,78.74 239.63,84.86 238.84,84.86 234.59,89.1 231.31,89.1 226.46,93.95 226.46,94.55 226.73,94.83 226.73,97.05 227.84,98.17 227.84,100.27 230.73,103.16 230.73,108.15 226.36,112.52 225.71,112.52 224.32,113.91 224.32,115.26 221.86,117.72 217.2,117.72 216.39,118.53 216.39,119.67 214.8,121.26 213.36,121.26 212.65,120.54 212.65,119.69 211.94,118.98 211.58,118.98 211.1,119.47 210.11,119.47 210.03,119.39 206.1,119.39 205.68,118.97 201.38,118.97 201.23,118.82 196.01,118.82 195.51,119.32 194.41,119.32 193.59,118.49 192.35,118.49 191.21,117.34 189.16,117.34 188.52,116.69 185.75,116.69 185.53,116.92 184.95,116.92 184.7,116.67 184.7,116.51 183.7,115.5 180.13,115.5 179.46,114.84 179.46,114.41 v2(179.04,113.99)
  IN4 w0.109: v2(301.1,32.29) 301.1,30.43 308.95,22.58 308.95,9.97 v2(308.95,9.96)
  BOTTOM w0.102: U46.B9 179.3,115.15 179.47,114.98 179.47,114.42 v2(179.04,113.99)
ME_FWP: length 80.5
  TOP w0.102: v2(149.25,132.71) 148.68,132.71 147.36,131.38 147.36,130.38 146.16,129.18 RH328.1
  IN2 w0.127: v2(199.62,143.75) 197.63,143.75 195.91,145.46 195.5,145.88 193.13,145.88 192.55,146.46 191.53,146.46 190.68,147.31 181.04,147.31 181.03,147.32 180.19,147.32 180.18,147.31 176.77,147.31 176.42,147.66 176.38,147.66 172.34,147.66 171.61,146.93 169.62,146.93 169.01,147.54 167.73,147.54 167.09,148.18 157.89,148.18 157.45,147.74 155.29,147.74 v2(155.16,147.87)
  IN3 w0.127: v2(155.16,147.87) 155.16,147.01 156.39,145.78 156.39,143.49 157.12,142.77 157.12,140.19 156.29,139.36 156.29,134.78 155.6,134.09 151.21,134.09 149.82,132.71 v2(149.25,132.71)
  BOTTOM w0.102: v2(199.62,143.75) 198.86,143.75 198.75,143.64 v1(198.75,143.46) 198.75,143.34 198.88,143.21 RC301.1 200.37,142.76 199.87,142.25 SW2.3
ME_FWP_EC: length 70.8
  TOP w0.102: v2(196.03,138.86) 195.97,138.86 195.03,137.92 195.03,136.59 197.04,134.57 197.04,132.51 198.58,130.97 198.58,127.15 v2(197.32,125.88)
  IN3 w0.127: v2(173.61,125.31) 173.13,124.83 173.13,121.72 175.06,119.79 175.06,117.22 174.71,116.87 174.21,116.87 173.08,115.73 v2(173.08,115.4)
  IN4 w0.109: v2(197.32,125.88) 196.83,125.4 194.06,125.4 193.57,125.88 191.85,125.88 190.59,124.62 181.76,124.62 181.41,124.27 177.47,124.27 176.33,125.41 173.71,125.41 v2(173.61,125.31)
  BOTTOM w0.102: SW2.1 203.87,142.18 204.06,142.37 204.06,143.03 v3(204.01,143.08) 203.77,143.32 203.77,144.46 203.12,145.12 201.36,145.12 RC301.2 200.34,144.16 197.52,144.16 196.03,142.66 v2(196.03,138.86) ; U46.A64 173.32,114.51 173.08,114.76 v2(173.08,115.4)
ME_RESET#: length 2.7
  TOP w0.102: UC3.2 143.54,126.77 143.68,126.91 RH70.1 143.68,128.27 v1(143.45,128.5)
ME_SUS_PWR_ACK: length 118.1
  TOP w0.089: UH1.BD19 125.99,123.63 125.99,124.61 v2(126.38,125) 126.56,125.18 126.56,125.37 126.57,125.38 126.57,126.2
  TOP w0.102: RH327.1 126.09,129.38 RH84.2 126.57,127.63 126.57,126.2
  IN3 w0.127: v2(212.58,125.43) 212.27,125.12 212.27,113.84 211.67,113.24 210.97,113.24 209.89,112.16 208.78,112.16 207.91,111.29 v2(206.66,111.29)
  IN4 w0.089: v2(126.38,125) 126.38,125.18 126.79,125.58 128.21,125.58 129.12,124.68 131.34,124.68 131.55,124.47 137.6,124.47 138.18,123.88 139.51,123.88 140.36,123.03 141.76,123.03
  IN4 w0.109: 141.76,123.03 142.28,123.03 143.11,123.86 143.75,123.86 143.85,123.76 145.73,123.76 145.78,123.82 148.96,123.82 149.18,124.04 152.91,124.04 153.33,123.63 153.67,123.63 154.97,124.92 156.27,124.92 157.43,123.77 165.28,123.77 165.95,123.1 166.62,123.1 166.74,123.22 167.08,123.22 167.75,122.56 168.85,122.56 169.52,121.89 177.23,121.89 177.84,122.5 178.98,122.5 179.14,122.66 191.22,122.66 192.59,124.03 193.72,124.03 194.38,124.69 198.06,124.69 198.45,125.07 205.79,125.07 206.29,124.57 211.71,124.57 v2(212.58,125.43)
  BOTTOM w0.102: U51.A8 206.59,111.36 v2(206.66,111.29)
MEC_XTAL1: length 4.9
  BOTTOM w0.102: Y6.1 202.11,120.66 202.74,120.03 C743.1 202.74,118.93 202.55,118.74 v1(202.55,118.57) 202.55,118 202.75,117.8 U51.A61
MEC_XTAL2: length 2.5
  BOTTOM w0.102: Y6.2 204.61,120 204.5,119.89 C741.1 R1068.2
MEC_XTAL2_R: length 2.2
  BOTTOM w0.102: U51.A62 203.25,117.39 203.34,117.48 v1(203.34,117.56) 203.34,117.97 203.61,118.24 R1068.1
MEDIACARD_IRQ#: length 281.1
  TOP w0.089: UH1.AL39 115.85,117.1 v2(116.14,116.81)
  TOP w0.102: v2(316.42,31.85) 316.37,31.8 JIO1.67
  IN1 w0.109: v2(232.05,102.93) 232.05,102.9 233.53,101.42 236.83,101.42 239.22,99.03 239.22,96.22 237.25,94.25 237.25,92.08 238.89,90.44 239.21,90.44 240.01,89.64 240.01,87.32 240.96,86.37 240.96,84.93 246.61,79.28 246.61,78.07 246.94,77.74 246.94,76.57 250.54,72.97 250.54,70.46 256.26,64.73 256.26,61.79 265.16,52.9 266.66,52.9 275.25,44.31 280.41,44.31 282.73,41.99 287.3,41.99 289.06,40.23 290.41,40.23 290.89,39.75 296.48,39.75 297.11,39.11 298.96,39.11 299.25,38.82 299.25,38.39 299.25,37.98 303.88,33.36 308.4,33.36 309.13,32.63 309.54,32.63 312.18,32.63 312.34,32.79 314.3,32.79 315.24,31.85 v2(316.42,31.85)
  IN2 w0.089: v2(116.14,116.81) 116.14,116.81 116.62,116.32 118.57,116.32 119.42,117.18 121.84,117.18 122.08,117.42 123.29,117.42 124.8,115.91 124.8,115.66 125.06,115.4 127.24,115.4 127.94,114.7 133.07,114.7 136.6,111.17 141.76,111.17
  IN2 w0.127: v2(232.05,102.93) 233.86,104.74 233.86,107.95 231.5,110.31 231.5,114.81 228.94,117.37 227.92,117.37 226.45,118.84 226.45,123.04 223.39,126.09 220.76,126.09 220.21,126.65 216.13,126.65 215.7,126.22 211.8,126.22 211.09,125.5 207.88,125.5 206.97,126.41 201.42,126.41 200.35,125.34 196.28,125.34 196.07,125.14 194.25,125.14 193.5,124.39 192.34,124.39 190.85,122.9 188.27,122.9 187.4,122.03 184.45,122.03 183.98,121.55 180.72,121.55 179.94,120.77 179.94,120.41 179.71,120.18 178.86,120.18 178.71,120.02 173.3,120.02 171.71,118.44 170.93,118.44 168.71,116.22 168.71,111.16 168.47,110.92 167.91,110.92 167.73,111.09 164.92,111.09 164.5,111.51 153.42,111.51 152.64,110.73 148.8,110.73 148.36,110.28 147.55,110.28 146.66,111.17 141.76,111.17
MEM_SMBCLK: length 17.4
  TOP w0.089: UH1.AW44 113.86,121.04 v2(114.15,121.33)
  TOP w0.102: v2(111.02,126.26) 111.02,127.66 110.89,127.78 v1(110.72,127.78) 110.66,127.78 110.53,127.66 110.53,126.13 110.41,126 109.3,126 109.17,126.13 QH4.6 108.62,126.17 107.73,126.17 106.68,127.23 RH56.2
  IN2 w0.089: v2(114.15,121.33) 114.13,121.31 113.61,121.31 113.52,121.4 113.52,121.53 113.61,121.62 113.8,121.62 113.9,121.72 113.9,121.85 113.75,122 113.46,122 112.91,122.54 112.89,122.54 112.87,122.56
  IN2 w0.127: 112.87,122.56 112.75,122.68 112.24,122.68 110.42,124.5 110.42,125.51 110.57,125.66 110.57,125.81 v2(111.02,126.26)
MEM_SMBDATA: length 15.5
  TOP w0.089: v2(113.66,122.42) 113.68,122.39 UH1.BB43
  TOP w0.102: v2(111.06,125.5) 111.43,125.87 111.43,129.12 111.11,129.43 109.83,129.43 109.16,130.11 v1(108.72,130.11) 108.49,130.11 107.84,129.46 107.84,128.65 QH4.3 107.36,128.12 RH65.2
  IN2 w0.089: v2(113.66,122.42) 113.63,122.42 113.21,122.84 113.21,122.86 113.19,122.88
  IN2 w0.127: v2(111.06,125.5) 111.05,125.5 110.88,125.32 110.88,124.69 112.43,123.13 112.94,123.13 113.19,122.88
MID1_CA_DET: length 196.4
  TOP w0.102: RV28.2 154.86,118.4 154.41,118.84 154.41,119.87 v2(154.97,120.43) ; JIO2.59 57.99,36.85 58.21,37.07 60.8,37.07 61.12,36.75 61.12,36.11 61.12,36 62.07,35.05 v2(62.36,35.05)
  IN2 w0.127: v2(142.46,120.25) 142.63,120.25 143.49,121.11 147.72,121.11 148.08,121.47 149.94,121.47 151.15,122.68 151.8,122.68 154.05,120.43 v2(154.97,120.43) ; v2(107.05,80.86) 103.06,76.88 100.67,76.88 98.82,75.03 98.82,74.55 96.02,71.75 96.02,60.45 77.17,41.6 75.78,41.6 74.38,40.2 74.16,40.2 72.32,38.36 72.32,37.78 69.51,34.97 67.95,34.97 67.39,35.53 63.99,35.53 63.5,35.05 v2(62.36,35.05)
  BOTTOM w0.102: UV2.33 154.89,118.67 154.41,119.15 154.41,119.87 v2(154.97,120.43) ; 140.29,106.42 143.24,106.42 147.16,102.5 147.16,102.47 147.33,102.3 U631.48 ; 140.29,106.42 138.98,106.42 136.31,103.75 136.31,101.01 134.7,99.4 131.92,99.4 131.69,99.63 131.16,99.63 130.89,99.36 123.26,99.36 122.88,98.98 109.04,98.98 108.59,99.43 108.59,100 107.29,101.3 106.09,101.3 105.49,100.71 105.15,100.71 103.89,99.44 103.89,98.38 96.63,91.12 96.63,90.04 100.69,85.97 101.74,85.97 102.94,84.78 104.96,84.78 106.03,83.71 106.03,81.88 v2(107.05,80.86) ; 140.29,106.42 140.29,107.21 140.12,107.37 140.12,108.4 140.48,108.76 141.87,108.76 143.15,110.03 143.15,110.75 v1(144.26,111.86) 144.26,117.41 143.54,118.13 143.54,119.17 v2(142.46,120.25)
MID2_CA_DET: length 156.2
  TOP w0.102: Q367.2 169.52,94.52 RV48.1 168.39,93.38 168.39,91.44 v2(168.18,91.23) ; JIO2.84 53.6,42.85 v2(54.08,43.33)
  IN1 w0.109: v2(168.18,91.23) 167.2,92.21 165.68,92.21 165.09,91.63 165.09,90.76 v2(165.03,90.7)
  IN2 w0.127: v2(165.03,90.7) 165,90.73 164.53,90.73 164.51,90.75 162.81,90.75 161.9,91.65 159.94,91.65 159.03,90.75 156.25,90.75 151.16,85.66 144.87,85.66 144.13,86.41 139.59,86.41 136.95,89.05 129.55,89.05 129.28,89.32 123.42,89.32 123.3,89.2 110.23,89.2 108.74,87.71 107.34,87.71 105.87,86.24 105.1,86.24 104.46,85.61 100.83,85.61 100.61,85.61 90.37,75.36 90.37,62.96 77.91,50.5 74.06,50.5 71.55,47.99 70.93,47.99 64.55,41.6 57.78,41.6 57.34,42.03 56.01,42.03 54.84,43.2 54.21,43.2 v2(54.08,43.33)
  BOTTOM w0.102: v2(165.03,90.7) 165.1,90.77 165.1,91.32 165.38,91.59 U636.48
MID2_CA_DET_Q: length 8.4
  TOP w0.102: R3746.2 171.61,100.48 v1(171.86,100.22) 171.86,98.45 172.06,98.24 Q369.5 Q369.2 171.52,96.07 170.37,96.07 170.17,95.87 Q367.3
MSCLK: length 70.9
  TOP w0.102: v2(182.22,102.64) 182.02,102.84 182.02,103.27 181.75,103.54 180.87,103.54 180.03,102.7 176.51,102.7 175.3,103.91 174.15,103.91 172.9,105.15 172.15,105.15 171.8,105.5 171.8,107.04 171.91,107.14 172.44,107.14 172.82,107.52 172.82,107.53 172.87,107.58 172.87,108.86 172.41,109.32 172.41,110.46 172.97,111.02 173.4,111.02 173.82,111.43 173.82,114.33 174.17,114.68 174.17,115.35 173.89,115.63 173.89,116.71 174.06,116.88 174.06,116.89 v2(174.46,117.29) ; v2(190.33,119.95) 190.33,119.79 190.78,119.35 192.69,119.35 192.97,119.63 192.97,119.76 193.25,120.04 193.5,120.04 193.89,119.64 193.89,118.42 195.55,116.77 195.55,116.37 195.94,115.97 196.9,115.97 v1(196.91,115.97) 196.91,115.97 197.82,115.97 198.17,115.62 198.17,114.55 198.06,114.44 198.06,112.55 v2(197.64,112.14)
  IN4 w0.109: v2(174.46,117.29) 174.53,117.36 174.91,117.36 175.18,117.62 175.18,118.66 175.71,119.19 178.82,119.19 178.94,119.31 180.07,119.31 180.23,119.47 181.52,119.47 181.99,119.94 188.1,119.94 188.83,119.21 189.78,119.21 190.17,119.6 190.17,119.79 v2(190.33,119.95)
  BOTTOM w0.102: v2(182.22,102.64) 182.16,102.58 JDEG2.6 182.16,101.31 182.06,101.2 181.97,101.2 181.89,101.13 181.89,101.13 181.63,100.86 181.63,99.4 182.15,98.88 182.15,97.04 181.63,96.51 R847.2 ; v2(197.64,112.14) 197.64,111.89 197.19,111.44 196.74,111.44 196.41,111.11 U51.B43
MSDATA: length 71.1
  TOP w0.102: v2(173.83,117.29) 173.83,116.97 173.56,116.71 173.56,115.5 173.94,115.12 173.94,114.78 173.59,114.42 173.59,111.53 173.31,111.25 172.87,111.25 172.18,110.56 172.18,109.23 172.64,108.77 172.64,107.68 172.59,107.62 172.59,107.61 172.35,107.37 171.82,107.37 171.58,107.13 171.58,105.4 172.05,104.92 172.78,104.92 174.02,103.68 175.21,103.68 176.41,102.47 180.13,102.47 180.97,103.31 181.66,103.31 181.79,103.18 181.79,102.84 v2(181.59,102.64) ; v2(193.75,110.2) 193.75,110.25 194.72,111.22 194.72,112.37 194.48,112.61 193.99,112.61 193.9,112.52 193.53,112.52 192.74,113.3 192.74,114.66 191.5,115.89 190.78,115.89 188.78,117.9 R869.2 187.86,118.66 v1(188.67,119.46) 189.16,119.95 v2(189.75,119.95)
  IN4 w0.109: v2(189.75,119.95) 189.88,119.82 189.88,119.64 189.68,119.45 188.93,119.45 188.2,120.17 181.89,120.17 181.43,119.71 180.13,119.71 179.97,119.55 178.84,119.55 178.73,119.43 175.62,119.43 174.94,118.75 174.94,117.96 174.76,117.78 174.32,117.78 v2(173.83,117.29)
  BOTTOM w0.102: U51.A40 194.72,110.86 194.7,110.84 194.65,110.84 194.57,110.76 194.31,110.76 v2(193.75,110.2) ; R850.2 181.4,95.4 181.4,96.61 181.92,97.13 181.92,98.78 181.4,99.3 181.4,100.96 181.68,101.24 181.66,101.25 JDEG2.7 181.66,102.56 v2(181.59,102.64)
MUX_CET: length 6
  TOP w0.102: v2(149.78,142.59) 149.81,142.55 C98.2
  BOTTOM w0.102: v2(149.78,142.59) 150.42,142.59 150.96,142.06 v1(150.98,142.06) 151.39,141.65 151.39,139.81 150.81,139.23 U630.47
MUX_REXT: length 6.3
  TOP w0.102: v2(145.14,139.66) 144.63,140.16 143.93,140.16 143.44,140.66 142.94,140.66 142.79,140.81 142.79,141.5 R101.2 v1(143.3,142.9)
  BOTTOM w0.102: U630.34 145.61,139.1 145.38,139.33 145.38,139.42 v2(145.14,139.66)
MXM_ALERT#: length 12.7
  TOP w0.102: JMXM1.58 208.25,78.9 208.43,78.72 R4.2 208.12,77.5 207.12,78.51 206.49,78.51 v2(206.04,78.05)
  BOTTOM w0.102: v2(206.04,78.05) 205.71,78.05 v1(205.26,77.6) 200.9,77.6 Q5.3
MXM_BIA_PWM: length 188.4
  TOP w0.102: v2(214,116.84) 214.56,116.84 v1(215.04,116.36) 215.19,116.2 215.19,116.01 215.86,115.34 215.86,114.26 214.14,112.54 214.14,109.98 216.07,108.05 216.08,108.05 216.32,107.8 216.32,107.8 216.44,107.68 216.44,107.38 215.99,106.93 215.29,106.93 214.92,106.55 214.92,106.03 215.45,105.49 215.45,104.86 214.61,104.01 214.61,100.36 216.01,98.96 216.01,98.19 218.25,95.94 218.25,93.3 216.96,92.01 212.02,92.01 211.84,92.18 210.06,92.18 209.67,91.79 206.66,91.79 206.13,91.26 206.13,90.02 207,89.15 JMXM1.63
  IN1 w0.109: v2(151.17,146.71) 150.73,146.26 150.55,146.26 149.3,145.01 137.49,145.01 136.66,144.18 135.77,144.18 135.01,143.42 129.29,143.42 128.18,144.53 127.98,144.53 127.26,145.24 126.66,145.24 122.28,149.63 115.95,149.63 113.56,152.01 113.56,155.35 111.85,157.07 109.62,157.07 109.36,156.81 109.36,156.39 v2(109.76,155.99) ; v2(214,116.84) 213.66,116.84 213.34,117.16 213.34,124.29 214.1,125.05 214.1,130.2 214.55,130.64 214.55,131.66 214.1,132.1 214.1,134.38 212.03,136.45 212.03,137.38 210.82,138.59 209.15,138.59 208.47,139.26 v2(208.47,139.38)
  IN2 w0.127: v2(208.47,139.38) 208.31,139.21 207.86,139.21 206.93,140.14 206.72,140.14 200.61,140.14 199.79,140.96 198.81,140.96 198.38,141.4 195.14,144.67 193.03,144.67 192.49,144.13 190.19,144.13 189.45,144.86 186.8,144.86 186.22,145.44 177.65,145.44 175.94,147.15 172.55,147.15 171.82,146.42 169.41,146.42 168.8,147.04 167.52,147.04 166.88,147.67 158.68,147.67 158.09,147.09 154.35,147.09 154.31,147.12 151.66,147.12 151.24,146.71 v2(151.17,146.71)
  BOTTOM w0.102: U3.2 109.57,155.8 v2(109.76,155.99)
MXM_CLK_REQ#: length 18.4
  TOP w0.102: v2(175.75,81.14) 175.75,81.17 175.25,80.67 JMXM1.182 175.25,78.58 174.69,78.03 v3(174.69,77.5)
  BOTTOM w0.102: v2(175.75,81.14) 175.75,81.15 175.72,81.17 174.85,81.17 173.45,79.78 165.13,79.78 163.49,78.14 R1978.2
MXM_DP_HDMI_HPD: length 122.5
  TOP w0.102: D8.1 146.32,73.3 v2(146.38,73.24) ; v2(156.71,72.98) 158.2,74.47 D7.1 ; v2(171.33,112.88) 169.9,112.88 168.89,111.87 168.89,109.96 169.34,109.51 169.34,106.71 168.27,105.63 168.27,103.46 167.97,103.17 167.97,101.52 168.53,100.96 168.53,100.16 v2(170.13,98.56) ; v2(149.84,73.24) 150.5,73.24 D18.1
  IN2 w0.127: v2(187.43,86.63) 187.43,87.4 191.3,91.27 191.3,94.07 189.72,95.65 185.31,95.65 184.32,96.64 181.46,96.64 181.33,96.51 180.77,96.51 179.79,97.49 177.41,97.49 176.67,96.76 176.67,95.54 176.39,95.26 175.48,95.26 174.86,94.64 173.71,94.64 170.25,98.1 170.25,98.45 v2(170.13,98.56) ; v2(171.33,112.88) 172.12,113.68 176.04,113.68 176.99,114.62 v2(177,114.62) ; v2(156.71,72.98) 156.71,72.67 156.57,72.54 150.55,72.54 v2(149.84,73.24) 149.2,72.6 146.73,72.6 146.38,72.95 v2(146.38,73.24)
  BOTTOM w0.102: v2(171.33,112.88) 171.18,113.03 RP4.4 ; v2(177,114.62) 177,114.88 176.8,115.07 U46.B4 ; v2(187.43,86.63) 187.02,86.22 181.85,86.22 181.51,85.88 181.51,84.9 179.28,82.67 174.42,82.67 173.4,81.64 158.44,81.64 156.98,80.18 156.98,77.64 154.54,75.2 154.54,73.24 155.3,72.47 156.2,72.47 v2(156.71,72.98)
MXM_DPA_AUXN: length 46.3
  TOP w0.102: JMXM1.307 144.5,89.25 144.21,89.53 143.13,89.53 142.99,89.67 142.99,90.49 142.03,91.46 v2(141.27,91.46)
  IN1 w0.117: v2(141.27,91.46) 141.39,91.33 141.88,91.33 142.19,91.64 142.19,95.8 142.19,96.04 144.19,98.03 144.19,107.53 146.92,110.26 146.92,110.7 v2(147.93,111.72) 148.06,111.59 148.55,111.59 149.94,112.99 151.36,112.99 151.55,113.18 151.68,113.18 v2(151.87,113.37)
  BOTTOM w0.102: Q355.4 151.31,112.18 151.43,112.29 151.43,112.67 151.11,112.99 151.11,113.24 151.49,113.62 151.62,113.62 v2(151.87,113.37) 151.99,113.25 152.19,113.25 152.32,113.38 152.32,114.13 152.87,114.69 UV2.23 ; C1437.1 149.2,116.94 148.71,116.94 148.31,116.54 v4(148.31,113.54) 148.31,112.61 148.34,112.58 148.34,111.87 148.19,111.72 v2(147.93,111.72)
MXM_DPA_AUXN_C: length 3.9
  BOTTOM w0.102: UV2.25 152.17,115.49 151.62,116.03 151.62,116.54 151.09,117.06 150.85,117.06 C1437.2
MXM_DPA_AUXP: length 46.3
  TOP w0.102: JMXM1.309 144,88.68 144.09,88.77 144.14,88.77 144.23,88.86 144.23,89.14 144.1,89.26 143.02,89.26 142.73,89.56 142.73,90.38 141.92,91.19 141.58,91.19 141.46,91.07 141.39,91.07 141.27,90.95 v2(141.27,90.79)
  IN1 w0.117: v2(151.87,112.78) 151.76,112.89 151.67,112.89 151.48,112.7 150.06,112.7 148.67,111.31 148.11,111.31 v2(147.94,111.13) 147.75,111.13 147.2,110.58 147.2,110.14 144.47,107.41 144.47,97.92 142.47,95.92 142.47,91.52 142,91.05 141.36,91.05 141.27,90.95 v2(141.27,90.79)
  BOTTOM w0.102: v2(151.87,112.78) 152.07,112.99 152.3,112.99 152.58,113.27 152.58,114.02 152.85,114.29 UV2.22 ; Q355.1 149.58,114.45 149.27,114.76 149.27,116.11 C1438.1 149.45,116.67 148.82,116.67 148.58,116.43 v4(148.58,115.12) 148.58,112.72 148.61,112.69 148.61,111.8 v2(147.94,111.13)
MXM_DPA_AUXP_C: length 4
  BOTTOM w0.102: UV2.24 152.71,115.09 152.58,115.22 152.06,115.22 v4(151.74,115.54) 151.35,115.92 151.35,116.43 150.98,116.8 150.87,116.8 150.81,116.73 150.8,116.73 C1438.2
MXM_DPA_HPD: length 58.5
  TOP w0.102: v2(145,78.13) 145.74,78.13 146.32,77.55 D8.2 145.66,75.71 U27.2
  IN1 w0.109: v2(157.36,84.83) 157.74,85.21 157.74,85.78 156.51,87.02 156.32,87.02 152.76,90.57 152.76,95.08 152.94,95.26 152.94,99.99 155.16,102.21 155.16,103.05 157.61,105.5 160.07,105.5 v2(161.65,107.08)
  IN2 w0.127: v2(157.36,84.83) 157.08,84.83 155.43,83.18 154.55,83.18 152.67,81.3 149.88,81.3 147.82,79.24 146.11,79.24 v2(145,78.13)
  BOTTOM w0.102: v2(161.65,107.08) 161.65,107.92 162.21,108.48 163.43,108.48 163.72,108.77 163.72,109.93 v1(163.42,110.23) 160.89,112.76 UV2.3
MXM_DPA_HPD_GATE: length 5.9
  TOP w0.102: v3(141.67,76.11) 141.92,76.36 U27.4 143.62,76.36 143.8,76.53 143.8,77.19 R60.1 144.09,78.4 144.75,79.06 JMXM1.304
MXM_DPA_N0: length 29.3
  TOP w0.102: JMXM1.283 150.5,89.35 150.28,89.56 150.28,89.73 150.04,89.97 149.51,89.97 v2(149.36,90.12)
  IN1 w0.117: v2(149.36,90.12) 149.36,89.87 149.51,89.72 149.78,89.72 150.09,90.03 150.09,91.22 151.62,92.75 151.62,95.4 151.87,95.65 151.87,102.13 156.9,107.16 158.47,107.16 159.78,108.48 160.06,108.48 160.12,108.54 160.12,108.74 v2(159.88,108.98)
  BOTTOM w0.102: v2(159.88,108.98) 160.08,109.18 160.08,109.36 C540.1
MXM_DPA_N0_C: length 3.1
  BOTTOM w0.102: C540.2 160.1,110.86 160.1,111.02 159.35,111.77 159.35,112.44 159.29,112.51 UV2.7
MXM_DPA_N1: length 29.9
  TOP w0.102: v2(147.99,90.22) 148.61,90.22 148.91,89.92 148.91,89.15 149,89.07 JMXM1.289
  IN1 w0.117: v2(147.99,90.22) 148.25,89.97 148.37,89.97 148.44,90.03 148.44,94.06 150.6,96.22 150.6,97.49 150.82,97.72 150.82,99.98 150.49,100.31 150.49,103.29 151.16,103.95 152.41,103.95 156.53,108.07 157.97,108.07 158.21,108.31 158.21,108.97 158.13,109.05 157.88,109.05 v2(157.8,108.97)
  BOTTOM w0.102: v2(157.8,108.97) 157.87,108.97 158.13,109.24 158.13,109.4 157.89,109.64 C550.1
MXM_DPA_N1_C: length 2.8
  BOTTOM w0.102: UV2.10 158.09,112.51 158.15,112.44 v4(158.15,111.74) 158.15,110.82 C550.2
MXM_DPA_N2: length 30.8
  TOP w0.102: v2(146.63,90.26) 147.18,90.26 147.5,89.95 JMXM1.295
  IN1 w0.117: v2(146.63,90.26) 146.79,90.11 146.99,90.11 147.08,90.19 147.08,94.29 149.1,96.31 149.1,96.45 149.55,96.91 149.55,102.6 148.82,103.33 148.82,105.56 149.93,106.67 150.99,106.67 152.57,108.25 154.87,108.25 v2(155.02,108.41)
  BOTTOM w0.102: C553.1 156.6,109.02 156.6,108.7 155.99,108.09 155.37,108.09 155.26,108.2 155.26,108.3 155.15,108.41 v2(155.02,108.41)
MXM_DPA_N2_C: length 3.1
  BOTTOM w0.102: UV2.13 156.89,112.51 156.95,112.44 156.95,111.86 v4(156.73,111.63) 156.3,111.2 156.3,110.88 C553.2
MXM_DPA_N3: length 34.1
  TOP w0.102: JMXM1.301 146,89.96 145.6,90.36 v2(144.99,90.36)
  IN1 w0.117: v2(151.87,108.48) 151.81,108.54 151.81,109.01 151.58,109.24 149.34,109.24 147.9,107.8 147.9,106.54 147.04,105.68 147.04,104.54 147.91,103.67 147.91,102.96 148.19,102.68 148.19,96.69 145.55,94.05 145.55,90.43 145.48,90.36 v2(144.99,90.36)
  BOTTOM w0.102: C575.1 154.08,109.4 154.23,109.24 154.56,109.24 154.62,109.18 154.62,109.08 154.61,109.07 154.26,108.72 154.26,108.05 154.04,107.83 v4(153.72,107.83) 151.98,107.83 151.92,107.89 151.92,107.99 152.02,108.1 152.1,108.1 152.26,108.26 152.26,108.46 152.14,108.58 151.97,108.58 v2(151.87,108.48)
MXM_DPA_N3_C: length 3.8
  BOTTOM w0.102: C575.2 154.35,110.82 154.35,111.15 154.68,111.48 v4(155.03,111.48) 155.35,111.48 155.75,111.87 155.75,112.61 155.69,112.67 UV2.16
MXM_DPA_P0: length 29.3
  TOP w0.102: v2(149.43,89.3) 149.39,89.34 149.39,89.64 149.46,89.71 149.93,89.71 150.02,89.62 150.02,89.45 150.23,89.24 150.23,88.88 150.16,88.81 150.07,88.81 150,88.73 JMXM1.285
  IN1 w0.117: v2(160.47,108.98) 160.41,108.92 160.41,108.42 160.18,108.19 159.9,108.19 158.58,106.88 157.02,106.88 152.16,102.01 152.16,95.53 151.9,95.28 151.9,92.63 150.37,91.1 150.37,89.91 149.9,89.44 149.57,89.44 v2(149.43,89.3)
  BOTTOM w0.102: C545.1 160.34,109.3 160.34,109.11 v2(160.47,108.98)
