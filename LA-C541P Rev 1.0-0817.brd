# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_AUXP_C: length 2.8
  BOTTOM w0.102: U629.30 173.24,138.11 173.15,138.01 172.74,138.01 v4(172.51,138.24) 172.22,138.54 171.71,138.54 C591.2
CPU_DP1_N0: length 114.2
  TOP w0.089: 198.78,59.46 198.77,59.46 198.57,59.26 197.97,59.26 CPU1.K37
  TOP w0.102: v2(200.27,67.35) 200.41,67.2 200.89,67.2 201.68,66.42 201.68,65.07 202.76,63.99 v4(202.76,63.34) 202.76,62.51 199.71,59.46 198.78,59.46
  IN1 w0.109: v2(200.27,67.35) 200.15,67.23 199.9,67.23 199.5,67.63 199.5,69.62 200.07,70.19 200.07,73.11 206.96,80 206.96,82.94 209.24,85.22 209.24,91.07 209.96,91.79 209.96,98 207.74,100.22 205.91,100.22 204.7,101.43 198.4,101.43 197.93,101.9 191.49,101.9 190.97,102.42 190.14,102.42 189.69,102.86 189.69,103.84 189.12,104.41 189.12,104.64 188.69,105.07 188.69,105.91 187.84,106.76 187.84,110.42 187.74,110.52 187.74,111.92 187.42,112.23 187.42,113.37 187,113.8 187,114.24 187.42,114.66 187.42,116.59 187.17,116.85 186.57,116.85 186.35,117.06 186.35,118.5 185.68,119.17 185.68,125.94 186.58,126.84 186.58,130.85 186.11,131.32 185.2,131.32 184.76,130.89 177.16,130.89 176.22,129.96 v2(176.22,129.25)
  BOTTOM w0.102: v2(176.22,129.25) 176.38,129.42 176.38,129.72 C597.1
CPU_DP1_N0_C: length 3.8
  BOTTOM w0.102: C597.2 176.45,131.27 176.45,131.54 v4(176.81,131.91) 177.09,132.19 177.41,132.19 177.68,132.46 177.68,133.24 177.59,133.33 U629.12
CPU_DP1_N1: length 117
  TOP w0.089: v2(195.35,60.12) 195.37,60.1 195.37,60.09 CPU1.J34
  IN1 w0.089: 199.9,65.88 199.25,65.23 199.25,62.45 196.3,59.5 195.76,59.5 195.51,59.75 195.51,59.96 v2(195.35,60.12)
  IN1 w0.109: 199.9,65.88 200.14,66.12 200.69,66.12 202.47,67.9 205.35,67.9 207.64,70.19 207.64,82.73 210,85.09 210,89.01 210.68,89.69 210.68,90.16 211.31,90.79 211.31,97.54 209.01,99.84 209.01,100.55 207.56,102 206.53,102 205.7,102.83 202.81,102.83 202.64,102.67 197.16,102.67 196.8,103.03 195.62,103.03 195.58,103.07 191.86,103.07 191.83,103.07 191.44,103.47 190.58,104.33 190.1,104.33 189.76,104.67 189.76,104.9 189.32,105.33 189.32,106.17 188.48,107.01 188.48,107.8 188.47,107.8 188.47,110.87 188.37,110.97 188.37,112.18 188.05,112.49 188.05,117.41 186.98,118.48 186.98,118.94 186.31,119.6 186.31,125.61 187.21,126.5 187.21,131.12 186.07,132.25 184.1,132.25 183.4,131.55 176.29,131.55 174.62,129.88 v2(174.62,129.28)
  BOTTOM w0.102: C626.1 174.68,129.58 174.68,129.34 v2(174.62,129.28)
CPU_DP1_N1_C: length 4.3
  BOTTOM w0.102: C626.2 174.57,131.24 174.57,131.43 174.79,131.66 175.49,131.66 176.48,132.65 176.48,133.19 176.39,133.29 U629.15
CPU_DP1_N2: length 121.5
  TOP w0.089: CPU1.H36 197.11,60.44 197.11,60.34 197.42,60.03 197.89,60.03 198.15,60.28 198.77,60.28 199.9,61.41
  TOP w0.102: v2(200.06,65.41) 200.2,65.27 200.54,65.27 200.75,65.06 200.75,64.58 200.35,64.18 200.35,61.86 199.9,61.41
  IN1 w0.109: v2(200.06,65.41) 200.42,65.04 200.77,65.04 201.24,65.51 201.24,65.84 202.63,67.23 205.69,67.23 208.05,69.59 208.05,79.62 208.59,80.16 208.59,82.14 210.46,84.01 210.46,88.06 211.23,88.83 211.23,90.11 211.75,90.64 211.75,99.56 208.89,102.42 207.4,102.42 206.57,103.25 202.63,103.25 202.47,103.08 197.33,103.08 196.97,103.44 195.79,103.44 195.75,103.49 192,103.49 190.77,104.72 190.77,105.3 188.89,107.18 188.89,111.09 188.8,111.18 188.8,112.43 188.71,112.52 188.71,113.07 188.95,113.31 188.95,113.92 188.68,114.19 188.68,117.41 187.39,118.7 187.39,119.12 186.97,119.55 186.97,124.26 187.8,125.09 187.8,127.34 187.62,127.51 187.62,131.29 186.24,132.67 183.93,132.67 183.26,132 176.15,132 173.87,129.71 173.87,128.9 173.59,128.62 173.14,128.62 172.92,128.85 172.92,128.95 172.85,129.01 172.69,129.01 172.55,129.15 v2(172.55,129.32)
  BOTTOM w0.102: v2(172.55,129.32) 172.73,129.5 172.73,129.68 C629.1
CPU_DP1_N2_C: length 5.3
  BOTTOM w0.102: U629.17 175.59,133.34 175.68,133.25 175.68,132.78 v4(175.37,132.47) 175.17,132.28 173.49,132.28 172.79,131.58 172.79,131.3 C629.2
CPU_DP1_N3: length 124.3
  TOP w0.089: CPU1.J38 198.4,60.09 199.16,60.09 199.23,60.16 199.23,60.45 199.31,60.52 199.6,60.52 199.73,60.66 199.73,60.89 199.84,60.99 199.9,60.99
  TOP w0.102: v2(201.23,63.22) 200.91,63.22 200.8,63.33 200.8,63.55 200.91,63.65 201.59,63.65 201.79,63.44 201.79,62.73 v4(200.51,61.44) 200.06,60.99 199.9,60.99
  IN1 w0.109: v2(170.71,129.4) 170.83,129.52 170.83,129.97 174.77,133.91 183.77,133.91 184.17,133.51 186.64,133.51 189.11,131.04 189.11,127.39 188.71,126.99 188.71,125.07 189.22,124.56 189.22,123.49 188.51,122.78 188.51,118.87 189.53,117.85 189.53,115.14 190.25,114.42 190.25,107.04 191.62,105.68 191.62,105.07 192.32,104.36 196.07,104.36 196.14,104.29 197.32,104.29 197.68,103.93 201.87,103.93 202.06,104.12 208.87,104.12 209.91,103.08 209.91,102.8 209.93,102.79 209.93,102.78 212,100.71 212,100.7 213.2,99.49 213.2,89.02 211.45,87.27 211.45,83.73 209.5,81.78 209.5,79.88 208.9,79.27 208.9,69.24 203.08,63.42 201.43,63.42 v2(201.23,63.22)
  BOTTOM w0.102: v2(170.71,129.4) 170.71,129.44 170.89,129.63 170.89,129.68 C584.1
CPU_DP1_N3_C: length 5.7
  BOTTOM w0.102: U629.20 174.39,133.34 174.48,133.24 174.48,133.11 174.4,133.03 172.53,133.03 v4(171.41,131.91) 170.92,131.42 170.92,131.27 C584.2
CPU_DP1_P0: length 114.1
  TOP w0.089: 198.78,59.67 198.76,59.67 198.75,59.67 198.69,59.67 198.49,59.47 197.73,59.47 197.22,58.96 CPU1.K36
  TOP w0.102: 198.78,59.67 199.62,59.67 202.54,62.6 202.54,63.9 201.46,64.98 v4(201.46,65.43) 201.46,66.33 200.8,66.99 200.49,66.99 v2(200.27,66.76)
  IN1 w0.109: v2(176.8,129.25) 176.44,129.62 176.44,129.87 177.25,130.68 184.85,130.68 185.28,131.11 186.02,131.11 186.36,130.77 186.36,126.93 185.47,126.03 185.47,119.08 186.14,118.41 186.14,116.97 186.48,116.63 187.08,116.63 187.21,116.5 187.21,114.75 186.78,114.33 186.78,113.71 187.21,113.29 187.21,112.14 187.52,111.83 187.52,110.43 187.62,110.33 187.62,106.67 188.47,105.82 188.47,104.98 188.9,104.55 188.9,104.32 189.48,103.75 189.48,102.77 190.05,102.2 190.88,102.2 191.4,101.68 197.84,101.68 198.31,101.21 204.61,101.21 205.82,100.01 207.65,100.01 209.74,97.91 209.74,91.88 209.02,91.16 209.02,85.31 206.74,83.03 206.74,80.09 199.85,73.2 199.85,70.28 199.29,69.71 199.29,67.54 199.81,67.01 200.02,67.01 v2(200.27,66.76)
  BOTTOM w0.102: C593.1 176.6,129.62 176.6,129.46 v2(176.8,129.25)
CPU_DP1_P0_C: length 3.8
  BOTTOM w0.102: C593.2 176.66,131.24 176.66,131.45 177.18,131.97 177.5,131.97 177.89,132.37 v4(177.89,132.63) 177.89,133.27 177.99,133.36 U629.11
CPU_DP1_P1: length 117
  TOP w0.089: v2(196.11,60.14) 196.11,59.9 196.26,59.75 CPU1.J35
  IN1 w0.089: 199.75,66.03 199.74,66.02 199.74,66.01 199.69,65.97 199.69,65.95 199.06,65.32 199.06,62.53 196.22,59.7 195.84,59.7 195.71,59.83 195.71,60.42 195.81,60.52 196.16,60.52 196.23,60.45 196.23,60.27 v2(196.11,60.14)
  IN1 w0.109: v2(175.2,129.28) 174.84,129.65 174.84,129.79 176.38,131.34 183.49,131.34 184.19,132.04 185.98,132.04 186.99,131.03 186.99,126.59 186.1,125.7 186.1,119.51 186.76,118.85 186.76,118.39 187.84,117.32 187.84,112.4 188.15,112.09 188.15,110.88 188.26,110.78 188.26,107.72 188.26,107.71 188.26,107.1 188.26,106.92 189.1,106.08 189.1,105.24 189.54,104.81 189.54,104.58 190.01,104.11 190.49,104.11 191.64,102.95 191.71,102.89 191.76,102.86 191.76,102.86 195.49,102.86 195.53,102.81 196.71,102.81 197.07,102.45 202.73,102.45 202.89,102.62 205.61,102.62 206.44,101.79 207.47,101.79 208.79,100.46 208.79,99.75 211.09,97.45 211.09,90.88 210.47,90.25 210.47,89.78 209.78,89.1 209.78,85.18 207.42,82.81 207.42,70.28 205.26,68.12 202.38,68.12 200.6,66.34 200.05,66.34 199.75,66.03
  BOTTOM w0.102: v2(175.2,129.28) 174.9,129.59 174.9,129.76 C598.1
CPU_DP1_P1_C: length 4.3
  BOTTOM w0.102: C598.2 174.81,131.25 174.81,131.36 174.88,131.44 175.58,131.44 176.7,132.56 176.7,133.22 176.79,133.31 U629.14
CPU_DP1_P2: length 121.5
  TOP w0.089: CPU1.H37 197.76,60.63 197.76,60.76 197.63,60.89 197.43,60.89 197.31,60.78 197.31,60.42 197.5,60.23 197.81,60.23 198.06,60.48 198.69,60.48 199.69,61.49 199.69,61.5 199.73,61.54 199.73,61.55 199.75,61.57
  TOP w0.102: v2(200.06,64.83) 200.28,65.05 200.45,65.05 200.54,64.97 200.54,64.67 200.14,64.27 200.14,61.95 199.75,61.57
  IN1 w0.109: v2(200.06,64.83) 200.86,64.83 201.46,65.42 201.46,65.75 202.72,67.01 205.78,67.01 208.27,69.5 208.27,79.53 208.81,80.07 208.81,82.05 210.67,83.92 210.67,87.97 211.45,88.74 211.45,90.02 211.97,90.55 211.97,99.65 208.98,102.64 207.48,102.64 206.63,103.49 202.57,103.49 202.38,103.3 197.42,103.3 197.06,103.66 195.88,103.66 195.84,103.7 192.09,103.7 190.99,104.81 190.99,105.39 189.11,107.27 189.11,111.18 189.02,111.27 189.02,112.52 188.93,112.61 188.93,112.98 189.17,113.23 189.17,114.01 188.9,114.28 188.9,117.5 187.61,118.79 187.61,119.21 187.18,119.64 187.18,124.17 188.02,125 188.02,127.43 187.84,127.6 187.84,131.38 186.33,132.88 183.84,132.88 183.17,132.21 176.06,132.21 173.65,129.8 173.65,128.99 173.5,128.84 173.23,128.84 173.13,128.94 v2(173.13,129.32)
  BOTTOM w0.102: C628.1 172.95,129.66 172.95,129.5 v2(173.13,129.32)
CPU_DP1_P2_C: length 5.2
  BOTTOM w0.102: C628.2 173,131.22 173,131.49 173.58,132.06 v4(173.99,132.06) 175.26,132.06 175.9,132.69 175.9,133.24 175.99,133.33 U629.16
CPU_DP1_P3: length 124.3
  TOP w0.089: 199.9,60.53 199.88,60.52 199.88,60.52 199.25,59.89 198.67,59.89 198.51,59.72 198.12,59.72 198.1,59.75 CPU1.J37
  TOP w0.102: 199.9,60.53 v4(201.68,62.31) 202.01,62.64 202.01,63.53 201.67,63.88 201.4,63.88 v2(201.22,64.06)
  IN1 w0.109: v2(201.22,64.06) 200.95,64.06 200.83,63.94 200.83,63.75 200.94,63.63 202.99,63.63 208.68,69.33 208.68,79.36 209.29,79.97 209.29,81.87 211.23,83.82 211.23,87.36 212.99,89.11 212.99,99.4 211.78,100.61 211.78,100.62 209.71,102.69 209.71,102.7 209.69,102.71 209.69,102.99 208.78,103.91 202.15,103.91 201.96,103.72 197.59,103.72 197.23,104.07 196.05,104.07 195.98,104.15 192.23,104.15 191.4,104.98 191.4,105.59 190.03,106.95 190.03,114.33 189.31,115.05 189.31,117.76 188.3,118.78 188.3,122.87 189.01,123.58 189.01,124.47 188.5,124.98 188.5,127.08 188.9,127.48 188.9,130.95 186.55,133.3 184.08,133.3 183.68,133.69 174.86,133.69 171.05,129.88 171.05,129.64 v2(171.29,129.4)
  BOTTOM w0.102: C586.1 171.11,129.66 171.11,129.63 171.29,129.44 v2(171.29,129.4)
CPU_DP1_P3_C: length 5.6
  BOTTOM w0.102: C586.2 171.14,131.24 171.14,131.33 172.62,132.81 v4(172.85,132.81) 174.49,132.81 174.7,133.02 174.7,133.28 174.79,133.37 U629.19
CPU_DP2_AUXN: length 86.7
  TOP w0.089: CPU1.E26 190.11,62.11 v2(189.78,61.79)
  IN1 w0.089: v2(189.78,61.79) 189.67,61.79 189.6,61.85 189.6,64 189.28,64.31 189.28,70.72 189.28,70.9 189.29,70.91
  IN1 w0.109: 189.29,70.91 189.29,71.73 190.35,72.79 190.35,75.97 192.38,78 192.38,80.69 197.92,86.22 197.92,87.61 201.72,91.41 201.72,92.45 200.55,93.62 199.81,93.62 199.64,93.79 198.83,93.79 198.76,93.72 196.98,93.72 195.78,94.93 193.56,94.93 193.17,94.53 192.95,94.53 192.93,94.51 191.16,94.51 190.26,95.41 183.43,95.41 182.62,94.6 179.31,94.6 178.5,95.41 177.45,95.41 177.31,95.27 175.99,95.27 175.65,95.61 175.65,96.4 174.5,97.55 172.77,97.55 171.15,95.94 167.52,95.94 166.89,95.3 165.11,95.3 163.2,93.39 162.58,93.39 161.64,92.45 161.07,92.45 160.94,92.58 160.94,92.76 160.82,92.87 160.63,92.87 v2(160.52,92.76)
  BOTTOM w0.102: C548.1 158.48,92.41 158.7,92.41 158.86,92.57 v4(159.34,92.57) 160.34,92.57 v2(160.52,92.76)
CPU_DP2_AUXN_C: length 11.1
  BOTTOM w0.102: U631.29 148.91,94.15 148.73,93.97 148.73,93.01 148.92,92.81 150.95,92.81 151.02,92.88 v4(154.44,92.88) 155.58,92.88 156.38,92.08 156.55,92.08 C548.2
CPU_DP2_AUXP: length 86.7
  TOP w0.089: CPU1.F26 190.11,61.46 v2(189.78,61.14)
  IN1 w0.089: 189.08,70.91 189.08,70.82 189.09,70.81 189.09,64.23 189.4,63.91 189.4,61.52 v2(189.78,61.14)
  IN1 w0.109: v2(160.52,92.17) 160.58,92.23 161.73,92.23 162.67,93.17 163.29,93.17 165.2,95.09 166.98,95.09 167.61,95.72 171.24,95.72 172.86,97.33 174.41,97.33 175.43,96.31 175.43,95.52 175.9,95.05 177.4,95.05 177.54,95.19 178.41,95.19 179.22,94.38 182.71,94.38 183.52,95.19 188.81,95.19 190.17,95.19 191.08,94.29 193.02,94.29 193.04,94.31 193.26,94.31 193.65,94.71 195.69,94.71 196.89,93.51 198.85,93.51 198.92,93.57 199.55,93.57 199.72,93.4 200.46,93.4 201.5,92.36 201.5,91.5 197.7,87.7 197.7,86.31 192.17,80.78 192.17,78.09 190.14,76.06 190.14,72.88 189.08,71.82 189.08,70.91
  BOTTOM w0.102: C552.1 158.45,92.18 158.78,92.18 158.95,92.36 160.33,92.36 v2(160.52,92.17)
CPU_DP2_AUXP_C: length 11.1
  BOTTOM w0.102: U631.30 148.51,92.92 148.83,92.6 151.04,92.6 151.11,92.67 155.49,92.67 v4(155.93,92.23) 156.29,91.87 C552.2
CPU_DP2_N0: length 100
  TOP w0.089: CPU1.H33 195.06,60.73 195.24,60.9 v2(195.39,60.9)
  IN1 w0.089: v2(195.39,60.9) 195.39,60.77 195.32,60.7 194.47,60.7 193.83,60.06 191.93,60.06 191.3,60.69 191.19,60.69 190.88,61 190.88,61.91 191.32,62.34 191.32,63.95 190.81,64.45 190.23,64.45 189.76,64.92 189.76,66.03 189.87,66.13 189.87,68.73 190.67,69.53 190.67,70.91
  IN1 w0.109: 190.67,70.91 190.67,71.22 191.62,72.17 191.62,73.01 191.62,73.1 191.91,73.39 191.91,73.83 191.65,74.1 191.65,76.09 193.81,78.25 193.81,79.29 194.54,80.03 194.54,81.29 199.01,85.76 199.01,87.75 199.9,88.64 202.37,91.1 202.37,92.81 202.07,93.1 202.07,93.35 200.65,94.78 198.93,94.78 198.5,94.35 197.29,94.35 196.03,95.61 193.3,95.61 192.9,95.22 191.41,95.22 190.56,96.06 183.19,96.06 182.43,95.3 179.5,95.3 178.76,96.04 177.77,96.04 176.86,96.96 175.98,96.96 174.76,98.18 172.5,98.18 170.89,96.57 164.04,96.57 163.59,96.12 162.88,96.12 162.15,95.38 160.02,95.38 159.85,95.21 159.85,95.12 v2(159.48,94.75)
  BOTTOM w0.102: C576.1 156.36,98.05 156.91,98.61 157.17,98.61 157.39,98.38 v4(157.99,98.38) 159.12,98.38 160.29,97.22 160.29,96.25 159.85,95.81 159.85,95.12 v2(159.48,94.75)
CPU_DP2_N0_C: length 3
  BOTTOM w0.102: U631.12 153.33,98.7 153.42,98.8 154.24,98.8 154.71,98.32 155.09,98.32 C576.2
CPU_DP2_N1: length 94
  TOP w0.089: 196.26,70.91 196.28,70.89 196.28,70.89 198.49,68.67 198.49,67.08 199.58,65.98 199.58,64.21 199.85,63.94 199.85,62.07 199.18,61.4 198.68,61.4 198.62,61.34 198.62,60.83 198.53,60.74 198.4,60.74 198.31,60.83 CPU1.G38
  TOP w0.102: v2(193.54,72.04) 193.4,72.17 193.13,72.17 192.98,72.01 192.98,71.87 193.29,71.56 193.69,71.56 193.84,71.71 195.46,71.71 196.26,70.91
  IN1 w0.109: v2(158.86,97.16) 159.04,97.34 159.44,97.34 159.57,97.48 159.58,97.48 159.59,97.49 160.13,97.49 160.63,96.98 161.46,96.98 162.35,97.87 164.23,97.87 165.58,99.22 175.45,99.22 176.25,98.42 177.23,98.42 177.55,98.1 180.74,98.1 181.69,97.15 190.99,97.15 191.43,96.71 196.6,96.71 197.2,96.1 200.8,96.1 202.75,94.15 203.52,94.15 203.99,93.68 203.99,91 201.07,88.08 201.07,86.34 196.83,82.1 196.83,80.43 195.34,78.94 195.34,78.3 193.44,76.41 193.44,73.86 192.96,73.38 192.96,72.93 192.82,72.79 192.82,72.61 192.82,72.45 193.07,72.19 193.38,72.19 v2(193.54,72.04)
  BOTTOM w0.102: v2(158.86,97.16) 158.75,97.05 158.55,97.05 C580.1
CPU_DP2_N1_C: length 4.8
  BOTTOM w0.102: U631.15 153.33,97.5 153.38,97.56 154.28,97.56 154.74,97.1 v4(155.92,97.1) 156.27,97.1 156.39,96.97 156.88,96.97 C580.2
CPU_DP2_N2: length 93.6
  TOP w0.089: v2(196.68,61.72) 196.68,61.64 CPU1.F35
  IN1 w0.089: 191.69,70.91 191.69,69.18 191.01,68.49 191.01,67.38 190.65,67.02 190.65,66.1 191.03,65.72 191.03,65.01 191.61,64.43 192.16,64.43 192.55,64.04 192.55,62.82 193.7,61.67 193.82,61.67 194.28,61.21 194.86,61.21 194.92,61.27 196.24,61.27 v2(196.68,61.72)
  IN1 w0.109: 191.69,70.91 191.69,71.65 192.04,72 192.04,72.92 192.33,73.21 192.33,73.68 192.68,74.02 192.68,76.53 194.3,78.16 194.3,78.95 196.19,80.84 196.19,82.36 200.44,86.6 200.44,88.46 203.36,91.37 203.36,93.26 203.22,93.4 202.61,93.4 200.54,95.47 196.88,95.47 196.32,96.03 193.07,96.03 192.68,95.64 191.6,95.64 190.76,96.48 180.87,96.48 180.07,97.28 177.39,97.28 176.87,97.79 175.99,97.79 175.19,98.59 171.05,98.59 169.57,97.11 162.67,97.11 161.4,95.84 159.86,95.84 159.41,95.39 v2(158.79,95.39)
  BOTTOM w0.102: v2(158.79,95.39) 158.59,95.59 158.31,95.59 158.21,95.49 157.13,95.49 156.97,95.64 156.7,95.64 C583.1
CPU_DP2_N2_C: length 3.5
  BOTTOM w0.102: C583.2 155.12,95.63 154.83,95.63 v4(154.51,95.94) 154.32,96.13 154.32,96.45 153.98,96.8 153.56,96.8 153.46,96.7 U631.17
CPU_DP2_N3: length 99
  TOP w0.089: 197.59,68.35 197.59,68.33 197.6,68.32 197.6,66.82 198.91,65.51 198.91,63.79 199.17,63.53 199.17,62.59 198.91,62.33 198.45,62.33 198.42,62.3 198.05,62.3 197.92,62.43 197.68,62.43 197.6,62.39 CPU1.E36
  TOP w0.102: 197.59,68.35 197.59,68.36 195.57,70.38 194.16,70.38 194.11,70.33 193.58,70.33 v2(193.39,70.14)
  IN1 w0.109: v2(158.81,94.12) 158.25,94.12 158.06,94.31 158.06,97.89 158.54,98.37 159.58,98.37 159.88,98.66 161.77,98.66 163.17,100.07 173.51,100.07 173.91,100.47 176,100.47 176.47,100.01 176.47,99.99 177.14,99.32 177.58,99.32 177.81,99.09 181.83,99.09 182.91,98.01 191.35,98.01 191.78,97.58 201.91,97.58 204.84,94.65 204.84,90.65 202.32,88.13 202.32,86.4 197.67,81.75 197.67,80.04 196.66,79.03 196.66,77.8 194.29,75.43 194.29,70.63 193.95,70.29 193.54,70.29 v2(193.39,70.14)
  BOTTOM w0.102: C535.1 158.13,94.01 158.43,94.31 158.62,94.31 v2(158.81,94.12)
CPU_DP2_N3_C: length 5.4
  BOTTOM w0.102: U631.20 153.46,95.5 153.56,95.6 153.7,95.6 154.09,95.21 154.09,95.05 v4(154.55,94.6) 155.07,94.07 156.37,94.07 156.64,94.34 156.85,94.34 C535.2
CPU_DP2_P0: length 100
  TOP w0.089: v2(196.06,60.9) 195.71,60.56 CPU1.H34
  IN1 w0.089: 190.46,70.91 190.46,70.89 190.47,70.88 190.47,70.82 190.48,70.81 190.48,69.61 189.67,68.81 189.67,66.22 189.57,66.11 189.57,64.84 190.15,64.26 190.73,64.26 191.12,63.87 191.12,62.43 190.68,61.99 190.68,60.92 191.11,60.49 191.22,60.49 191.84,59.87 193.92,59.87 194.55,60.51 195.54,60.51 195.94,60.9 v2(196.06,60.9)
  IN1 w0.109: v2(160.07,94.75) 160.07,95.12 160.11,95.17 162.23,95.17 162.97,95.91 163.68,95.91 164.13,96.35 170.98,96.35 172.59,97.96 174.67,97.96 175.89,96.74 176.77,96.74 177.68,95.82 178.67,95.82 179.41,95.09 182.52,95.09 183.28,95.85 190.47,95.85 191.32,95 192.99,95 193.39,95.4 195.94,95.4 197.2,94.14 198.59,94.14 199.02,94.56 200.56,94.56 201.86,93.26 201.86,93.01 202.15,92.72 202.15,91.19 199.81,88.86 198.8,87.84 198.8,85.85 194.33,81.38 194.33,80.12 193.59,79.38 193.59,78.34 191.43,76.18 191.43,74.01 191.7,73.74 191.7,73.48 191.41,73.19 191.41,72.92 191.41,72.26 190.46,71.31 190.46,70.91
  BOTTOM w0.102: v2(160.07,94.75) 160.07,95.72 160.5,96.16 160.5,97.3 v4(160.23,97.57) 159.21,98.6 157.48,98.6 157.26,98.83 156.39,98.83 C574.1
CPU_DP2_P0_C: length 3
  BOTTOM w0.102: C574.2 155.12,98.53 154.8,98.53 154.33,99.01 153.39,99.01 153.3,99.1 U631.11
CPU_DP2_P1: length 94
  TOP w0.089: CPU1.F37 197.7,61.36 198.35,61.36 198.59,61.6 199.09,61.6 199.65,62.16 199.65,63.85 199.38,64.12 199.38,65.9 198.29,66.99 198.29,68.58 196.14,70.74 196.13,70.74 196.11,70.75
  TOP w0.102: v2(193.54,72.62) 193.32,72.4 193.06,72.4 192.76,72.1 192.76,71.78 193.2,71.34 193.78,71.34 193.93,71.5 195.37,71.5 196.11,70.75
  IN1 w0.109: v2(158.84,97.74) 159.02,97.56 159.35,97.56 159.49,97.69 159.49,97.69 159.5,97.71 160.22,97.71 160.72,97.2 161.37,97.2 162.26,98.09 164.14,98.09 165.49,99.44 175.54,99.44 176.34,98.64 177.32,98.64 177.64,98.32 180.83,98.32 181.78,97.37 191.08,97.37 191.52,96.92 196.69,96.92 197.29,96.32 200.89,96.32 202.84,94.37 203.61,94.37 204.21,93.77 204.21,90.91 201.29,87.99 201.29,86.25 197.04,82.01 197.04,80.34 195.55,78.85 195.55,78.21 193.66,76.32 193.66,73.77 193.17,73.29 193.17,72.84 193.03,72.7 193.03,72.54 193.16,72.41 193.33,72.41 v2(193.54,72.62)
  BOTTOM w0.102: v2(158.84,97.74) 158.82,97.74 158.56,97.47 158.45,97.37 158.29,97.37 C578.1
CPU_DP2_P1_C: length 4.9
  BOTTOM w0.102: C578.2 156.88,97.19 156.48,97.19 156.36,97.31 154.83,97.31 154.37,97.77 v4(154.11,97.77) 153.46,97.77 153.33,97.9 U631.14
CPU_DP2_P2: length 93.5
  TOP w0.089: v2(196.03,61.72) 195.71,61.39 CPU1.F34
  IN1 w0.089: v2(196.03,61.72) 196.03,61.88 195.92,62 195.76,62 195.65,61.88 195.65,61.55 195.56,61.47 194.84,61.47 194.78,61.41 194.36,61.41 193.9,61.87 193.78,61.87 192.75,62.9 192.75,64.12 192.24,64.62 191.69,64.62 191.22,65.09 191.22,65.8 190.84,66.18 190.84,66.94 191.2,67.3 191.2,68.41 191.89,69.1 191.89,70.8 191.91,70.82 191.91,70.91
  IN1 w0.109: 191.91,70.91 191.91,71.56 192.26,71.91 192.26,72.83 192.54,73.12 192.54,73.59 192.89,73.93 192.89,76.44 194.52,78.07 194.52,78.86 196.41,80.75 196.41,82.27 200.66,86.51 200.66,88.37 203.57,91.28 203.57,93.35 203.31,93.62 202.7,93.62 200.63,95.69 196.97,95.69 196.41,96.25 192.98,96.25 192.59,95.85 191.69,95.85 190.85,96.69 180.96,96.69 180.16,97.49 177.47,97.49 176.96,98.01 176.08,98.01 175.28,98.81 170.96,98.81 169.48,97.33 162.58,97.33 161.31,96.06 159.77,96.06 159.32,95.61 159.16,95.61 v2(158.79,95.98)
  BOTTOM w0.102: C581.1 156.69,95.86 157.06,95.86 157.22,95.7 v4(157.71,95.7) 158.12,95.7 158.22,95.81 158.63,95.81 v2(158.79,95.98)
CPU_DP2_P2_C: length 3.5
  BOTTOM w0.102: U631.16 153.46,97.1 153.56,97.01 154.07,97.01 154.54,96.54 154.54,96.22 154.92,95.84 155.09,95.84 C581.2
CPU_DP2_P3: length 99
  TOP w0.089: 197.81,68.35 197.81,68.33 197.8,68.32 197.8,66.91 199.11,65.6 199.11,63.88 199.37,63.62 199.37,62.51 198.99,62.13 197.94,62.13 197.86,62.21 197.76,62.21 CPU1.E37
  TOP w0.102: 197.81,68.35 197.81,68.45 195.66,70.59 194.07,70.59 194.02,70.54 193.77,70.54 193.6,70.71 193.6,70.92 v2(193.62,70.94)
  IN1 w0.109: v2(193.62,70.94) 193.14,70.94 193.04,70.84 193.04,70.62 193.15,70.51 193.86,70.51 194.07,70.72 194.07,75.52 196.45,77.89 196.45,79.12 197.46,80.13 197.46,81.84 202.11,86.49 202.11,88.22 204.63,90.74 204.63,94.56 201.82,97.37 191.69,97.37 191.26,97.8 182.82,97.8 181.74,98.87 177.72,98.87 177.49,99.11 177.05,99.11 176.25,99.9 176.25,99.92 175.92,100.26 174,100.26 173.6,99.85 163.26,99.85 161.86,98.45 159.96,98.45 159.67,98.15 158.63,98.15 158.28,97.8 158.28,94.4 158.34,94.34 158.44,94.34 158.55,94.45 158.55,94.68 158.58,94.71 v2(158.81,94.71)
  BOTTOM w0.102: C546.1 158.13,94.82 158.43,94.52 158.62,94.52 v2(158.81,94.71)
CPU_DP2_P3_C: length 5.4
  BOTTOM w0.102: C546.2 156.92,94.56 156.55,94.56 156.39,94.4 156.28,94.29 v4(155.91,94.29) 155.16,94.29 154.31,95.14 154.31,95.3 153.79,95.81 153.56,95.81 153.46,95.9 U631.19
CPU_DP3_AUXN: length 79
  TOP w0.089: CPU1.B27 190.82,64.06 190.46,64.43 190.46,65 190.63,65.16 190.63,66.84 191.25,67.46 v2(191.82,67.46)
  IN1 w0.109: v2(176.87,100.28) 176.87,100.28 177.01,100.28 177.54,99.75 177.91,99.75 178.15,99.5 182,99.5 183.08,98.43 192.35,98.43 192.77,98.01 202.1,98.01 205.27,94.83 205.27,87.58 201.28,83.59 200.3,83.59 199.41,82.7 199.41,80.99 198.03,79.61 197.83,79.61 197.11,78.89 197.11,77.67 195.3,75.86 195.3,73.57 194.77,73.03 194.77,70.47 194.54,70.23 194.54,69.13 192.48,67.08 192.21,67.08 192.07,67.22 192.07,67.38 191.98,67.46 v2(191.82,67.46)
  BOTTOM w0.102: v2(176.87,100.28) 177.01,100.28 177.19,100.1 177.19,99.91 177.06,99.77 v4(177.06,96.82) 177.06,93.24 176.55,92.73 176.41,92.73 C1446.1
CPU_DP3_AUXN_C: length 2.2
  BOTTOM w0.102: C1446.2 174.43,93.01 173.75,93.01 173.53,93.24 U636.29
CPU_DP3_AUXP: length 79.1
  TOP w0.089: CPU1.A27 191.05,64.63 191.05,64.43 190.99,64.37 190.79,64.37 190.66,64.5 190.66,64.91 190.83,65.08 190.83,66.75 191.34,67.26 191.48,67.26 191.56,67.18 191.56,66.95 191.62,66.89 v2(191.81,66.89)
  IN1 w0.109: v2(177.47,100.41) 177.47,100.12 177.63,99.97 177.99,99.97 178.24,99.72 182.09,99.72 183.17,98.64 192.44,98.64 192.86,98.22 202.19,98.22 205.49,94.92 205.49,87.49 201.37,83.37 200.38,83.37 199.62,82.61 199.62,80.9 198.12,79.4 197.92,79.4 197.33,78.8 197.33,77.58 195.52,75.77 195.52,73.48 194.99,72.94 194.99,70.38 194.75,70.14 194.75,69.04 192.57,66.86 191.84,66.86 v2(191.81,66.89)
  BOTTOM w0.102: v2(177.47,100.41) 177.41,100.35 177.41,99.82 177.27,99.68 v4(177.27,94.23) 177.27,93.15 176.64,92.51 C1447.1
CPU_DP3_AUXP_C: length 2.1
  BOTTOM w0.102: U636.30 173.35,92.84 173.4,92.89 173.57,92.89 173.66,92.79 174.54,92.79 C1447.2
CPU_DP3_N0: length 85.5
  TOP w0.089: v2(195.91,67.1) 195.91,66.93 195.78,66.8 195.53,66.8 195.34,66.61 195.34,65.26 195.52,65.08 195.52,65.1 195.65,64.96 195.65,64.25 195.21,63.82 195.21,63.24 195.47,62.97 195.48,62.97 CPU1.D34
  IN1 w0.109: v2(169.69,102.64) 169.32,103 169.32,103.28 169.38,103.35 170.39,103.35 170.59,103.14 173.26,103.14 173.42,103.31 174.83,103.31 175.41,102.72 176.24,102.72 176.48,102.48 180.55,102.48 181.02,102.01 182.72,102.01 183.45,101.28 184.15,101.28 185.11,100.32 196.62,100.32 196.99,99.94 202.86,99.94 204.32,98.49 206.32,98.49 207.03,97.78 207.03,96.71 207.61,96.13 207.61,94.93 207.24,94.55 207.24,93.4 207.75,92.89 207.75,91.65 207.73,91.63 207.73,87.36 205.37,85 205.37,83.85 201.81,80.29 201.81,78.92 197.66,74.76 197.66,72.02 196.75,71.12 196.75,70.09 197.27,69.56 197.27,68.25 196.64,67.61 196.64,66.87 196.46,66.7 195.67,66.7 195.57,66.8 195.57,67.01 195.66,67.1 v2(195.91,67.1)
  BOTTOM w0.102: v2(169.69,102.64) 169.5,102.45 169.5,102.24 C1450.1
CPU_DP3_N0_C: length 4.4
  BOTTOM w0.102: C1450.2 169.56,100.71 169.56,99.06 168.77,98.27 168.77,97.82 168.98,97.62 U636.12
CPU_DP3_N1: length 80.7
  TOP w0.089: v2(195.96,68.41) 196.17,68.62 196.34,68.62 196.53,68.44 196.53,66.91 196.32,66.71 196.32,65.05 196.46,64.92 196.46,64.39 196.55,64.31 196.55,64.09 196.45,63.99 196.18,63.99 CPU1.B34
  IN1 w0.109: v2(195.96,68.41) 196.6,68.41 196.79,68.6 196.79,69.4 196.33,69.86 196.33,72.31 196.79,72.77 196.79,73.46 197.24,73.92 197.24,74.94 200,77.7 200,79.07 204.96,84.02 204.96,85.17 206.82,87.04 206.82,94.72 207.2,95.1 207.2,95.96 206.49,96.67 205.53,96.67 202.71,99.48 196.62,99.48 196.2,99.9 184.94,99.9 183.99,100.86 183.05,100.86 182.41,101.49 180.69,101.49 180.15,102.03 176.3,102.03 176.06,102.27 174.52,102.27 174.41,102.15 171.18,102.15 170.97,102.36 v2(170.97,102.64)
  BOTTOM w0.102: v2(170.97,102.64) 170.79,102.45 170.79,100.38 C1451.1
CPU_DP3_N1_C: length 2.6
  BOTTOM w0.102: C1451.2 170.76,98.84 170.76,98.27 170.39,97.9 170.24,97.9 170.11,97.77 170.11,97.7 170.18,97.63 U636.15
CPU_DP3_N2: length 86.2
  TOP w0.089: CPU1.E33 194.83,62.11 v2(194.51,62.44)
  IN1 w0.109: v2(194.51,62.44) 194.76,62.44 194.82,62.38 194.82,62.03 194.87,61.98 195.01,61.98 195.48,62.45 195.48,64.19 197.15,65.86 197.15,66.57 198.04,67.47 198.04,69.65 199.19,70.8 199.19,73.43 203.5,77.74 203.5,81.09 208.36,85.95 208.36,91.39 209.1,92.13 209.1,95.54 207.66,96.97 207.66,98.04 206.58,99.12 204.58,99.12 203.12,100.58 197.71,100.58 197.34,100.95 185.38,100.95 184.42,101.91 183.71,101.91 182.5,103.12 177.93,103.12 177.48,103.57 176.6,103.57 176.41,103.38 175.65,103.38 175.01,104.02 173.69,104.02 173.07,104.64 172.09,104.64 171.92,104.48 171.92,104.33 172.01,104.24 172.39,104.24 172.55,104.08 172.55,103.89 172.43,103.78 172.32,103.78 v2(172.29,103.8)
  BOTTOM w0.102: C1454.1 172.1,102.18 172.1,102.28 172.19,102.37 172.19,103.3 172.08,103.41 172.08,103.59 v2(172.29,103.8)
CPU_DP3_N2_C: length 4.6
  BOTTOM w0.102: C1454.2 172.03,100.63 172.03,98.99 171.54,98.51 171.37,98.51 171.2,98.34 171.2,98.08 170.88,97.76 170.88,97.72 170.98,97.62 U636.17
CPU_DP3_N3: length 75.3
  TOP w0.089: v2(194.66,67.7) 194.72,67.64 194.72,66.78 194.96,66.55 194.96,65.06 195.03,64.99 195.03,64.45 194.82,64.23 194.82,64.15 CPU1.B33
  IN1 w0.109: v2(194.66,67.7) 194.48,67.51 194.48,67.32 194.66,67.13 194.96,67.13 195.29,67.46 195.29,69.57 195.48,69.77 195.48,72.85 195.93,73.3 195.93,75.6 197.28,76.94 197.5,76.94 198.26,77.71 198.26,78.53 200.27,80.54 200.27,82.58 200.64,82.95 201.54,82.95 205.92,87.33 205.92,95.08 202.36,98.64 193.12,98.64 192.7,99.06 183.47,99.06 182.39,100.13 179.67,100.13 179.54,100.27 178.69,101.11 175.65,101.11 175.45,100.91 174.48,100.91 174.09,101.3 173.52,101.3 173.37,101.15 173.37,101.09 v2(173.6,100.86)
  BOTTOM w0.102: C1452.1 173.5,99.96 173.28,99.96 173.19,100.05 173.19,100.47 173.59,100.86 v2(173.6,100.86)
CPU_DP3_N3_C: length 2.8
  BOTTOM w0.102: U636.20 172.18,97.62 172.13,97.67 172.13,97.72 172.32,97.91 172.6,97.91 v4(172.95,98.27) 173.31,98.62 173.31,98.85 C1452.2
CPU_DP3_P0: length 85.5
  TOP w0.089: v2(195.92,66.31) 195.92,66.47 195.8,66.59 195.61,66.59 195.54,66.52 195.54,65.34 195.7,65.19 195.7,65.17 195.83,65.04 195.83,64.18 195.39,63.74 195.39,63.31 195.6,63.1 195.86,63.1 195.94,63.18 195.94,63.38 195.9,63.42 CPU1.C34
  IN1 w0.109: v2(169.1,102.64) 169.1,103.37 169.3,103.56 170.48,103.56 170.68,103.36 173.17,103.36 173.33,103.53 174.92,103.53 175.5,102.94 176.33,102.94 176.57,102.7 180.64,102.7 181.11,102.23 182.81,102.23 183.54,101.49 184.24,101.49 185.2,100.53 196.71,100.53 197.08,100.16 202.95,100.16 204.41,98.7 206.41,98.7 207.24,97.87 207.24,96.8 207.83,96.22 207.83,94.84 207.45,94.46 207.45,93.49 207.97,92.98 207.97,91.56 207.95,91.54 207.95,87.27 205.59,84.91 205.59,83.76 202.02,80.2 202.02,78.83 197.87,74.67 197.87,71.93 196.97,71.03 196.97,70.17 197.49,69.65 197.49,68.16 196.85,67.52 196.85,66.78 196.54,66.47 196.07,66.47 v2(195.92,66.31)
  BOTTOM w0.102: C1448.1 169.29,102.24 169.29,102.45 v2(169.1,102.64)
CPU_DP3_P0_C: length 4.4
  BOTTOM w0.102: U636.11 168.58,97.71 168.56,97.73 168.56,98.36 169.35,99.15 169.35,100.59 C1448.2
CPU_DP3_P1: length 80.7
  TOP w0.089: v2(195.96,69.04) 196.18,68.83 196.43,68.83 196.73,68.52 196.73,66.83 196.53,66.62 196.53,65.14 196.63,65.03 196.63,64.49 196.74,64.38 196.74,64.16 CPU1.B36
  IN1 w0.109: v2(170.39,102.64) 171.09,101.93 174.5,101.93 174.61,102.05 175.97,102.05 176.21,101.81 180.06,101.81 180.6,101.28 182.32,101.28 182.96,100.64 183.9,100.64 184.85,99.69 196.11,99.69 196.53,99.27 202.62,99.27 205.44,96.45 206.4,96.45 206.98,95.87 206.98,95.19 206.61,94.81 206.61,87.13 204.74,85.26 204.74,84.11 199.79,79.16 199.79,77.79 197.03,75.03 197.03,74 196.57,73.55 196.57,72.86 196.12,72.4 196.12,69.77 196.57,69.31 196.57,68.69 196.51,68.62 196.38,68.62 196.32,68.68 v2(195.96,69.04)
  BOTTOM w0.102: C1453.1 170.57,100.46 170.57,102.45 v2(170.39,102.64)
CPU_DP3_P1_C: length 2.6
  BOTTOM w0.102: C1453.2 170.54,98.83 170.54,98.36 170.3,98.12 170.15,98.12 169.89,97.86 169.89,97.7 169.78,97.58 U636.14
CPU_DP3_P2: length 86.2
  TOP w0.089: CPU1.F33 194.83,61.46 v2(194.51,61.79)
  IN1 w0.109: v2(171.71,103.78) 171.71,104.57 172,104.86 173.16,104.86 173.78,104.24 175.1,104.24 175.74,103.6 176.32,103.6 176.51,103.78 177.57,103.78 178.02,103.33 182.59,103.33 183.8,102.12 184.51,102.12 185.47,101.16 197.43,101.16 197.79,100.79 203.21,100.79 204.67,99.33 206.67,99.33 207.88,98.13 207.88,97.06 209.31,95.63 209.31,92.04 208.58,91.3 208.58,85.86 203.71,81 203.71,77.65 199.41,73.34 199.41,70.71 198.26,69.56 198.26,67.38 197.37,66.49 197.37,65.77 195.69,64.1 195.69,62.36 195.1,61.77 194.53,61.77 v2(194.51,61.79)
  BOTTOM w0.102: v2(171.71,103.78) 171.86,103.63 171.86,103.32 171.98,103.21 171.98,102.46 171.88,102.37 171.88,102.29 171.5,101.9 C1449.1
CPU_DP3_P2_C: length 4.6
  BOTTOM w0.102: C1449.2 171.75,100.73 171.75,100.72 171.81,100.66 171.81,99.08 171.45,98.72 171.28,98.72 170.98,98.43 170.98,98.17 170.67,97.85 170.67,97.75 170.58,97.66 U636.16
CPU_DP3_P3: length 75.3
  TOP w0.089: CPU1.C33 194.61,63.7 194.61,64.32 194.85,64.56 194.85,64.88 194.75,64.98 194.75,66.46 194.36,66.85 v2(194.33,66.85)
  IN1 w0.109: v2(194.33,66.85) 194.4,66.92 195.05,66.92 195.5,67.37 195.5,69.48 195.7,69.68 195.7,72.76 196.15,73.21 196.15,75.51 197.37,76.73 197.59,76.73 198.48,77.62 198.48,78.44 200.49,80.45 200.49,82.49 200.73,82.74 201.63,82.74 206.14,87.24 206.14,95.17 202.45,98.85 193.21,98.85 192.79,99.27 183.55,99.27 182.48,100.35 179.76,100.35 178.78,101.33 175.56,101.33 175.36,101.13 174.57,101.13 174.18,101.52 173.43,101.52 173.16,101.24 173.16,101 v2(173.02,100.86)
  BOTTOM w0.102: C1455.1 172.98,100.32 172.98,100.67 173.02,100.71 v2(173.02,100.86)
CPU_DP3_P3_C: length 2.9
  BOTTOM w0.102: C1455.2 173.05,98.85 173.05,98.67 172.51,98.13 172.23,98.13 171.91,97.81 171.91,97.76 171.78,97.63 U636.19
CPU_EDP_HPD: length 27.7
  TOP w0.089: UH1.BD7 132.17,123.64 132.17,124.02 132.63,124.48 132.63,124.96 v2(132.71,125.05)
  IN2 w0.089: v2(132.71,125.05) 132.71,125.43 133.2,125.92 133.46,125.92 133.74,126.2
  IN2 w0.127: 133.74,126.2 136.08,128.54 136.08,129.2 136.88,129.99 138.19,129.99 139.93,128.25 141.9,128.25 142.6,128.95 143.73,128.95 146.79,132.02 146.79,132.72 147.04,132.96 148.21,132.96 148.89,132.29 150.79,132.29 v2(151.3,132.8)
  BOTTOM w0.102: U630.3 151.21,132.89 v2(151.3,132.8)
CPU_EOPIO_RCOMP: length 10.7
  TOP w0.254: RC227.2 197.02,16.44 197.02,16.97 v1(196.31,17.68) 195.27,18.72 193.79,18.72 192.1,20.41 192.1,23.87 CPU1.BT29
CPU_MSM#: length 164.9
  TOP w0.089: v2(179.82,36.91) 179.5,36.58 CPU1.AW13
  TOP w0.102: v1(50.35,4.39) PR1815.2 v2(51.67,3.77)
  IN1 w0.089: 176.68,19.24 177.14,19.71 178.29,19.71 178.86,20.28 178.86,22.88 178.1,23.64 178.1,24.15 175.37,26.88 175.37,34.44 176.51,35.58 179.02,35.58 179.11,35.67 179.11,36.2 v2(179.82,36.91)
  IN1 w0.109: 176.68,19.24 175.94,18.5 175.94,13.03 171.69,8.78 169.81,8.78 169.49,8.46 159.87,8.46 157.95,10.37 149.77,10.37 149.2,10.94 135.7,10.94 132.27,7.51 130.46,7.51 130.32,7.37 125.22,7.37 v2(123.49,9.1) ; v2(51.67,3.77) 51.67,3.99 52.49,4.82 77.61,4.82 78.59,5.8 104.27,5.8 v2(105.6,7.13)
  BOTTOM w0.102: v2(105.6,7.13) 105.6,7.28 106.25,7.93 122.32,7.93 v2(123.49,9.1)
CPU_MSM#_ED2: length 2
  TOP w0.254: v2(179.82,36) 179.5,35.68 CPU1.AY13
  BOTTOM w0.508: RC230.2 179.9,36.08 v2(179.82,36)
CPU_VIDALERT#: length 29.5
  TOP w0.089: v2(194.08,28.65) 193.76,28.97 CPU1.BH31
  TOP w0.102: v1(198.35,4.53) 198.35,5.48 RC156.2 v2(198.3,7.54)
  IN4 w0.089: v2(194.08,28.65) 194.16,28.57 194.16,27.9 194.82,27.24 196.3,27.24 196.45,27.39 196.75,27.39 197.27,26.87 197.27,24.21 198.28,23.21 198.28,18.39 198.3,18.39 198.59,18.1 198.59,17.89
  IN4 w0.109: 198.59,17.89 198.59,15.59 200.43,13.75 200.43,9.77 198.3,7.64 v2(198.3,7.54)
CPU_XDP_HOOK6: length 8.7
  TOP w0.102: RC144.1 RC6.1 160.34,13.83 160.34,13.08 v1(160.19,12.93) 159.11,11.86 155.88,11.86 155.36,11.35 JXDP1.46
CPU_XDP_PRDY#: length 84.6
  TOP w0.089: v2(189.95,22.68) 190.31,23.04 190.31,23.46 190.24,23.53 190.24,24.75 190.74,25.24 CPU1.BP27
  TOP w0.102: RC314.1 149.67,13.02 149.43,12.78 144.38,12.78 143.66,12.07 143.66,7.66 144.25,7.07 144.5,7.07 145.25,6.32 v2(145.31,6.32) 145.36,6.27 JXDP1.5
  IN1 w0.109: v2(177.72,8.91) 177.72,7.72 173.96,3.97 147.29,3.97 145.31,5.94 v2(145.31,6.32)
  IN3 w0.109: v2(177.72,8.91) 178.1,9.29 179.37,9.29 181.06,10.98 191.15,10.98 192.76,12.59 192.76,15.35 189.58,18.54 189.58,22.3 v2(189.95,22.68)
  BOTTOM w0.089: T189.1 190.46,23.19 v2(189.95,22.68)
CPU_XDP_PREQ#: length 85.9
  TOP w0.089: CPU1.BL30 192.6,26.95 192.6,23.96 192.39,23.75 192.39,20.88 193.51,19.76 194.03,19.76 v2(194.1,19.7) 193.83,19.43 T190.1
  TOP w0.102: RC315.1 RC138.1 147.8,13.3 147.54,13.04 144.25,13.04 143.34,12.13 143.34,7.52 v2(144.34,6.52) 144.34,6.37 144.86,5.84 JXDP1.3
  IN1 w0.109: v2(178.41,8.08) 174.06,3.73 146.84,3.73 144.34,6.23 v2(144.34,6.52)
  IN3 w0.109: v2(194.1,19.7) 193.47,19.07 193.47,12.3 191.44,10.27 181.35,10.27 179.16,8.08 v2(178.41,8.08)
CPU_XDP_PRS: length 7.9
  TOP w0.102: RC127.1 164.44,13.66 164.44,12.95 164.09,12.6 163.82,12.6 v1(163.33,12.11) 162.51,11.3 161.35,11.3 161.15,11.1 159.03,11.1 158.86,10.94 JXDP1.60
CPU_XDP_TCLK: length 68.8
  TOP w0.089: v2(191.34,22.04) 190.95,22.43 190.95,23.77 191.23,24.05 191.23,24.44 CPU1.BR28
  TOP w0.102: RC306.2 163.3,13.91 RC143.1 v2(163.43,13.15) ; JXDP1.57 158.36,6.82 159.26,7.71 v2(162.14,7.71)
  IN3 w0.089: v2(191.34,22.04) 193.05,20.34 194.03,20.34 194.67,19.71 194.67,17.89
  IN3 w0.127: 194.67,17.89 194.1,17.32 194.1,12.04 191.7,9.64 181.61,9.64 179.37,7.4 163.76,7.4 163.45,7.71 v2(162.14,7.71)
  BOTTOM w0.089: v2(191.34,22.04) 190.91,22.48 190.91,23.41 191.66,24.16 T181.1
  BOTTOM w0.102: v2(163.43,13.15) 163.28,13.15 160.08,9.95 160.08,9 161.37,7.71 v2(162.14,7.71)
CPU_XDP_TDI: length 79
  TOP w0.089: CPU1.BL32 194.04,27.09 v2(193.43,27.09)
  TOP w0.102: RC308.1 168.29,9.16 161.22,9.16 v2(160.69,9.7) 159.77,8.78 158.36,8.78 157.86,9.28 JXDP1.56
  IN4 w0.089: v2(193.43,27.09) 193.95,27.09 194.16,26.88 195.88,26.88 196.26,26.5 196.26,24.72 197.61,23.37 197.61,17.89
  IN4 w0.109: v2(196.7,7.86) 197.14,8.29 197.48,8.29 198.86,9.67 198.86,13.16 197.61,14.42 197.61,17.89
  BOTTOM w0.089: v2(193.43,27.09) 192.8,26.46 T185.1
  BOTTOM w0.102: v2(196.7,7.86) 196.61,7.76 196.61,7.11 196.61,7.1 196.61,6.69 196.52,6.6 195.79,6.6 195.47,6.92 195.47,8.01 195.15,8.33 180.05,8.33 179.05,7.34 170.6,7.34 168.77,9.16 161.22,9.16 v2(160.69,9.7)
CPU_XDP_TDO: length 74.9
  TOP w0.089: CPU1.BT28 191.34,23.91 v2(191.34,22.68)
  TOP w0.102: RC135.2 RC309.1 166.51,7.58 165.77,8.32 158.54,8.32 158.37,8.15 v2(157.39,8.15) 156.86,8.68 JXDP1.52
  IN4 w0.089: 193.13,17.89 193.13,19.24 192.18,20.19 192.18,21.84 v2(191.34,22.68)
  IN4 w0.109: 193.13,17.89 193.13,10.74 194.21,9.66 194.49,9.66 195.11,9.04 195.11,8.61 194.84,8.33 v2(194.84,7.28)
  BOTTOM w0.089: v2(191.34,22.68) 191.35,22.68 191.35,22.91 192.05,23.61 192.69,23.61 T184.1
  BOTTOM w0.102: v2(194.84,7.28) 194.24,7.88 180.24,7.88 179.24,6.88 166.48,6.88 166.41,6.81 161.08,6.81 159.49,8.4 157.65,8.4 v2(157.39,8.15)
CPU_XDP_TMS: length 65.2
  TOP w0.089: 191.75,21.28 191.75,23.9 191.86,24.01 191.86,25.05 CPU1.BP28
  TOP w0.102: v2(191.34,20.77) 191.75,21.18 191.75,21.28 ; JXDP1.58 158.36,9.37 158.73,9.01 159.08,9.01 160.95,10.87 161.25,10.87 161.44,11.07 162.92,11.07 v2(164.05,12.2) 164.67,11.58 164.67,11.02 166.14,9.55 RC307.1
  IN4 w0.089: v2(191.34,20.77) 192.83,19.29 192.83,17.89
  IN4 w0.109: v2(193.97,8.91) 193.97,9.55 192.83,10.69 192.83,17.89
  BOTTOM w0.102: T180.1 191.34,20.21 v2(191.34,20.77) ; v2(193.97,8.91) 193.62,8.56 179.95,8.56 178.96,7.56 170.69,7.56 168.87,9.39 166.85,9.39 v2(164.05,12.2)
CPU_XDP_TRST#: length 249.3
  TOP w0.089: UH1.AY5 132.53,121.45 v2(132.53,121.17) ; CPU1.BP30 193.39,25.09 193.39,24.84 193.56,24.67 193.56,23.93 193.65,23.84 193.65,22.38 193.61,22.34 193.61,21.74 T179.1 193.27,21.41 v2(193.1,21.41)
  TOP w0.102: JXDP1.54 157.36,8.81 v2(157.39,8.78) 157.84,8.78 158.07,8.55 168.12,8.55 168.52,8.15 170.1,8.15 170.48,8.53 170.48,10.25 170.48,10.44 173.9,13.86 173.9,17.35 171.1,20.15 166.97,20.15 158.11,29.01 158.11,45.84 159.74,47.46 159.74,59.51 160.32,60.09 160.32,67.82 164.5,72 164.5,74.23 v2(163.91,74.83) ; v2(197.01,7.28) 196.62,7.28 v1(196.07,7.83)
  IN3 w0.089: 138.2,99.28 138.2,102.01 137.79,102.41 137.79,105.84 137.39,106.24 137.39,111.7 139.89,114.2 139.89,115.06 139.76,115.19 139.4,115.19 139.33,115.11 139.33,115.11 139.22,115.01 137.6,115.01 137.39,115.21 137.39,117.94 135.04,120.29 135.04,120.81 134.33,121.52 134.33,121.77 133.98,122.13 133.49,122.13 v2(132.53,121.17)
  IN3 w0.127: 138.2,99.28 138.2,97.8 137.8,97.4 137.8,97.06 138.04,96.81 138.04,96.81 138.28,96.57 138.28,89.02 143.95,83.35 143.95,75.61 145.44,74.12 150.26,74.12 152.87,71.52 164.25,71.52 165.02,72.28 165.02,75.29 164.43,75.88 163.73,75.88 163.48,75.62 163.48,75.26 v2(163.91,74.83)
  IN4 w0.089: v2(193.1,21.41) 192.83,21.14 192.83,20.02 193.58,19.27 193.58,17.89
  IN4 w0.109: 193.58,17.89 193.58,11.05 195.41,9.22 195.41,6.95 195.79,6.57 196.31,6.57 v2(197.01,7.28)
  BOTTOM w0.089: v2(132.53,121.17) 132.86,121.5 133.33,121.5 133.46,121.37 134.59,121.37 RC328.2
  BOTTOM w0.102: v2(197.01,7.28) 197.01,6.74 196.64,6.37 195.5,6.37 195.24,6.62 195.24,7.92 195.06,8.11 180.14,8.11 179.14,7.11 166.29,7.11 166.22,7.04 161.17,7.04 159.59,8.63 157.54,8.63 v2(157.39,8.78)
CPU_ZVM#: length 159.4
  TOP w0.089: v2(179.82,38.74) 179.5,38.41 CPU1.AT13
  TOP w0.102: PR501.2 v2(77.06,3.89) v1(78.27,3.89) ; v2(60.24,3.77) PR1801.2
  IN1 w0.089: 176.68,19.64 176.92,19.88 178.21,19.88 178.68,20.35 178.68,22.81 177.92,23.57 177.92,24.08 175.19,26.81 175.19,35.85 175.81,36.47 178.86,36.47 179.18,36.79 179.18,38.09 v2(179.82,38.74)
  IN1 w0.109: 176.68,19.64 175.68,18.64 175.68,13.11 171.59,9.01 162.42,9.01 162.1,8.69 159.96,8.69 158.05,10.61 149.87,10.61 149.3,11.18 135.6,11.18 132.18,7.76 130.38,7.76 130.26,7.64 125.68,7.64 v2(124.18,9.14) ; v2(105.6,6.24) 104.41,5.05 83.6,5.05 82.45,3.89 v2(77.06,3.89) 77.06,3.91 76.43,4.53 61,4.53 v2(60.24,3.77)
  BOTTOM w0.102: v2(124.18,9.14) 122.75,7.7 106.4,7.7 106.15,7.45 106.15,6.79 v2(105.6,6.24)
CPU_ZVM#_ED2: length 2.1
  TOP w0.254: CPU1.AU13 179.5,37.5 v2(179.82,37.82)
  BOTTOM w0.508: RC230.1 180.17,37.48 v2(179.82,37.82)
CS_1.2V: length 3.4
  BOTTOM w0.102: v1(61.42,21.64) 60.24,20.45 PR201.2
  BOTTOM w0.203: PR201.2 59.78,20.07 PU200.13
CS_CTR: length 4.9
  TOP w0.089: 112.37,111.78 113.26,111.78 113.53,112.05 UH1.AA44
  TOP w0.102: RH342.2 110.48,110.57 110.66,110.57 v1(110.76,110.68) 110.99,110.68 112.09,111.78 112.37,111.78
CSCOMP_3PH_A: length 40.6
  TOP w0.203: PU1100.8 256.55,49.07 256.26,49.35 256.26,50.31 PC1122.2
  TOP w0.254: PC1122.2 PC1121.1 256.21,51.28 PR1138.1 257.07,51.65 256.9,51.82 256.9,52.35 257.09,52.53 PR1140.1 255.76,54.37 v1(255.76,54.73) 255.76,55.21 254.42,56.55 249.99,56.55 249.25,57.29 248.59,57.29 244.11,61.78 244.11,65.08 241.83,67.36 v2(241.83,68.35)
  IN2 w0.254: v2(241.83,68.35) 241.24,67.75 240.17,67.75 239.78,68.14 235.67,68.14 234.99,67.46 234.99,67.1 v2(235.41,66.68)
  BOTTOM w0.254: v2(235.41,66.68) 234.79,66.68 234.14,67.33 PH1101.1
CSCOMP_3PH_B: length 74.1
  TOP w0.203: PR1139.2 255.92,39.07 255.92,40.87 256.15,41.1 PU1100.31
  TOP w0.254: PR1141.1 v2(255.35,36.66) ; PR1141.1 PR1139.2 ; PR1141.1 PC1124.1 PC1125.1 ; PH1102.1 v2(221.26,18.18)
  BOTTOM w0.254: v2(255.35,36.66) 252.17,36.66 247.83,32.32 247.83,14.35 242.53,9.05 237.24,9.05 235.94,7.75 227.48,7.75 224.69,10.54 224.69,17.78 223.72,18.75 v1(222.81,18.75) 221.97,18.75 221.4,18.18 v2(221.26,18.18)
CSN_1PH: length 130.3
  TOP w0.203: PU1100.48 260.73,45.97 261.11,46.35 262.11,46.35 PC1104.1
  TOP w0.254: v2(263.96,47.01) 263.73,47.01 263.17,46.45 PC1102.1 PC1104.1
  IN3 w0.254: v2(225.96,70.12) 225.96,70.17 226.55,70.76 230.48,70.76 231.37,69.87 234.02,69.87 235.26,71.1 239.21,71.1 239.25,71.14 244.83,71.14 245.85,70.12 245.85,61.87 251.54,56.18 258.39,56.18 259.31,55.27 259.31,51.58 262.36,48.53 262.36,46.25 263.76,44.85 265.03,44.85 265.28,45.11 265.28,45.68 v2(263.96,47.01) 263.5,47.01 263.26,47.26 263.26,48.89 260.2,51.94 260.2,55.47 258.7,56.98 252.06,56.98 246.81,62.23 246.81,70.89 245.23,72.47 237.33,72.47 237.02,72.79 235.92,72.79 232.84,75.88 225.6,75.88 224.9,75.17 224.9,73.33 v2(224.68,73.11)
  BOTTOM w0.254: PH1100.1 v2(225.96,70.12) ; v2(224.68,73.11) 224.59,73.02 PL1700.3
CSON_1: length 11.8
  TOP w0.254: PC713.1 PR762.1 274.17,26.17 PC710.2 274.43,25.91 v1(274.43,23.26) 274.43,22.77 272.06,20.4 272.06,18.56 271.87,18.37 PR723.3
CSOP_1: length 11.8
  TOP w0.254: PR723.2 272.69,18.37 272.46,18.61 272.46,20.23 274.86,22.64 v1(274.86,25.03) 274.86,25.91 PC710.1 275.12,26.17 PR761.1 PC712.2
CSP1_3PH_A: length 6.9
  TOP w0.203: PU1100.11 255.35,48.74 254.34,49.74 254.34,50.17 PC1131.2
  TOP w0.254: v2(253.14,49.36) 253.45,49.36 253.83,49.74 253.83,50.05 PC1131.2
  BOTTOM w0.254: v2(253.14,49.36) 251.88,49.36 v1(251.88,49.36) 251.88,50.14 252.1,50.36 PR1154.2
CSP1_3PH_B: length 7.6
  TOP w0.203: v2(254.22,40.98) 254.28,40.98 254.95,41.64 PU1100.28
  TOP w0.254: v2(254.22,40.98) 254.22,40.97 254.22,39.62 v1(253.91,39.31) 253.75,39.15 252.87,39.15 252.5,39.52 PC1132.2
  BOTTOM w0.254: v2(254.22,40.98) 253.64,40.98 253.07,41.55 PR1160.1
CSP2_3PH_A: length 6.3
  TOP w0.203: v2(253.64,48.85) 253.83,49.04 254.57,49.04 254.95,48.67 PU1100.12
  TOP w0.254: PC1133.2 253.26,50.25 252.63,49.61 252.63,49.11 252.88,48.85 v2(253.64,48.85)
  BOTTOM w0.254: v2(253.64,48.85) v1(253.64,49.42) 253.64,49.74 253.26,50.12 PC1133.2
CSP2_3PH_B: length 7
  TOP w0.203: PU1100.27 254.55,41.75 254.41,41.61 253.81,41.61 253.56,41.37 v1(253.56,41.05) 253.33,40.81 v2(253.33,40.6)
  TOP w0.254: v2(253.33,40.6) 253.58,40.6 253.83,40.34 253.83,39.86 253.5,39.53 253.03,39.53 252.13,40.42 PC1134.2
  BOTTOM w0.254: PC1134.2 253.26,40.53 v2(253.33,40.6)
CSP3_3PH_A: length 7.6
  TOP w0.203: PU1100.13 254.55,48.52 254.41,48.66 254.28,48.66 v2(253.96,48.34)
  TOP w0.254: v2(253.96,48.34) 253.39,48.34 253.33,48.41 252.76,48.41 252.12,49.04 v1(252.12,49.34) 252.12,49.87 252.37,50.12 PC1135.2 PR1169.2
  BOTTOM w0.254: PR1163.2 254.15,48.53 v2(253.96,48.34)
CSP3_3PH_B: length 10.8
  TOP w0.203: PU1100.26 253.53,42.77 252.95,42.18 252.77,42.18 PC1136.2
  TOP w0.254: PR1170.2 251.24,42.44 PC1136.2 252.69,40.99 252.69,40.5 253.17,40.01 v2(253.3,40.01)
  BOTTOM w0.102: v1(249.2,39.21) 249.69,38.71 251.88,38.71 252.13,38.96 PR1164.1
  BOTTOM w0.254: PR1164.1 252.81,39.52 v2(253.3,40.01)
CSREF_3PH_A: length 109.3
  TOP w0.203: PU1100.10 255.75,48.87 255.42,49.2 v2(255.42,49.42)
  TOP w0.254: PC1131.1 PC1133.1 PC1135.1 252.31,51.28 252.15,51.44 252.15,51.69 v2(251.58,52.26) ; PC1131.1 254.15,52.18 v1(254.13,52.2) 253.99,52.34 v2(253.52,52.34) ; PC1131.1 254.47,51.28 254.72,51.03 254.72,49.99 255.3,49.42 v2(255.42,49.42)
  IN3 w0.254: v2(253.52,52.34) 253.42,52.24 253.42,51.5 251.57,49.66 251.57,46.63 248.01,43.07 242.68,43.07 238.99,46.76 235.83,46.76 234.05,44.98 231.49,44.98 230.74,45.73 230.74,46.49 v2(230.66,46.57) ; v2(230.66,56.73) 230.66,56.1 231.24,55.52 232.27,55.52 234.16,57.41 239.77,57.41 242.17,55.01 242.17,50.82 243.44,49.55 247.5,49.55 250.23,52.28 251.57,52.28 v2(251.58,52.26)
  IN4 w0.254: v2(251.58,52.26) 250.97,51.65 250.1,51.65 249.82,51.36 249.82,51.36 249.68,51.22 244.92,51.22 242.63,53.51 242.63,55.69 241.89,56.43 241.89,64.76 240.33,66.32 240.33,66.97 238.81,68.49 232.61,68.49 231.18,67.06 v2(231.18,66.95)
  BOTTOM w0.254: v2(255.42,49.42) 255.92,48.93 PC1123.2 ; v2(231.18,66.95) 230.23,66.95 PR1204.2 ; PR1210.2 230.4,46.82 v2(230.66,46.57) ; PR1205.2 230.4,56.98 v2(230.66,56.73)
CSREF_3PH_B: length 124.8
  TOP w0.203: PU1100.29 255.35,41.35 v2(254.98,40.98)
  TOP w0.254: v2(250.53,41.55) PC1136.1 PC1134.1 ; PR1405.2 v2(224.69,27.39) ; v2(254.98,40.98) 254.65,40.65 254.65,39.38 254.03,38.76 251.87,38.76 251.22,39.4 PC1132.1 ; v2(250.53,39.52) PC1132.1 ; PC1132.1 PC1134.1 ; v2(250.53,40.53) PC1134.1 ; v2(224.82,19.96) 224.45,19.6 224.45,17.66 PR1404.2 ; PR1410.2 v2(224.69,37.55)
  IN3 w0.254: v2(250.53,41.55) 250.64,41.66 251.36,41.66 252.22,40.8 252.22,38.84 250.93,37.55 246.99,37.55 243.05,33.61 243.05,28.6 235.4,20.95 233.82,20.95 232.45,19.58 231.19,19.58 229.79,20.98 225.15,20.98 224.9,20.73 224.9,20.04 v2(224.82,19.96) ; v2(224.69,37.55) 224.81,37.67 224.81,38.1 225.35,38.65 229.86,38.65 231.23,37.27 234.59,37.27 235.88,35.99 241.12,35.99 245.08,39.95 249.51,39.95 249.58,40.03 250.15,40.03 250.53,39.64 v2(250.53,39.52) ; v2(250.53,40.53) 250.64,40.64 251.03,40.64 251.29,40.39 251.29,39.46 250.52,38.69 246.24,38.69 241.76,34.21 238.2,34.21 232.56,28.57 225.37,28.57 224.83,28.02 224.83,27.53 v2(224.69,27.39)
  BOTTOM w0.254: PC1126.1 256.95,41.42 256.44,40.91 255.04,40.91 v2(254.98,40.98)
CSS_GC: length 480.8
  TOP w0.102: v2(25.56,41.46) 24.93,40.84 PR773.1
  TOP w0.254: v2(336.91,51.14) 337.16,51.39 337.16,51.58 337.05,51.69 PU1001.10
  IN1 w0.109: v2(308.77,49.4) 306.91,47.54 304.08,47.54 303.84,47.3 292.13,47.3 289.62,49.8 286.87,49.8 286.45,50.23 286.44,50.23 286.35,50.32 284.62,50.32 283.56,51.38 278.3,51.38 263.64,66.03 263.64,67.83 257.84,73.63 257.84,75.66 256.12,77.38 256.12,84.47 253.41,87.18 253.41,90.49 252.26,91.64 252.26,94.04 248.25,98.05 v2(246.8,98.05)
  IN2 w0.127: v2(35.79,32.47) 35.79,32.5 35.66,32.37 33.98,32.37 30.66,35.68 27.94,35.68 25.15,38.48 25.15,41.05 v2(25.56,41.46) 25.15,41.87 25.15,46.43 24.06,47.52 24.06,51.31 26.73,53.98 26.73,60.49 29.52,63.29 54.69,63.29 56.91,61.07 77.46,61.07 84.78,68.39 84.78,78.25 92.22,85.69 92.22,97.07 96.74,101.59 97.59,102.45 97.97,102.45 98.39,102.45 99.29,103.35 99.29,104.75 100.18,105.63 100.18,108.97 104.32,113.11 104.9,113.11 107.12,115.33 107.12,117.67 106.76,118.03 106.51,118.03 106.08,118.45 106.08,119.05 106.28,119.25 106.28,119.72 106.04,119.95 106.04,122.01 105.64,122.42 105.64,127.81 110.27,132.43 110.27,134.15 111.2,135.08 115.5,135.08 116.26,134.32 116.61,134.32 117.57,135.28 119.87,135.28 121.54,136.95 125.36,136.95 129.59,141.18 134.79,141.18 136.63,143.02 143.28,143.02 143.58,143.33 149.04,143.33 149.29,143.09 150.28,143.09 151.17,142.2 157.21,142.2 158.16,141.24 162.18,141.24 164.64,138.78 167.63,138.78 168.25,139.4 170.97,139.4 171.45,138.93 174.23,138.93 174.43,138.72 178.21,138.72 181.29,138.72 181.49,138.92 187.02,138.92 187.72,138.22 191.47,138.22 191.48,138.21 191.53,138.26 196.02,138.26 196.28,138.51 199.81,138.51 200.36,139.06 206.51,139.06 207.37,138.2 224.9,138.2 231.91,131.18 231.91,123.86 232.74,123.03 232.74,118.39 234.34,116.79 234.34,110.71 238.37,106.69 238.88,106.69 241.59,103.97 241.59,103.26 v2(246.8,98.05)
  BOTTOM w0.102: v2(308.77,49.4) 308.77,49.52 309.94,50.69 315.32,50.69 319.92,46.1 321.87,46.1 323.38,47.61 324.55,47.61 v1(325.97,49.02) 328.08,51.14 v2(336.91,51.14)
  BOTTOM w0.254: PR703.2 36.34,33.01 v2(35.79,32.47)
CSS_GC_1: length 28.5
  TOP w0.254: PR771.1 v2(25.98,39.64)
  BOTTOM w0.102: PQ702.2 46.72,32.63 v1(47.01,32.92)
  BOTTOM w0.254: v2(25.98,39.64) 25.98,38.32 29.43,34.87 35.74,34.87 36.24,34.37 PC700.2 36.29,34.27 PR703.1 38.15,33.01 38.87,33.74 39.84,33.74 40.35,33.23 40.35,32.85 40.56,32.63 PQ700.2 41.31,33.56 41.62,33.87 43.65,33.87 43.97,33.55 45.07,33.55 45.31,33.31 PQ702.2
CSSN_1: length 24.1
  IN1 w0.254: v2(42.57,30.12) 42.57,30.04 41.84,29.31 40.3,29.31 40.06,29.07 40.06,28.42 38.66,27.02 37.76,27.02 36.39,25.65 35.68,25.65 34.77,26.56 v2(34.01,26.56)
  BOTTOM w0.254: PQ706.3 30.2,28.95 v1(30.2,27.5) 30.2,26.56 30.92,25.85 33.33,25.85 34.03,26.55 v2(34.01,26.56) 34.03,26.58 PR712.1 ; PQ702.3 42.74,32.63 42.38,32.28 42.38,31.08 PR704.1 42.51,30.55 42.51,30.18 v2(42.57,30.12) 42.57,29.62 PR711.1
CSSN_2: length 338.7
  TOP w0.203: PC704.1 277.28,36.4 276.18,35.3 274.6,35.3 274.28,34.97 PU700.1
  TOP w0.254: PC704.1 278.08,36.42 PC703.2 278.4,36.56 279.14,36.56 279.68,36.01 279.68,35.85 v2(279.62,35.78)
  IN1 w0.254: v2(181.72,6.38) 182.2,6.86 182.68,6.86 183.29,6.26 220.05,6.26 221.11,7.32 242.41,7.32 v2(243.87,5.86) ; v2(143.09,6.33) 143.09,6.57 142.77,6.89 142.28,6.89 141.84,6.45 141.84,5.84 140.19,4.19 126.29,4.19 111.42,4.19 107.27,8.35 77.71,8.35 75.05,5.68 49.89,5.68 48.93,6.64 48.93,12.47 47.08,14.32 47.08,17.89 45.33,19.64 43.01,19.64 40.75,21.9 40.75,25.46 42.48,27.19 42.48,27.87 v2(42.57,27.96)
  IN2 w0.254: v2(143.09,6.33) 143.07,6.31 143.07,6.26 143.5,5.83 181.17,5.83 v2(181.72,6.38)
  IN4 w0.254: v2(279.62,35.78) 278.48,34.64 278.48,33.98 277.3,32.8 277.3,30.43 281.53,26.2 289.29,26.2 294.5,20.99 295.29,20.99 300.44,15.85 300.44,8.8 300.04,8.4 300.04,7.07 298.7,5.74 291.28,5.74 290.03,4.48 269.45,4.48 268.37,5.56 244.18,5.56 v2(243.87,5.86)
  BOTTOM w0.254: v2(42.57,27.96) 42.52,28.01 42.52,28.4 PR711.2
