# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG19: length 59.7
  TOP w0.089: CPU1.BP22 v2(186.4,25.06)
  TOP w0.102: v2(149.38,8.82) 149.38,10.3 JXDP1.22 149.36,12.12 v1(149.33,12.15)
  IN4 w0.089: v2(186.4,25.06) 184.88,23.54 184.88,18.13 185.11,17.89
  IN4 w0.109: v2(149.38,8.82) 148.97,8.42 148.97,6.01 149.28,5.7 178.34,5.7 179.93,7.28 179.93,7.29 180.1,7.47 180.1,8.18 183.52,11.6 184.21,11.6 185.23,12.62 185.23,17.78 185.11,17.89
CHARGER_SMBCLK: length 212.5
  TOP w0.102: PR729.1 268.15,31.99 268.04,31.99 v2(267.85,31.8)
  IN1 w0.109: v2(196.56,115.02) 196.16,115.02 195.67,115.51 195.67,115.63 195.71,115.7 195.76,115.75 195.76,116.23 195.37,116.62 195.37,117.23 196.78,118.64 197.96,118.64 198.58,119.26 206.73,119.26 209.05,116.94 209.93,116.94 210.67,116.19 211.15,116.19 213.77,113.57 216.12,113.57 216.45,113.9 219.52,113.9 221.43,115.81 222.26,115.81 223.63,114.44 223.63,113.74 224.62,112.75 226.69,112.75 227.23,112.75 229.16,110.83 229.7,110.83 230.32,110.21 231.74,108.79 231.74,108.1 232.27,107.58 232.98,107.58 232.98,107.55 233.88,106.65 238.82,106.65 240.22,105.26 241.07,105.26 v2(241.28,105.05)
  IN3 w0.127: v2(196.56,115.02) 196.55,115.03 196.31,115.03 195.72,115.62 195.72,116.33 195.62,116.43 195.62,117.42 196.65,118.45 197.7,118.45 199.37,120.12 199.37,120.33 198.85,120.85 v2(198.85,121.07)
  BOTTOM w0.102: v2(198.85,121.07) 199.16,121.37 RP5.5 ; v2(196.56,115.02) 196.15,114.61 U51.B50 ; v2(241.28,105.05) 241.47,105.24 241.69,105.24 241.93,105 241.93,102.94 242.43,102.43 242.43,101.86 245.95,98.34 245.95,98 246.4,97.55 246.4,97.22 246.74,96.88 246.74,95.34 245.34,93.94 245.21,93.94 244.49,93.21 244.49,91.14 243.77,90.41 243.77,90.23 243.77,88.83 242.88,87.94 242.88,82.62 246.38,79.11 246.38,78.04 247.51,76.91 247.51,69.51 247.4,69.4 247.4,67.78 246.77,67.15 246.77,60.87 250.74,56.89 256.82,56.89 257.26,57.32 259.73,57.32 263.31,53.74 263.31,51.7 273.73,41.28 280.31,41.28 281.87,39.72 290.08,39.72 291.15,38.65 291.15,28.53 290.72,28.1 270.61,28.1 270.55,28.17 267.27,31.45 267.27,31.77 267.5,32.01 267.64,32.01 v2(267.85,31.8)
CHARGER_SMBDAT: length 216.9
  TOP w0.102: PR727.1 268.17,32.21 268.02,32.21 v2(267.85,32.38)
  IN1 w0.109: v2(194.51,116.46) 194.55,116.42 194.55,116.16 195.27,115.72 195.31,115.72 195.46,115.75 195.52,115.85 195.52,116.13 195.13,116.52 195.13,117.33 196.68,118.87 197.87,118.87 198.49,119.5 206.83,119.5 209.15,117.18 210.02,117.18 210.77,116.43 211.24,116.43 213.87,113.81 216.02,113.81 216.35,114.14 219.42,114.14 221.33,116.05 222.36,116.05 223.87,114.54 223.87,113.84 224.72,112.99 226.59,112.99 227.33,112.99 229.26,111.06 229.8,111.06 230.42,110.44 230.42,110.44 231.98,108.89 231.98,108.2 232.37,107.81 233.08,107.81 233.21,107.68 233.21,107.65 233.98,106.89 238.92,106.89 240.31,105.49 241.14,105.49 v2(241.28,105.63)
  IN3 w0.127: v2(198.21,121) 198.32,121 198.68,120.65 198.69,120.65 199.11,120.23 197.59,118.7 196.55,118.7 195.37,117.52 195.37,116.33 195.47,116.23 195.47,115.91 195.29,115.73 194.58,115.73 194.51,115.8 v2(194.51,116.46)
  BOTTOM w0.102: RP5.6 198.66,121.56 198.19,121.09 198.21,121.07 v2(198.21,121) ; v2(241.28,105.63) 241.44,105.47 241.79,105.47 242.16,105.1 242.16,103.03 242.66,102.52 242.66,101.96 246.18,98.44 246.18,98.1 246.63,97.65 246.63,97.31 246.97,96.97 246.97,95.24 245.44,93.71 245.31,93.71 244.72,93.12 244.72,91.04 244,90.32 244,88.74 243.11,87.85 243.11,82.71 246.61,79.2 246.61,78.13 247.74,77 247.74,69.42 247.63,69.31 247.63,67.69 246.99,67.05 246.99,60.96 250.84,57.12 256.73,57.12 257.16,57.55 259.82,57.55 263.54,53.83 263.54,51.8 273.83,41.51 280.41,41.51 281.97,39.95 290.17,39.95 291.37,38.75 291.37,28.44 290.81,27.88 270.52,27.88 267.04,31.36 267.04,31.87 267.41,32.24 267.71,32.24 v2(267.85,32.38) ; v2(194.51,116.46) 194.06,116.01 v1(194.06,115.58) 194.06,115.18 194.7,114.54 194.75,114.54 194.93,114.36 U51.A47
CHG: length 12.5
  TOP w0.254: PU700.17 272.68,30.06 v2(272.43,29.82)
  IN1 w0.254: v2(275.42,19.71) 275.42,22.66 273.42,24.66 273.42,29.28 272.89,29.82 v2(272.43,29.82)
  vias: v1(275.73,17.89)
CLK_DDC2_DOCK: length 120
  TOP w0.102: R5.2 167.01,77.29 v4(168.15,77.29) 171.3,77.29 172.19,78.18 173.73,78.18 173.91,78.35 173.91,78.79 173.75,78.95 JMXM1.188 173.75,80.44 173.87,80.56 173.87,80.82 174.19,81.15 174.83,81.15 175.11,81.43 175.11,81.44 175.48,81.81 175.49,81.81 175.65,81.97 177.68,81.97 179.01,83.3 179.01,85 178.83,85.17 v2(178.84,85.17)
  IN3 w0.127: v2(168.43,151.41) 168.26,151.58 168.26,152.94 169.14,153.82 171.87,153.82 172.78,152.91 172.78,149.8 172.95,149.63 172.95,147.15 173.91,146.2 173.91,145.56 175.05,144.42 176.36,144.42 177,145.06 178.05,145.06 178.56,145.56 180.28,145.56 184.34,145.56 184.76,145.14 184.76,143.32 184.38,142.94 184.38,135.34 189.08,130.64 189.08,128.27 187.83,127.02 187.02,127.02 185.4,125.4 185.4,120.28 187.75,117.93 187.75,114.51 187.92,114.34 187.92,113.88 187.92,113.88 187.92,113.86 187.82,113.77 187.82,113.04 187.98,112.89 187.98,108.48 185.68,106.18 185.68,104.9 185.17,104.4 185.17,103 184.45,102.28 184.45,99.25 181.57,96.37 181.57,94.22 181.8,93.98 181.8,92.16 181.45,91.8 180.58,91.8 179.49,90.72 179.49,86.74 178.97,86.21 178.97,85.3 v2(178.84,85.17)
  BOTTOM w0.102: JDOCK1.48 169.25,154.95 169.25,154.95 169.12,154.82 169.12,154.07 168.25,153.21 168.25,151.59 v2(168.43,151.41)
CLK_KBD: length 85.5
  TOP w0.102: v2(193.78,109.3) 194.15,109.67 194.58,109.67 194.83,109.93 195.56,110.65 195.56,110.65 195.68,110.78 195.68,113.04 194.35,114.37 194.35,114.76 193.54,115.58 193.54,116.64 192.83,117.36 v1(192.59,117.36) 192.24,117.36 191.44,118.16 RP6.6
  IN3 w0.127: v2(193.78,109.3) 193.34,109.75 193.34,110.13 193.15,110.32 192.41,110.32 191.58,111.15 191.33,111.15 190.78,111.69 190.78,114.72 189.51,115.99 189.51,119.03 187.61,120.94 187.61,124.06 188.5,124.95 188.5,125.47 189.22,126.19 192,126.19 192.32,126.51 192.32,130.7 192.96,131.34 193.93,131.34 194.54,131.95 194.54,132.57 193.49,133.62 192.02,133.62 189.34,136.31 189.34,143.66 189.46,143.78 189.46,145.75 188.38,146.83 188.38,153.12 186.1,155.4 184.26,155.4 183.18,154.33 180.06,154.33 177.91,156.48 177.91,157.44 v2(177.71,157.64)
  BOTTOM w0.102: v2(193.78,109.3) 194.16,109.68 194.54,109.68 194.72,109.86 U51.A38 ; JDOCK1.78 177.75,156.95 177.88,157.09 177.88,157.47 v2(177.71,157.64)
CLK_MSE: length 77.3
  TOP w0.102: v2(194.38,110.15) 194.86,110.64 195.2,110.98 195.2,112.84 194.54,113.49 194.14,113.49 194.01,113.36 193.48,113.36 193.22,113.62 193.22,114.98 v1(192.78,115.43) 192.51,115.69 192.51,116.57 192.21,116.87 192.04,116.87 190.94,117.97 RP6.5
  IN3 w0.127: v2(194.38,110.15) 194.4,110.13 194.58,110.13 194.8,109.92 194.8,108.99 194.56,108.75 191.99,108.75 190.27,110.47 190.27,114.51 189,115.78 189,118.82 187.1,120.73 187.1,124.27 187.93,125.1 187.93,125.63 189.01,126.7 190.9,126.7 191.24,127.04 191.24,131.06 190.65,131.66 190.22,131.66 189.84,132.04 189.84,133.94 187.43,136.35 187.43,144.04 184.76,146.71 182.65,146.71 181.5,147.85 177.1,147.85 176.38,147.13 176.38,145.96 176.17,145.75 175.54,145.75 v2(175.4,145.89)
  BOTTOM w0.102: U51.A39 194.71,110.36 194.5,110.15 v2(194.38,110.15) ; v2(175.4,145.89) 175.57,145.71 176.22,145.71 176.39,145.88 176.39,146.82 176.25,146.95 JDOCK1.71
CLK_PCI_5048: length 158.4
  TOP w0.102: v2(186.08,108.45) 186.08,107.46 186.14,107.4 R795.1
  IN3 w0.127: v2(214.99,111.13) 215.07,111.13 215.63,111.7 215.63,113.02 214.6,114.06 214.6,114.92 214.87,115.2 214.87,119.19 215.03,119.35 215.03,122.79 214.67,123.15 214.67,126.06 214.14,126.58 214.14,130.09 214.61,130.56 214.61,132.82 v2(213.28,134.16)
  IN4 w0.109: v2(130.37,133.18) 130.5,133.18 132.04,131.64 133.26,131.64 133.95,130.94 141.45,130.94 142.58,132.08 143.87,132.08 146.29,134.5 148.58,134.5 150.19,136.1 151.74,136.1 153.8,138.16 155.01,138.16 155.99,139.14 160.07,139.14 161.97,137.23 164.53,137.23 164.6,137.17 168.01,137.17 168.17,137.33 170.47,137.33 170.63,137.17 172.83,137.17 174.35,135.66 175.37,135.66 176.51,134.51 180.64,134.51 180.9,134.25 184.46,134.25 185.49,135.28 186.35,135.28 187,135.92 187,136.25 188.49,137.74 191.61,137.74 191.85,137.97 193.68,137.97 195.99,135.66 211.51,135.66 213.01,134.16 v2(213.28,134.16) ; v2(186.08,108.45) 186.27,108.65 194.32,108.65 194.32,108.65 194.59,108.65 196.3,110.36 197.82,110.36 198.68,111.21 198.96,111.21 200.14,112.39 200.14,112.55 200.81,113.21 203.22,113.21 203.27,113.17 206,113.17 206.1,113.27 208.8,113.27 209.28,112.79 209.7,112.79 210.44,113.53 212.22,113.53 212.99,112.76 214.87,112.76 214.95,112.84 215.36,112.84 215.65,112.56 215.65,111.79 v2(214.99,111.13)
  BOTTOM w0.102: RH96.2 130.8,132.48 130.8,133.34 131.3,133.84 CH42.1 130.9,133.93 130.51,133.53 130.51,133.32 v2(130.37,133.18) ; U46.A28 185.51,109.01 v2(186.08,108.45)
CLK_PCI_DOCK: length 82.4
  TOP w0.102: v2(188.83,145.69) v1(189.59,146.45) 189.59,147.12 189.17,147.53 R756.1
  IN4 w0.109: v2(188.83,145.69) 188.83,143.66 187.75,142.58 187.75,139.66 185.4,137.31 185.4,136.92 183.78,135.3 182.84,135.3 182.48,135.66 176.75,135.66 175.77,136.64 174.83,136.64 173.31,138.15 171.04,138.15 170.88,138.31 167.22,138.31 167.06,138.15 165.96,138.15 165.58,138.53 162.06,138.53 159.34,141.25 155.31,141.25 152.12,138.07 150.98,138.07 150.03,137.12 145.72,137.12 144.08,135.48 144.08,135.17 141.37,132.46 140.52,132.46 139.98,131.92 135.72,131.92 134.91,132.73 132.33,132.73 131.38,133.69 129.94,133.69 v2(129.55,133.3)
  BOTTOM w0.102: v2(129.55,133.3) 129.55,133.46 129.71,133.61 129.71,133.67 129.96,133.93 CH51.1 130.03,133.59 129.96,133.52 129.96,132.74 129.67,132.45 RH98.2 ; JDOCK1.121 189.75,146.61 v2(188.83,145.69)
CLK_PCI_LPDEBUG: length 93
  IN4 w0.109: v2(128.89,133.31) 128.89,133.27 129.56,132.61 130.38,132.61 131.84,131.15 133.05,131.15 133.75,130.45 141.65,130.45 142.03,130.83 143.9,130.83 146.93,133.86 148.72,133.86 150.29,135.43 152.1,135.43 154.33,137.67 155.21,137.67 156.19,138.65 159.86,138.65 161.77,136.74 164.33,136.74 165.34,135.73 167.92,135.73 168.02,135.83 171.22,135.83 171.76,136.36 172.2,136.36 172.53,136.04 173.08,136.04 175.11,134.01 179.56,134.01 179.8,133.76 185.73,133.76 187.53,135.56 190.07,135.56 191.22,136.71 194.25,136.71 195.79,135.17 203.47,135.17 v2(203.88,134.76)
  BOTTOM w0.102: R3757.1 v1(205.69,132.35) 205.02,131.68 JLPDE1.10 204.26,131.68 204.13,131.81 204.13,134.5 v2(203.88,134.76) ; v2(128.89,133.31) 128.89,133.45 129.14,133.7 CH50.1 128.63,133.93 128.33,133.62 128.33,132.71 RH99.2
CLK_PCI_MEC: length 164.3
  IN3 w0.127: v2(221.9,103.8) 221.9,105.84 221.51,106.23 221.51,108.84 221.39,108.96 221.39,110.76 221.3,110.84 221.3,113.44 220.58,114.16 220.58,127.4 218.86,129.12 218.86,130.51 217.24,132.13 v2(217.24,133.5)
  IN4 w0.109: v2(221.9,103.8) 221.78,103.92 219.5,103.92 219,103.41 217.45,103.41 217.43,103.39 217.09,103.39 217.07,103.41 213.15,103.41 212.83,103.09 212.28,103.09 211.6,102.41 209.3,102.41 207.02,100.13 198.24,100.13 196.61,101.75 196.51,101.75 v2(195.95,102.32) ; v2(131.2,133.17) 132.13,132.24 134.71,132.24 135.52,131.43 140.19,131.43 140.73,131.97 141.78,131.97 142.38,132.57 143.67,132.57 146.6,135.49 148.49,135.49 149.6,136.61 151.43,136.61 154.45,139.63 156.77,139.63 157.26,140.11 159.79,140.11 162.18,137.72 164.74,137.72 164.8,137.66 167.81,137.66 167.96,137.82 170.68,137.82 170.83,137.66 173.11,137.66 174.63,136.15 175.57,136.15 176.63,135.08 180.76,135.08 181.11,134.74 184.26,134.74 185.4,135.88 186.27,135.88 186.51,136.12 186.51,136.45 188.29,138.23 191.41,138.23 191.64,138.46 193.88,138.46 196.14,136.2 212.27,136.2 213.08,135.39 215.34,135.39 217.24,133.5 v2(217.24,133.5)
  BOTTOM w0.102: U51.A29 198.25,105.28 197.95,104.98 197.95,104.71 197.53,104.29 197.53,104.15 R885.1 196.65,103.27 196.13,103.27 195.94,103.08 195.94,102.32 v2(195.95,102.32) ; RH97.2 132.19,132.98 CH49.1 131.43,133.17 v2(131.2,133.17)
CLK_PCIE_N1: length 239
  TOP w0.102: v2(131.97,106.52) 132.16,106.71 UH1.L7 ; JIO1.61 313.98,33.3 313.77,33.51 313.77,40.25 312.69,41.33 312.69,45.97 312.92,46.2 v2(312.92,47.3)
  IN4 w0.109: v2(131.97,106.52) 132.15,106.52 132.26,106.41 132.26,106.09 132.47,105.88 135.17,105.88 136.21,106.93 140.78,106.93 141.02,107.17 141.89,107.17 142.35,107.63 143.15,107.63 143.17,107.65 145.28,107.65 146.49,106.45 147.56,106.45 148.1,105.91 149.92,105.91 150,105.83 156.38,105.83 156.59,106.04 160.66,106.04 163.15,103.55 164.16,103.55 164.46,103.26 165.23,103.26 166.01,102.48 166.01,102.1 167.72,100.39 171.09,100.39 172.36,99.12 175.33,99.12 176,98.45 176.9,98.45 177.35,98 179.31,98 180.84,96.47 181.32,96.47 181.6,96.75 182.23,96.75 182.86,97.38 191.22,97.38 191.66,96.95 191.69,96.98 191.77,96.98 191.78,96.98 192.38,96.98 193.34,96.03 195.07,96.03 195.16,95.93 195.87,95.93 196.6,95.2 200.56,95.2 201.5,96.15 203.18,96.15 205.06,94.27 207.38,94.27 208.19,95.07 209.66,95.07 209.91,95.33 212.83,95.33 213.21,95.71 219.18,95.71 220.02,96.56 221.41,96.56 222.45,97.59 225.38,97.59 225.61,97.37 227.7,97.37 230.78,94.29 231.84,94.29 234.81,91.32 236.85,91.32 237.73,90.44 239.35,90.44 239.97,89.82 239.97,89.57 240.77,88.76 241.65,88.76 242.44,89.56 247.47,89.56 251.44,85.58 251.81,85.21 253,85.21 253.51,84.7 253.51,82.8 254.14,82.16 254.14,78.91 256.49,76.56 256.49,74.62 256.49,73.83 256.56,73.77 256.56,73.76 257.33,72.99 257.33,71.04 258.82,69.55 258.82,68.6 260.05,67.36 260.05,64.27 266.59,57.74 268.05,57.74 276.74,49.05 281.22,49.05 282.78,47.49 286.15,47.49 286.99,46.65 290.04,46.65 290.73,45.96 307.36,45.96 309.27,47.87 312.62,47.87 312.92,47.58 v2(312.92,47.3)
CLK_PCIE_N2: length 253.7
  TOP w0.102: UH1.D3 134.11,103.81 134.21,103.91 134.21,104.12 134.04,104.29 v2(133.84,104.29)
  IN4 w0.109: v2(133.84,104.29) 134.03,104.48 135.05,104.48 136.82,106.26 141.15,106.26 141.43,106.54 145.5,106.54 146.22,105.82 147.24,105.82 147.78,105.28 149.67,105.28 149.74,105.2 156.64,105.2 156.85,105.41 160.35,105.41 164.04,101.72 165.31,101.72 167.28,99.75 170.76,99.75 172.19,98.32 175.24,98.32 175.78,97.78 176.67,97.78 177.14,97.3 179.12,97.3 180.58,95.84 181.58,95.84 181.86,96.12 182.49,96.12 183.12,96.75 190.96,96.75 192.41,95.3 195.61,95.3 196.77,94.14 198.49,94.14 198.93,94.57 200.72,94.57 201,94.29 203.89,94.29 204.56,93.62 207.62,93.62 208.45,94.44 209.02,94.44 209.47,94 215.37,94 216.32,94.95 219.31,94.95 220.29,95.93 226.79,95.93 228.34,94.38 228.34,94.32 230.21,92.45 232.79,92.45 234.55,90.69 236.56,90.69 238.04,89.21 239.38,89.21 240.5,88.09 241.92,88.09 242.53,88.7 245.24,88.7 249.5,84.45 252.56,84.45 252.87,84.13 252.87,82.48 253.45,81.91 253.45,78.72 255.8,76.37 255.8,73.52 256.67,72.64 256.67,72.64 256.7,72.61 256.7,70.77 258.19,69.29 258.19,68.34 259.42,67.1 259.42,64.01 266.48,56.95 267.95,56.95 276.48,48.42 280.96,48.42 282.52,46.86 285.76,46.86 286.6,46.02 289.78,46.02 290.47,45.33 307.62,45.33 309.46,47.18 312.12,47.18 312.63,46.67 318.12,46.67 319.01,45.78 320.64,45.78 321.99,47.12 323.38,47.12 324.08,47.82 329.23,47.82 330.94,46.11 330.94,43.78 331.54,43.19 331.54,42.17 330.89,41.52 329.39,41.52 328.79,40.93 328.79,37.98 329.7,37.07 329.7,36.79 v2(330.11,36.38)
  BOTTOM w0.102: v2(330.11,36.38) 329.95,36.55 329.43,36.55 329.31,36.43 JNGFF2.45
CLK_PCIE_N3: length 175.8
  TOP w0.089: UH1.E5 v2(132.81,104.83)
  TOP w0.102: U31.45 254.66,110.94 254.72,110.89 254.95,110.89 v2(255.16,111.1)
  IN1 w0.089: v2(132.81,104.83) 133.15,105.17 133.15,105.32 133.21,105.37 133.21,105.64 133.38,105.81 134.96,105.81 136.63,107.48 136.63,109.07 138.96,111.4 141.75,111.4 141.76,111.41
  IN1 w0.109: v2(255.16,111.1) 254.38,111.1 254.04,110.76 254.04,109.29 251.54,106.79 249.72,106.79 249.09,107.42 245.5,107.42 243.08,109.84 235.91,109.84 229.96,115.78 229.08,115.78 228.77,116.09 228.77,116.57 226.64,118.7 226.64,127.09 212.07,141.66 206.7,141.66 206.04,142.32 198.02,142.32 197.69,142.66 192.21,142.66 191.91,142.96 178.21,142.96 177.23,143.94 175.47,143.94 174.64,143.11 169.18,143.11 168.04,141.97 166.2,141.97 163.85,139.62 163.85,132.39 164.13,132.11 164.13,129.19 164.55,128.77 164.55,125.75 163.81,125.01 163.64,125.01 160.44,121.81 159.58,121.81 159.54,121.77 159.51,121.77 158.85,121.11 157.53,121.11 156.27,119.85 156.27,118.59 155.16,117.48 154.09,117.48 153.95,117.34 151.72,117.34 151.55,117.51 148.66,117.51 148.2,117.05 146.47,117.05 143.3,113.88 143.3,111.91 142.81,111.41 141.76,111.41
CLK_PCIE_N4: length 109.6
  TOP w0.102: UH1.D5 132.69,103.92 131.72,103.92 131.52,104.13 131.16,104.13 v2(130.85,103.82) ; JIO2.110 53.14,49.35 53.28,49.21 53.37,49.21 53.97,49.8 54.33,49.8 v2(54.58,50.05)
  IN3 w0.109: 130.28,103.42 130.3,103.42 130.31,103.41 130.38,103.41 130.39,103.4 131.03,103.4 131.45,103.81 131.45,104.03 131.24,104.23 130.8,104.23 130.66,104.1 130.66,104.01 v2(130.85,103.82)
  IN3 w0.127: v2(54.58,50.05) 54.82,49.81 55.44,49.81 56.33,50.69 60.8,50.69 61.5,51.39 61.5,52.73 96.24,87.47 97.58,87.47 104.17,94.06 106.77,94.06 107.17,94.46 107.85,95.14 112.02,95.14 112.21,95.33 114.76,95.33 114.82,95.27 124.25,95.27 124.57,95.59 124.57,98.7 126.92,101.05 126.92,102.38 127.55,103.02 129.39,103.02 129.79,103.42 130.28,103.42
CLK_PCIE_N5: length 162.8
  TOP w0.102: UH1.D8 131.92,103.27 v2(131.93,103.27)
  IN3 w0.109: v2(131.93,103.27) 132.12,103.08 132.12,102.96 131.74,102.58 131.02,102.58 131.01,102.59 130.82,102.59 130.77,102.54 130.75,102.54 130.74,102.53
  IN3 w0.127: 130.74,102.53 130.62,102.41 129.08,102.41 128.63,101.96 128.63,95.58 127.36,94.32 115.04,94.32 114.27,93.55 113.39,93.55 113,93.94 110.8,93.94 110.28,93.42 108.69,93.42 108.33,93.78 107.45,93.78 107.04,93.37 106.43,93.37 105,91.94 103.01,91.94 60.18,49.11 56.43,49.11 55.21,47.88 55.21,46.04 55.03,45.86 54.4,45.86 54.36,45.9 52.17,45.9 48.76,49.31 46.97,51.1 37.8,51.1 36.1,49.4 36.1,45.88 35.2,44.98 35.2,36.72 35.57,36.35 35.57,35.09 37.11,33.55 37.11,31.85 36.17,30.91 36.17,25.62 35.06,24.51 35.06,22.7 37.14,20.62 37.14,20.19 v2(36.99,20.04)
  BOTTOM w0.102: v2(36.99,20.04) 37.15,19.87 37.15,19.63 37.05,19.53 JSATA2.15
CLK_PCIE_N6: length 124
  TOP w0.102: v2(131.01,108.6) 131.39,108.98 UH1.R8
  IN1 w0.109: v2(211.51,116.76) 211.35,116.92 210.94,116.92 210.17,117.69 209.34,117.69 207.41,119.62 207.41,122.18 204.17,125.43 204.17,126.98 197.63,133.52 196.37,133.52 193.16,136.74 191.62,136.74 191.02,137.33 188.02,137.33 187.42,136.74 174.04,136.74 173.44,137.33 169.04,137.33 168.48,136.77 168.48,134.61 169.08,134.01 169.08,132.13 168.73,131.78 168.73,126.73 169.36,126.11 169.36,126.08 169.42,126.02 169.42,123.3 167.03,120.91 167.03,120.18 165.43,118.58 165.43,114.29 164.38,113.24 164.38,112.73 163.67,112.03 163.67,107.71 163.4,107.44 162.85,107.44 v2(162.71,107.3)
  IN4 w0.109: v2(131.01,108.6) 131.21,108.4 131.21,108.22 131.46,107.97 134.71,107.97 136.59,109.85 142.31,109.85 142.73,109.43 145.46,109.43 146.56,108.33 148.59,108.33 149.17,107.75 150.13,107.75 150.77,107.12 155.26,107.12 155.64,107.5 162.5,107.5 v2(162.71,107.3)
  BOTTOM w0.102: JNGFF1.41 211.94,116.7 211.88,116.76 v2(211.51,116.76)
CLK_PCIE_N7: length 213.4
  TOP w0.102: UH1.U5 v2(132.58,109.43)
  IN1 w0.089: v2(132.58,109.43) 132.42,109.6 132.42,109.77 132.12,110.07 127.94,110.07 127.87,110 118.53,110 116.75,108.23 115.4,108.23 115.21,108.03 112.39,108.03 112.38,108.04 112.37,108.04
  IN1 w0.109: v2(15.25,6.08) 15.05,6.28 14.55,6.28 12.93,7.89 11.92,7.89 10.9,6.88 5.57,6.88 3.92,8.53 3.92,9.8 4.42,10.31 4.42,14.5 5.73,15.81 5.73,34.89 10.63,39.78 10.63,40.18 19.72,49.27 19.72,50.05 24.11,54.44 24.11,64.03 26.74,66.66 56.58,66.66 58.77,64.47 63.54,64.47 91.37,92.3 91.37,93.44 99.97,102.04 99.97,104.57 104.09,108.69 110.01,108.69 110.65,108.04 112.37,108.04
  BOTTOM w0.102: v2(15.25,6.08) 15.43,6.26 15.92,6.26 16.04,6.13 16.04,5.1 15.96,5.02 15.87,5.02 15.75,4.9 JNGFF3.53
CLK_PCIE_P1: length 239
  TOP w0.102: JIO1.59 314.5,33.8 314.39,33.69 314.39,33.57 314.34,33.52 314.07,33.52 313.99,33.6 313.99,40.34 312.91,41.42 312.91,45.88 313.14,46.11 313.14,46.93 v2(313.51,47.3) ; UH1.L5 132.92,106.73 v2(132.7,106.52)
  IN4 w0.109: v2(132.7,106.52) 132.48,106.29 132.48,106.18 132.56,106.1 135.08,106.1 136.12,107.14 140.69,107.14 140.93,107.38 141.8,107.38 142.26,107.85 143.06,107.85 143.08,107.87 145.37,107.87 146.58,106.66 147.65,106.66 148.19,106.13 150.01,106.13 150.09,106.05 156.29,106.05 156.5,106.26 160.75,106.26 163.24,103.77 164.25,103.77 164.55,103.47 165.32,103.47 166.22,102.57 166.22,102.19 167.81,100.6 171.17,100.6 172.44,99.33 175.42,99.33 176.09,98.66 176.99,98.66 177.44,98.22 179.4,98.22 180.93,96.69 181.23,96.69 181.51,96.97 182.14,96.97 182.77,97.6 191.31,97.6 191.71,97.2 192.47,97.2 193.43,96.25 194.98,96.25 195.16,96.25 195.25,96.15 195.96,96.15 196.69,95.42 200.47,95.42 201.41,96.36 203.27,96.36 205.15,94.48 207.29,94.48 208.1,95.29 209.57,95.29 209.83,95.55 212.74,95.55 213.12,95.93 219.09,95.93 219.93,96.78 221.32,96.78 222.36,97.81 225.47,97.81 225.7,97.58 227.79,97.58 230.86,94.51 231.93,94.51 234.9,91.54 236.94,91.54 237.82,90.66 239.43,90.66 240.18,89.91 240.18,89.66 240.86,88.98 241.56,88.98 242.35,89.77 247.55,89.77 251.53,85.8 251.9,85.43 253.09,85.43 253.72,84.79 253.72,82.89 254.36,82.25 254.36,79 256.71,76.65 256.71,74.53 256.71,73.92 256.77,73.85 257.55,73.08 257.55,71.13 259.03,69.64 259.03,68.69 260.27,67.45 260.27,64.36 266.68,57.96 268.14,57.96 276.83,49.27 281.31,49.27 282.87,47.71 286.24,47.71 287.08,46.87 290.13,46.87 290.82,46.17 307.27,46.17 309.18,48.09 312.71,48.09 313.13,47.68 v2(313.51,47.3)
CLK_PCIE_P2: length 253.7
  TOP w0.102: v2(133.46,104.7) 134.06,104.7 UH1.F2
  IN4 w0.109: v2(133.46,104.7) 134.96,104.7 136.73,106.47 141.06,106.47 141.34,106.75 145.59,106.75 146.31,106.03 147.33,106.03 147.87,105.49 149.76,105.49 149.83,105.42 156.55,105.42 156.76,105.63 160.44,105.63 164.13,101.94 165.4,101.94 167.36,99.97 170.85,99.97 172.28,98.53 175.33,98.53 175.87,97.99 176.76,97.99 177.23,97.52 179.21,97.52 180.67,96.06 181.49,96.06 181.77,96.34 182.4,96.34 183.03,96.97 191.05,96.97 192.5,95.52 195.7,95.52 196.86,94.35 198.4,94.35 198.84,94.79 200.81,94.79 201.09,94.51 203.98,94.51 204.65,93.83 207.53,93.83 208.36,94.66 209.11,94.66 209.56,94.22 215.28,94.22 216.23,95.17 219.22,95.17 220.2,96.15 226.88,96.15 228.55,94.47 228.55,94.41 230.3,92.67 232.88,92.67 234.64,90.91 236.65,90.91 238.13,89.43 239.47,89.43 240.59,88.31 241.83,88.31 242.44,88.92 245.33,88.92 249.59,84.67 252.65,84.67 253.09,84.22 253.09,82.57 253.66,82 253.66,78.81 256.01,76.46 256.01,73.61 256.92,72.7 256.92,70.86 258.4,69.38 258.4,68.43 259.64,67.19 259.64,64.1 266.57,57.17 268.04,57.17 276.57,48.64 281.05,48.64 282.61,47.08 285.85,47.08 286.69,46.24 289.87,46.24 290.56,45.54 307.53,45.54 309.37,47.39 312.21,47.39 312.72,46.88 318.21,46.88 319.1,45.99 320.55,45.99 321.9,47.34 323.29,47.34 323.99,48.04 329.32,48.04 331.16,46.2 331.16,43.87 331.75,43.28 331.75,42.08 330.98,41.31 329.48,41.31 329.01,40.84 329.01,38.07 v2(330.11,36.97)
  BOTTOM w0.102: JNGFF2.47 329.26,36.93 329.43,36.76 329.89,36.76 330.06,36.93 330.07,36.93 v2(330.11,36.97)
CLK_PCIE_P3: length 175.7
  TOP w0.089: UH1.G4 v2(133.77,105.18)
  TOP w0.102: U31.44 254.62,110.54 254.77,110.69 255.03,110.69 v2(255.2,110.52)
  IN1 w0.089: 141.76,111.2 141.74,111.2 141.73,111.21 139.04,111.21 136.83,108.99 136.83,107.4 135.04,105.62 133.46,105.62 133.4,105.56 133.4,105.29 133.35,105.23 133.35,105.09 133.38,105.06 133.64,105.06 v2(133.77,105.18)
  IN1 w0.109: 141.76,111.2 142.9,111.2 143.51,111.82 143.51,113.79 146.56,116.83 148.29,116.83 148.75,117.29 151.46,117.29 151.63,117.12 154.04,117.12 154.18,117.27 155.25,117.27 156.48,118.5 156.48,119.76 157.62,120.9 158.94,120.9 159.6,121.55 159.63,121.55 159.67,121.6 160.53,121.6 163.73,124.8 163.9,124.8 164.76,125.66 164.76,128.86 164.34,129.28 164.34,132.2 164.07,132.48 164.07,139.53 166.29,141.75 168.13,141.75 169.27,142.9 174.73,142.9 175.56,143.72 177.14,143.72 178.12,142.75 191.82,142.75 192.12,142.45 197.6,142.45 197.93,142.11 205.95,142.11 206.61,141.44 211.98,141.44 226.42,127 226.42,118.61 228.55,116.48 228.55,116 228.99,115.56 229.87,115.56 235.82,109.62 242.99,109.62 245.41,107.21 249,107.21 249.63,106.57 251.63,106.57 254.26,109.2 254.26,110.67 254.47,110.89 254.8,110.89 255.16,110.52 v2(255.2,110.52)
CLK_PCIE_P4: length 109.6
  TOP w0.102: v2(130.98,104.6) 130.98,104.54 131.17,104.35 131.61,104.35 131.81,104.14 132.04,104.14 132.12,104.22 132.12,104.67 132.25,104.8 132.33,104.8 132.58,104.54 UH1.E6 ; v2(54.58,49.47) 54.46,49.59 54.06,49.59 53.46,48.99 53.27,48.99 53.13,48.85 JIO2.108
  IN3 w0.109: 130.28,103.17 131.13,103.17 131.68,103.72 131.68,104.12 131.33,104.47 131.11,104.47 v2(130.98,104.6)
  IN3 w0.127: v2(54.58,49.47) 54.67,49.56 55.55,49.56 56.43,50.44 60.9,50.44 61.75,51.29 61.75,52.63 96.34,87.22 97.68,87.22 104.27,93.81 106.87,93.81 107.42,94.36 107.96,94.89 112.12,94.89 112.31,95.08 114.65,95.08 114.72,95.02 124.35,95.02 124.81,95.48 124.81,98.6 127.16,100.95 127.16,102.28 127.65,102.77 129.5,102.77 129.89,103.17 130.28,103.17
CLK_PCIE_P5: length 162.8
  TOP w0.102: UH1.D7 132.62,103.67 132.69,103.59 132.69,103.33 v2(132.63,103.27)
  IN3 w0.109: v2(132.63,103.27) 132.38,103.02 132.38,102.89 131.84,102.35 130.92,102.35
  IN3 w0.127: 130.92,102.35 130.73,102.16 129.18,102.16 128.88,101.86 128.88,95.48 127.47,94.07 115.14,94.07 114.38,93.3 113.29,93.3 112.9,93.7 110.9,93.7 110.38,93.17 108.59,93.17 108.23,93.53 107.56,93.53 107.14,93.12 106.53,93.12 105.1,91.69 103.11,91.69 60.28,48.86 56.53,48.86 55.46,47.78 55.46,45.94 55.13,45.61 54.29,45.61 54.25,45.65 52.06,45.65 48.58,49.13 46.86,50.85 37.91,50.85 36.35,49.29 36.35,45.78 35.44,44.87 35.44,36.82 35.82,36.45 35.82,35.19 37.36,33.65 37.36,31.74 36.42,30.8 36.42,25.52 35.31,24.4 35.31,22.8 37.39,20.72 37.39,20.21 v2(37.57,20.04)
  BOTTOM w0.102: JSATA2.14 37.55,19.42 37.37,19.6 37.37,19.83 v2(37.57,20.04)
CLK_PCIE_P6: length 123.9
  TOP w0.102: UH1.R7 131.77,108.62 v2(131.77,108.6)
  IN1 w0.109: v2(211.54,117.34) 211.33,117.14 211.03,117.14 210.26,117.91 209.43,117.91 207.63,119.71 207.63,122.27 204.39,125.51 204.39,127.07 197.72,133.74 196.46,133.74 193.25,136.95 191.71,136.95 191.11,137.55 187.93,137.55 187.33,136.95 174.13,136.95 173.53,137.55 168.95,137.55 168.26,136.86 168.26,134.52 168.86,133.92 168.86,132.22 168.52,131.87 168.52,126.64 169.14,126.02 169.14,125.99 169.21,125.93 169.21,123.39 166.82,121 166.82,120.27 165.21,118.67 165.21,114.38 164.16,113.33 164.16,112.82 163.46,112.11 163.46,107.8 163.31,107.65 162.94,107.65 v2(162.71,107.88)
  IN4 w0.109: v2(162.71,107.88) 162.54,107.72 155.55,107.72 155.17,107.34 150.85,107.34 150.22,107.97 149.26,107.97 148.68,108.54 146.65,108.54 145.55,109.65 142.82,109.65 142.4,110.07 136.5,110.07 134.63,108.19 131.55,108.19 131.42,108.31 131.42,108.48 131.54,108.6 v2(131.77,108.6)
  BOTTOM w0.102: JNGFF1.39 211.96,117.2 211.88,117.11 211.76,117.11 v2(211.54,117.34)
CLK_PCIE_P7: length 213.4
  TOP w0.102: v2(131.82,109.45) UH1.U7
  IN1 w0.089: 112.37,107.83 112.38,107.84 115.29,107.84 115.48,108.03 116.83,108.03 118.61,109.81 127.95,109.81 128.02,109.88 132.04,109.88 132.22,109.69 132.22,109.15 132.14,109.07 132.04,109.07 131.82,109.29 v2(131.82,109.45)
  IN1 w0.109: 112.37,107.83 110.56,107.83 109.92,108.47 104.17,108.47 100.19,104.48 100.19,101.95 91.58,93.35 91.58,92.21 63.63,64.26 58.68,64.26 56.49,66.44 26.83,66.44 24.32,63.94 24.32,54.35 19.93,49.96 19.93,49.18 10.84,40.09 10.84,39.69 5.95,34.8 5.95,15.72 4.64,14.41 4.64,10.22 4.13,9.71 4.13,8.62 5.66,7.09 10.81,7.09 11.83,8.11 13.02,8.11 14.64,6.5 15.09,6.5 v2(15.25,6.66)
  BOTTOM w0.102: JNGFF3.55 16.25,6.22 16.01,6.47 15.45,6.47 v2(15.25,6.66)
CLK_PEG_N0: length 65.1
  TOP w0.102: v2(174.94,99.85) 174.87,99.78 174.87,99.35 175.62,98.6 176.22,98.6 v4(176.79,98.02) 177.14,97.67 177.14,94.14 174.98,91.98 174.98,90.57 175.26,90.29 175.26,88.94 175.5,88.71 JMXM1.183 ; v2(131.64,107.56) 131.64,107.66 UH1.N7
  IN4 w0.109: v2(174.94,99.85) 174.37,100.41 173.84,100.41 173.61,100.18 172.72,100.18 171.54,101.37 168,101.37 166.88,102.48 166.88,104.33 166.39,104.82 163.14,104.82 160.94,107.02 156.01,107.02 155.7,106.71 150.59,106.71 150.54,106.76 148.7,106.76 147.55,107.91 146.39,107.91 145.31,108.99 136.26,108.99 134.23,106.95 133.58,106.95 133.39,107.14 131.49,107.14 131.42,107.21 131.42,107.34 v2(131.64,107.56)
CLK_PEG_P0: length 65.1
  TOP w0.102: v2(174.36,99.85) 174.65,99.55 174.65,99.26 v4(175.3,98.61) 175.53,98.38 176.13,98.38 176.93,97.58 176.93,94.23 174.77,92.07 174.77,90.48 175.05,90.2 175.05,88.85 175,88.79 JMXM1.185 ; UH1.N8 130.88,107.66 v2(130.88,107.56)
  IN4 w0.109: v2(174.36,99.85) 174.36,100.13 174.28,100.2 173.93,100.2 173.7,99.97 172.63,99.97 171.45,101.15 167.91,101.15 166.67,102.39 166.67,104.24 166.3,104.6 163.05,104.6 160.85,106.8 156.1,106.8 155.79,106.49 150.5,106.49 150.45,106.55 148.61,106.55 147.46,107.69 146.3,107.69 145.22,108.77 136.35,108.77 134.32,106.74 133.49,106.74 133.3,106.93 131.4,106.93 131.21,107.12 131.21,107.36 131.01,107.56 v2(130.88,107.56)
CLK_SIO_14M: length 2.4
  BOTTOM w0.102: T207.1 186.81,107.01 U46.A32
CLK_TP_SIO: length 152.2
  TOP w0.102: R400.1 CZ31.1 RZ19.2 287.71,34.23 v2(287.55,34.07)
  IN1 w0.109: v2(213.61,101.25) 213.8,101.44 214.08,101.44 214.29,101.66 214.29,102.19 213.93,102.55 213.56,102.55 211.91,104.21 210.9,104.21 209.74,105.36 209.74,105.91 208.35,107.3 205.74,107.3 204.86,106.43 199.59,106.43 198.94,107.09 198.94,108.42 198.4,108.96 198.4,109.53 197.61,110.32 196.23,110.32 195.67,109.76 195.67,109.39 195.43,109.15 194.42,109.15 v2(194.36,109.21)
  IN3 w0.127: v2(213.61,101.25) 213.79,101.43 213.97,101.43 214.16,101.24 214.16,98.32 216.07,96.41 216.07,92.74 217.18,91.63 233.01,91.63 237.05,87.59 251.78,87.59 253.72,85.64 253.72,72.33 257.73,68.33 257.73,64.69 265.09,57.32 265.09,56.34 271.3,50.13 272.76,50.13 283.38,39.51 283.38,37.79 286.83,34.33 286.83,33.09 287.21,32.71 288.13,32.71 288.47,33.05 288.47,33.6 288.14,33.93 287.68,33.93 v2(287.55,34.07)
  BOTTOM w0.102: v2(194.36,109.21) 194.51,109.36 U51.A37
CLK_TP_SIO_R: length 4.9
  TOP w0.102: v1(290.19,36.1) 290.05,35.96 R400.2 290.84,34.36 290.84,32.76 291.25,32.35 JKBTP1.7
CLKDET#: length 200.1
  TOP w0.089: v2(122.73,119.38) 123.92,119.38 124.25,119.71 124.25,121.28 124.64,121.66 124.76,121.66 124.99,121.89 124.99,122.1 124.58,122.5 UH1.BB22
  TOP w0.102: R3753.2 36.78,21.74 v1(36.87,21.65) 36.89,21.64 v2(36.08,20.83)
  IN1 w0.089: v2(115.3,119.69) 114.11,119.69 113.36,118.94 112.37,118.94
  IN1 w0.109: 112.37,118.94 109.95,118.94 109.46,119.43 108.61,119.43 108.46,119.58 106,119.58 v2(105.82,119.4)
  IN2 w0.127: v2(36.08,20.83) 36.08,22.41 34.87,23.63 34.87,26.52 32.92,28.47 32.92,30.27 32.19,31.01 32.19,33.42 30.18,35.43 27.84,35.43 24.9,38.37 24.9,46.32 23.8,47.41 23.8,51.42 26.47,54.09 26.47,61.68 28.79,63.99 54.56,63.99 56.54,62.01 56.54,61.8 57.02,61.32 76.62,61.32 84.52,69.22 84.52,78.36 91.97,85.8 91.97,97.18 97.49,102.7 98.07,102.7 98.28,102.7 99.04,103.45 99.04,104.85 99.93,105.74 99.93,109.07 104.35,113.49 104.35,114.35 105.7,115.7 105.7,119.28 v2(105.82,119.4)
  BOTTOM w0.089: v2(122.73,119.38) 122.72,119.36 122.36,119.36 121.25,118.26 119.51,118.26 119.03,118.73 118.23,118.73 117.77,118.27 116.19,118.27 115.96,118.51 115.96,119.03 v2(115.3,119.69)
  BOTTOM w0.102: JSATA2.16 36.55,20.36 v2(36.08,20.83)
CLKREQ_PCIE#1: length 288
  TOP w0.089: UH1.AW24 123.33,121.29 123.59,121.55 123.59,122.25 123.82,122.48 123.82,123.39 123.84,123.41 123.84,123.65 123.82,123.67 123.82,123.73 123.74,123.8 123.74,124.01 124.02,124.29 124.02,124.81 124.14,124.93 124.14,125.86 v2(124.06,125.94) 124.32,126.2
  TOP w0.102: JIO1.65 316.32,32.3 v2(316.96,32.95) ; 124.32,126.2 124.44,126.32 124.44,127.11 RH124.1
  IN3 w0.127: v2(224.07,124.82) 223.26,124.01 223.26,115.53 223.69,115.1 223.69,108.2 224.05,107.84 224.05,107.11 224.68,106.48 224.68,103.5 224.63,103.45 224.63,98.95 228.01,95.57 228.45,95.57 231.25,98.37 231.25,98.62 234.46,101.84 237.7,101.84 241.64,97.9 244.3,97.9 246.96,95.24 246.96,94.74 247.47,94.23 248.89,94.23 251.12,91.99 254.21,91.99 255.12,91.08 255.83,91.08 257.18,89.72 257.18,88.78 257.38,88.58 257.38,84.91 257.64,84.65 257.64,83.34 257.98,82.99 257.98,73.49 262.11,69.36 262.11,66.75 280.07,48.79 296.79,48.79 299.07,46.5 302.06,46.5 302.38,46.18 311.95,46.18 312.14,45.99 316.37,45.99 v2(317,45.36)
  IN4 w0.089: 141.71,123.97 139.67,123.97 139.58,124.06 138.25,124.06 137.67,124.65 131.68,124.65 131.4,124.92 129.59,124.92 129.23,125.28 129.23,125.6 129.01,125.82 127.94,125.82 127.89,125.77 126.71,125.77 126.38,125.44 126.23,125.44 125.96,125.17 125.96,124.16 125.82,124.02 124.24,124.02 123.96,124.3 123.96,125.03 124.06,125.13 v2(124.06,125.94)
  IN4 w0.109: 141.71,123.97 142.89,123.97 143.01,124.1 143.85,124.1 143.95,124 145.33,124 145.38,124.05 148.86,124.05 149.08,124.28 152.07,124.28 153.1,125.31 156.22,125.31 157.53,124 166.64,124 167.84,122.79 169.22,122.79 169.33,122.91 175.82,122.91 176.4,123.49 180.3,123.49 180.66,123.13 191,123.13 192.64,124.77 193.63,124.77 194.02,125.16 197.87,125.16 198.25,125.55 205.99,125.55 206.49,125.04 211.49,125.04 211.93,125.48 211.93,125.7 212.31,126.08 213.62,126.08 214.67,125.03 223.87,125.03 v2(224.07,124.82)
  BOTTOM w0.102: v2(316.96,32.95) 316.96,33.27 316.02,34.22 316.02,44.37 v2(317,45.36)
CLKREQ_PCIE#2: length 286.4
  TOP w0.089: v2(124.5,125.5) 124.77,125.76 124.77,126.2 ; UH1.AT24 v2(123.77,120.19)
  TOP w0.102: RH125.1 124.77,126.76 124.77,126.2
  IN1 w0.089: v2(123.77,120.19) 124.96,119 126.38,119 126.42,118.96 128.44,118.96 129.07,119.59 129.67,119.59 130.04,119.96 130.04,121.73 131.34,123.04 133.54,123.04 133.71,123.21 133.78,123.21 135.49,124.92 135.49,125.5 135.38,125.61 135.38,126.03 135.41,126.05 135.41,126.11 135.5,126.2
  IN1 w0.109: 135.5,126.2 135.66,126.37 135.66,127.61 136.18,128.14 137.05,128.14 138.47,129.56 140.87,129.56 142.01,130.7 147.5,130.7 148.16,131.36 151.67,131.36 152.26,130.77 154.68,130.77 154.99,131.07 154.99,131.18 v2(155.08,131.27) ; v2(248.28,96.22) 247.55,95.49 247.55,91.6 251,88.15 251,85.68 251.98,84.7 252.74,84.7 254.16,83.28 254.16,76.59 255.66,75.09 255.66,72.73 261.46,66.93 261.46,63.84 266.53,58.77 268.16,58.77 277.5,49.43 282.74,49.43 283.83,48.34 285.2,48.34 285.69,47.86 288.81,47.86 291.32,45.35 302.79,45.35 303.84,44.3 308.42,44.3 308.85,43.87 310.51,43.87 314.82,39.55 317.43,39.55 317.65,39.77 318.63,39.77 320.02,38.38 320.02,37.99 319.76,37.74 319.63,37.74 v2(319.01,37.12)
  IN3 w0.127: v2(248.28,96.22) 249.72,97.67 249.72,102.72 247.02,105.43 245.25,105.43 241.76,108.91 241.76,117.36 241.36,117.76 241.36,123.31 237.32,127.34 235.94,127.34 235.06,127.34 v2(233.02,129.37)
  IN4 w0.109: v2(155.08,131.27) 155.58,131.77 155.58,132.2 156.31,132.93 157.78,132.93 158.22,133.37 163.06,133.37 165.47,130.97 173.34,130.97 174.23,130.08 184.06,130.08 184.58,130.6 185.16,130.6 185.72,131.16 194.09,131.16 194.31,130.94 208.67,130.94 208.93,130.68 214.45,130.68 214.58,130.56 218.64,130.56 218.95,130.25 230.95,130.25 231.02,130.33 232.07,130.33 v2(233.02,129.37)
  BOTTOM w0.089: v2(124.5,125.5) 124.82,125.5 125.19,125.12 125.19,124.56 123.85,123.22 v1(123.85,122.73) 123.85,122.12 123.77,122.03 123.77,121.83 123.36,121.42 123.36,120.6 v2(123.77,120.19)
  BOTTOM w0.102: JNGFF2.44 319.95,36.18 v2(319.01,37.12)
CLKREQ_PCIE#3: length 195.8
  TOP w0.089: UH1.BD25 122.95,123.55 122.73,123.77 122.73,123.78 122.72,123.79 122.72,124.03 122.73,124.04 122.78,124.09 122.78,124.76 122.65,124.89 122.65,124.9 122.61,124.94 122.61,125.77 122.37,126 122.05,126 121.85,126.2
  TOP w0.102: v2(254.99,112.48) 254.66,112.14 U31.48 ; RH126.1 121.56,127.11 v2(121.56,126.49) 121.85,126.2
  IN1 w0.109: v2(188.22,145.59) 188.57,145.24 188.89,145.24 189.16,144.98 194.95,144.98 196.21,143.72 198.16,143.72 198.54,143.34 206.54,143.34 207.42,144.21 211.05,144.21 227.62,127.65 227.62,119.11 229.42,117.3 230.12,117.3 234.43,112.99 239.18,112.99 239.88,113.69 247.75,113.69 248.7,112.75 254.86,112.75 254.99,112.61 v2(254.99,112.48)
  IN4 w0.109: v2(121.56,126.49) 121.56,127.55 120.74,128.37 119.39,128.37 118.84,128.93 116.01,128.93 113.62,131.31 113.62,134.61 114.46,135.45 115.78,135.45 116.17,135.85 127.25,135.85 128.91,134.2 131.56,134.2 132.54,133.22 135.11,133.22 135.92,132.41 139.78,132.41 140.32,132.95 141.17,132.95 142.12,133.9 142.12,135.3 144.56,137.75 149.78,137.75 150.6,138.58 151.94,138.58 155.1,141.74 159.55,141.74 162.27,139.02 165.78,139.02 166.01,138.79 167.01,138.79 167.01,138.8 173.37,138.8 173.79,138.37 174.81,138.37 176.2,136.98 184.26,136.98 186.92,139.65 186.92,143.28 188.13,144.48 188.13,145.5 v2(188.22,145.59)
CLKREQ_PCIE#4: length 141.5
  TOP w0.089: 123.56,126.2 123.12,125.76 123.12,124.68 123.12,124.09 123.18,124.03 123.18,123.79 123.12,123.74 123.12,123.59 123.2,123.51 123.2,123.34 123.23,123.32 123.23,122.79 UH1.BB24
  TOP w0.102: JIO2.104 53.19,47.85 53.29,47.94 53.67,47.94 54.08,48.35 v2(54.08,48.85) ; RH127.1 123.44,127.04 v2(123.92,126.56) 123.56,126.2
  IN1 w0.089: 123.56,126.2 123.36,126 120.63,126 120.27,125.65 120.27,125.17 120.17,125.06 119.51,125.06 119.38,125.2 116.58,125.2 115.61,124.22 115.02,124.22 114.67,123.87 114.48,123.87
  IN1 w0.109: v2(123.92,126.56) 123.56,126.2 ; v2(101.83,109.05) 101.45,109.43 98.8,109.43 97.68,110.55 97.68,113.15 101.56,117.03 101.56,117.96 104.47,120.87 105.41,120.87 106.62,122.08 108.63,122.08 110.24,120.47 110.93,120.47 111.33,120.87 111.33,121.05 112.02,121.74 112.02,122.14 113.75,123.87 114.48,123.87
  IN2 w0.127: v2(54.08,48.85) 54.65,48.85 56.67,50.87 63.94,50.87 66.78,53.72 71.53,53.72 72.13,54.31 75.24,54.31 86.56,65.63 86.56,77.46 103.87,94.77 103.87,96.6 101.99,98.48 101.99,100.51 100.69,101.81 100.69,104.17 101.6,105.08 101.6,108.82 v2(101.83,109.05)
CLKREQ_PCIE#5: length 214.4
  TOP w0.089: 122.56,126.2 122.78,125.99 122.78,125.01 122.95,124.84 122.95,124.01 122.95,124.01 UH1.BE25
  TOP w0.102: 122.56,126.2 v2(122.17,126.6) 122.55,126.98 RH131.1
  IN2 w0.127: v2(35.09,21.25) 35.09,22.68 34.36,23.42 34.36,24.23 32.51,26.07 32.51,26.71 31.96,27.26 31.84,27.26 31.14,27.96 31.14,30.5 27.94,33.7 25.99,33.7 25.4,34.28 25.4,35.96 24.39,36.98 24.39,46.11 23.3,47.2 23.3,51.63 25.96,54.3 25.96,61.89 28.58,64.5 54.78,64.5 56.75,62.53 76.56,62.53 84.02,69.99 84.02,78.57 91.46,86.01 91.46,97.39 97.65,103.59 97.65,109.28 98.15,109.77 98.15,112.06 101.88,115.79 104.68,115.79 105.39,116.5 105.39,122.24 105.05,122.57 105.05,124.62 104.55,125.13 104.55,127.08 108.08,130.61 108.08,132.86 110.56,135.34 115.8,135.34 116.44,134.7 v2(116.44,134.74)
  IN3 w0.127: v2(116.44,134.74) 116.44,131.37 117.23,130.58 120.25,130.58 120.49,130.33 120.49,128.21 122.1,126.6 v2(122.17,126.6)
  BOTTOM w0.102: JSATA2.18 35.55,19.78 35.56,19.79 35.56,20.78 v2(35.09,21.25)
CLKREQ_PCIE#6: length 136.7
  TOP w0.089: v2(117.49,120.83) 117.79,120.83 UH1.AT33
  TOP w0.102: RH132.1 118.55,126.63 v2(118.35,126.43)
  IN1 w0.109: v2(213.85,115.47) 213.68,115.64 213.68,115.91 212.51,117.08 212.51,124.16 213.08,124.73 213.08,131.59 212.45,132.23 v2(212.45,132.57) ; v2(118.35,126.43) 118.99,127.07 124.31,127.07 124.46,127.23 126.79,127.23 127.59,128.02 129.29,128.02 131.16,126.16 132.04,126.16 133.24,127.37 133.24,129.87 135.04,131.66 135.04,134.35 135.63,134.94 139.52,134.94 140.14,134.32 140.14,134.07 140.34,133.86 141.85,133.86 142.24,134.25 143.38,134.25 144.65,135.53 151.62,135.53 153.53,133.61 v2(153.55,133.61)
  IN3 w0.089: 118.09,126.2 116.63,124.74 116.63,121.68 v2(117.49,120.83)
  IN3 w0.127: 118.09,126.2 118.16,126.27 118.2,126.27 v2(118.35,126.43)
  IN4 w0.109: v2(212.45,132.57) 211.83,133.19 198.55,133.19 198.28,133.46 187.03,133.46 186.19,132.63 184.52,132.63 183.76,131.86 174.54,131.86 172.53,133.88 165.61,133.88 164.02,135.47 156.07,135.47 154.79,134.2 154.13,134.2 v2(153.55,133.61)
  BOTTOM w0.102: JNGFF1.45 213.76,115.7 213.87,115.6 213.87,115.48 213.86,115.48 213.86,115.47 213.85,115.47 v2(213.85,115.47)
CLKREQ_PCIE#7: length 240.2
  TOP w0.089: 118.74,126.2 118.4,125.85 v2(118.34,125.85) ; UH1.AR31 120.22,118.89 v2(120.44,119.11)
  TOP w0.102: 118.74,126.2 119.44,126.9 RH133.1
  IN3 w0.089: v2(118.34,125.85) 118.07,125.85 116.81,124.59 116.81,122.02 117.64,121.18 119.8,121.18 119.99,120.99 119.99,119.56 v2(120.44,119.11)
  IN4 w0.089: 112.37,109.3 113.14,110.07 118.48,110.07 118.73,110.31 120.09,110.31 120.55,110.77 120.55,111.66 120.71,111.81 120.71,118.84 v2(120.44,119.11)
  IN4 w0.109: v2(25.05,9.39) 22.71,11.73 22.71,22.82 22.2,23.32 21.05,23.32 19.87,24.51 19.87,29.34 11.98,37.23 6.4,37.23 2.5,41.13 2.5,56.57 10.72,64.78 17.56,64.78 18.84,66.06 54.06,66.06 55.07,67.07 56.8,67.07 59.1,64.77 62.93,64.77 86.58,88.42 86.58,92 86.78,92.2 93.07,98.49 93.3,98.72 93.87,98.72 94.18,98.72 94.18,98.72 94.66,98.72 102.09,98.74 103.07,99.72 105.64,102.29 105.64,103.08 108.18,105.62 110.15,105.62 112.31,107.78 112.31,108.6 112.34,108.63 112.34,109.27 112.37,109.3
  BOTTOM w0.102: JNGFF3.52 15.5,10.38 15.5,10.38 15.5,9.79 17.2,8.1 23.75,8.1 v2(25.05,9.39)
CLKREQ_PEG#0: length 23.7
  TOP w0.089: v2(123.49,124.59) 123.36,124.46 123.36,123.6 123.37,123.58 123.37,123.42 123.4,123.39 123.4,123.14 UH1.BC24
  BOTTOM w0.089: v2(123.49,124.59) 122.39,123.49 121.48,123.49 120.94,122.95 120.94,122 120.43,121.49 v1(118.93,121.49) 117.11,121.49 116.11,122.49 116.11,123.15 116.04,123.22 116.04,123.22 115.59,123.68 115.59,124.06 115.04,124.61 ; 114.79,128.08 114.56,128.3 114.56,128.35 112.93,129.98 112.93,129.99
  BOTTOM w0.102: 112.93,129.99 111.93,130.99 QH3.1 111.8,131.78 RH128.1 ; 115.04,124.61 115.01,124.64 115.01,125.06 115.52,125.57 115.52,127.19 114.99,127.72 114.99,127.88 114.79,128.08
CLKRUN#: length 106
  TOP w0.089: UH1.AW22 125.2,120.91 v2(125.2,120.73)
  TOP w0.102: RH202.1 137.85,124.81 v2(137.08,124.04) ; v2(182.63,113.27) 183.12,113.75 183.49,113.75 184.08,114.34 185.6,114.34 186,114.73 v2(186,114.91) 186,115.16 185.77,115.4 185.77,115.5 185.47,115.79 184.93,115.79 184.49,116.24 184.49,116.88 184.87,117.26 184.87,119 v1(182.46,121.4) 181.36,122.5 181.36,123.85 181.82,124.31 181.82,125.2 181.21,125.81 180.98,125.81 180.89,125.9 180.89,125.9 v2(180.89,125.9) ; v2(191.21,115.3) 191.63,115.3 192.51,114.41 192.51,111.83 192.38,111.7 192.38,108.89 193.6,107.67 194.61,107.67 195.34,106.94 195.34,106.54 196.28,105.6 v2(196.28,105.3)
  IN2 w0.089: 141.46,124.21 141.25,124.21 141.07,124.04 v2(137.08,124.04)
  IN2 w0.127: 141.46,124.21 144.45,124.21 144.63,124.04 149.9,124.04 150.09,124.23 152.19,124.23 153.31,125.34 154.22,125.34 154.33,125.24 155.26,125.24 156.33,124.16 164.9,124.16 165.96,123.09 166.31,123.09 166.35,123.13 166.36,123.13 166.46,123.23 167.28,123.23 167.48,123.03 168.95,123.03 169.64,123.72 173.17,123.72 174.51,125.05 176.16,125.05 176.8,124.42 179.41,124.42 v2(180.89,125.9)
  IN4 w0.109: v2(186,114.91) 185.99,114.91 185.99,114.94 186.35,115.3 v2(191.21,115.3)
  BOTTOM w0.089: v2(125.2,120.73) 125.65,120.29 125.65,120.23 126.12,119.76 126.38,119.76 127.9,118.23 128.65,118.23 128.86,118.45 128.86,118.66 129,118.79 130.08,118.79 130.3,119.01 131.64,119.01 132.05,119.43 132.05,119.89 131.81,120.14 131.81,120.38 132.04,120.61 132.47,120.61 132.76,120.32 134.64,120.32 136.4,122.09 136.4,122.56 136.26,122.7 136.26,123.16 136.28,123.18 136.28,123.24 v2(137.08,124.04)
  BOTTOM w0.102: U46.B20 183.13,113.76 v2(182.63,113.27) ; U51.A32 196.75,105.37 196.69,105.3 v2(196.28,105.3)
CMPIN: length 6.9
  TOP w0.102: PR737.2 268.52,30.78 268.04,31.26 267.2,31.26 v1(266.82,31.63)
  TOP w0.203: PU700.13 270.48,31.86 270.14,31.52
  TOP w0.254: 270.14,31.52 270.14,31.3 269.61,30.77 PR738.1 268.53,30.77 PR737.2 PC737.1 PR745.1
CMPOUT: length 6.6
  TOP w0.102: PR743.1 v1(268.52,26.31)
  TOP w0.203: PU700.14 270.73,31.46 270.57,31.3
  TOP w0.254: 270.57,31.3 270.57,31.03 PR738.2 269.39,28.96 PR740.1 269,28.44 268.72,28.44 268.52,28.24 PC741.2 PR743.1
COMP_3PH_A: length 3.3
  TOP w0.203: PU1100.6 257.35,49.75 PR1133.1 PC1113.1
COMP_3PH_B: length 4.7
  TOP w0.203: PU1100.33 256.95,41.49 256.85,41.4 256.85,40.7 256.78,40.63 256.78,39.73 256.95,39.57 v1(256.95,39.39) 256.95,38.68 PC1117.2
  TOP w0.254: PC1119.2 257.12,37.64 PC1117.2
CONTACTLESS_DET#: length 108.4
  TOP w0.089: v2(117.65,109.64) 117.45,109.84 UH1.U36
  TOP w0.102: v2(106.7,94.75) 106.28,95.17 105,95.17 100.2,90.37 99.65,90.37 97.91,88.63 93.11,88.63 72.29,67.81 72.29,44.44 72.15,44.3 JUSH1.4
  IN2 w0.089: v2(117.65,109.64) 117.23,110.07 112.37,110.07 112.37,110.07
  IN2 w0.127: v2(106.7,94.75) 106.77,94.81 106.77,96.7 104.24,99.22 104.24,101.95 104.63,102.34 104.63,103.31 103.86,104.07 103.86,104.98 103.51,105.34 103.51,107.89 105.37,109.75 107.23,109.75 107.8,109.18 108.94,109.18 110.6,110.83 111.61,110.83 v2(111.8,110.64) 112.37,110.07
  BOTTOM w0.102: v2(111.8,110.64) 111.55,110.89 v1(111,110.89) 110.81,111.08 108.67,111.08 107.78,110.18 107.78,110.07 107.24,109.53 RH90.2
CPU_2_PCH_TRIGGER: length 92.1
  TOP w0.089: 137.05,116.77 135.53,116.77 135.18,116.42 UH1.AK1
  TOP w0.102: 137.05,116.77 137.16,116.89 139.02,116.89 v2(139.49,116.42)
  IN3 w0.127: v2(193.34,102.45) 193.34,98.93 197.15,95.12 197.15,90.85 195.52,89.22 195.52,85.84 197.55,83.8 197.55,81.15 197.71,80.99 v2(198.1,80.99)
  IN4 w0.089: 141.76,114.77 141.13,114.77 v2(139.49,116.42)
  IN4 w0.109: v2(193.34,102.45) 192.93,102.86 191.21,102.86 190.97,102.61 189.94,102.61 189.44,103.11 184.94,103.11 184.44,103.62 182.65,103.62 182.16,104.1 182.16,104.71 181.87,105 180.42,105 179.42,106.01 175.16,106.01 174.6,106.57 174.6,107.52 172.69,109.44 172.69,109.94 172.02,110.61 170.93,110.61 169.27,112.27 166.67,112.27 166.34,112.6 164.85,112.6 164.73,112.49 162.42,112.49 161.72,113.18 152.64,113.18 152.04,113.78 149.46,113.78 148.55,114.69 145.42,114.69 145.33,114.77 141.76,114.77
  BOTTOM w0.102: RC177.1 197.84,80.75 198.09,80.99 v2(198.1,80.99)
CPU_2_PCH_TRIGGER_R: length 40.3
  TOP w0.089: CPU1.J23 v2(187.81,58.72)
  BOTTOM w0.089: 198.61,61.67 196.27,59.33 192.69,59.33 191.47,58.11 191.47,58.01 191.22,57.75 188.78,57.75 v2(187.81,58.72) ; 199.9,68.64 199.49,69.05
  BOTTOM w0.102: RC177.2 198.2,78.97 198.2,77.68 198.1,77.58 v3(198.1,77.29) 198.1,74.66 198.94,73.82 198.94,72.2 198.94,71.2 198.94,71.19 198.94,69.6 199.49,69.05 ; 198.61,61.67 202.19,61.67 204.77,64.25 204.77,66.06 204.32,66.5 201.86,66.5 200.78,67.58 200.78,67.76 200.78,67.76 200.07,68.47 200.06,68.48 199.9,68.64
CPU_24MHZ_R_D: length 87
  TOP w0.089: CPU1.E31 v2(193.72,62.44)
  TOP w0.102: v2(159.4,94.11) 159.48,94.11 159.6,94 159.6,93.78 159.44,93.62 157.97,93.62 155.49,96.1 155.49,97.54 152.86,100.17 v4(147.91,100.17) 146.64,100.17 145.14,101.67 145.14,102.55 143.87,103.82 139.2,103.82 RH169.1
  IN3 w0.089: v2(193.72,62.44) 193.72,62.58 193.5,62.8 193.08,62.8 192.78,63.1 192.78,65.93 193.76,66.91 193.76,68.18 194.31,68.73 194.31,70.88 194.29,70.89 194.29,70.91
  IN3 w0.127: v2(159.4,94.11) 159.62,93.89 159.62,93.55 159.86,93.31 160.98,93.31 161.51,92.78 161.51,91.77 162.5,90.78 162.5,90.44 162.9,90.03 162.9,88.18 163.67,87.4 163.67,86.39 167.01,83.05 172.41,83.05 173.87,81.59 182.41,81.59 182.95,81.05 185.92,81.05 187.46,79.5 187.46,78.06 188.8,76.72 190.34,76.72 191.3,75.75 191.3,74.14 192.04,73.4 193.35,73.4 194.29,72.46 194.29,70.91
CPU_24MHZ_R_D#: length 87
  TOP w0.089: v2(193.72,63.09) 194.05,62.76 CPU1.D31
  TOP w0.102: v2(160.04,94.11) 159.81,93.89 159.81,93.69 159.53,93.4 157.88,93.4 155.27,96.01 155.27,97.45 152.77,99.96 v4(149.43,99.96) 146.55,99.96 144.93,101.58 144.93,102.46 143.78,103.6 139.07,103.6 138.93,103.47 RH170.1
  IN3 w0.089: v2(193.72,63.09) 193.64,63.01 193.17,63.01 192.99,63.19 192.99,65.84 193.97,66.82 193.97,68.09 194.52,68.64 194.52,70.86 194.54,70.88 194.54,70.91
  IN3 w0.127: 194.54,70.91 194.54,72.56 193.46,73.65 192.14,73.65 191.55,74.24 191.55,75.85 190.44,76.96 188.91,76.96 187.71,78.16 187.71,79.61 186.02,81.29 183.05,81.29 182.51,81.84 173.97,81.84 172.52,83.3 167.12,83.3 163.92,86.49 163.92,87.51 163.15,88.28 163.15,90.13 162.75,90.54 162.75,90.88 161.76,91.87 161.76,92.88 161.08,93.56 159.96,93.56 159.87,93.65 159.87,93.95 v2(160.04,94.11)
CPU_DP1_AUXN: length 162.7
  TOP w0.089: v2(190.56,62.4) 190.75,62.4 190.96,62.18 CPU1.E27
  IN1 w0.089: v2(190.56,62.4) 190.83,62.4 190.94,62.52 190.94,62.66 190.84,62.77 190.24,62.77 190.13,62.66 190.13,62.24 190.36,62.01 190.36,60.83 190.2,60.66 190.2,60.27 190.38,60.08 191.27,60.08 192.22,59.13 193.52,59.13 193.71,59.32 196.6,59.32 198.89,61.62 199.9,61.62
  IN1 w0.109: 199.9,61.62 201.86,61.62 209.31,69.07 209.31,79.1 209.96,79.75 209.96,81.57 212.3,83.91 212.3,87.54 213.62,88.85 213.62,99.66 212.41,100.87 212.41,100.89 210.34,102.95 210.34,103.23 209.03,104.54 207.92,104.54 207.06,105.4 205.51,105.4 205.26,105.15 204.19,105.15 203.86,105.47 197.74,105.47 197.5,105.71 195.21,105.71 194.29,104.8 193.09,104.8 192.61,105.28 192.61,105.51 191.96,106.17 191.96,107.12 191.68,107.4 191.52,107.56 191.32,107.56 190.68,108.2 190.68,114.6 190.1,115.18 190.1,117.99 188.93,119.16 188.93,122.03 189.9,123 189.9,124.79 190.26,125.15 190.26,126.11 189.53,126.84 189.53,132.46 188.75,133.24 187.88,133.24 187.12,134.01 184.51,134.01 184.19,134.32 174.41,134.32 170.17,130.08 170.17,129.13 170.26,129.04 170.26,128.37 170.59,128.04 v2(170.86,128.04)
  BOTTOM w0.102: C588.1 170.43,138.1 169.84,138.69 169.46,138.69 v4(167.72,140.43) 167.1,141.05 165.32,141.05 164.34,140.07 164.34,133.4 166.06,131.68 167.43,131.68 170.26,128.85 170.26,128.36 170.59,128.04 v2(170.86,128.04)
CPU_DP1_AUXN_C: length 2.7
  BOTTOM w0.102: U629.29 173.21,137.71 173.12,137.8 172.65,137.8 172.13,138.32 171.65,138.32 C588.2
CPU_DP1_AUXP: length 162.7
  TOP w0.089: CPU1.D27 190.94,62.76 v2(190.56,63.14)
  IN1 w0.089: 199.9,61.4 199.89,61.4 199.88,61.41 199.82,61.41 199.81,61.42 198.97,61.42 196.68,59.13 193.8,59.13 193.6,58.94 192.14,58.94 191.19,59.89 190.3,59.89 190,60.19 190,60.74 190.17,60.91 190.17,61.92 189.94,62.16 189.94,62.74 190.17,62.98 190.4,62.98 v2(190.56,63.14)
  IN1 w0.109: v2(170.03,128.02) 170.03,128.97 169.96,129.04 169.96,130.17 174.32,134.54 184.28,134.54 184.6,134.22 187.21,134.22 187.97,133.46 188.84,133.46 189.74,132.55 189.74,126.93 190.47,126.2 190.47,125.06 190.11,124.7 190.11,122.91 189.14,121.94 189.14,119.25 190.31,118.08 190.31,115.27 190.9,114.69 190.9,108.29 191.41,107.78 191.61,107.78 192.17,107.21 192.17,106.26 192.83,105.6 192.83,105.37 193.18,105.01 194.2,105.01 195.12,105.93 197.59,105.93 197.83,105.68 203.95,105.68 204.28,105.36 205.17,105.36 205.42,105.61 207.15,105.61 208,104.76 209.12,104.76 210.56,103.32 210.56,103.04 212.63,100.98 212.63,100.96 213.83,99.75 213.83,88.76 212.52,87.45 212.52,83.82 210.18,81.48 210.18,79.66 209.53,79.01 209.53,68.98 201.95,61.4 199.9,61.4
  BOTTOM w0.102: C591.1 169.55,138.91 167.19,141.27 165.23,141.27 164.13,140.16 v4(164.13,138) 164.13,133.31 165.97,131.47 167.34,131.47 170.03,128.78 v2(170.03,128.02)
