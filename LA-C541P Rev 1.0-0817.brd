# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS6: length 92.9
  TOP w0.089: CPU1.P9 v2(177.22,56.11)
  TOP w0.14: JDIMM3.221 117.93,72.17 116.24,73.86 113.89,73.86 113.52,73.49 113.52,73.35 v2(113.34,73.17)
  IN4 w0.089: v2(177.22,56.11) 176.87,55.76 175.89,55.76 175.53,56.11 174.96,56.11 174.63,55.78 171.22,55.78 167.77,59.23 167.61,59.4 167.61,61.31 165.77,63.14 165.77,63.18 165.75,63.2
  IN4 w0.147: v2(113.34,73.17) 113.52,73.35 113.52,73.9 114.04,74.42 116.18,74.42 121.63,79.88 124.87,79.88 126.83,81.84 129.2,81.84 130.23,80.8 134.07,80.8 134.45,80.42 136.13,80.42 142.63,73.92 144.03,73.92 144.63,73.31 144.63,72.77 144.31,72.45 144.31,72.23 146.8,69.75 155.56,69.75 160.07,65.24 163.35,65.24 164.21,64.38 164.57,64.38 165.75,63.2
  BOTTOM w0.14: JDIMM4.221 111.59,72.17 111.69,72.28 111.69,72.67 111.92,72.89 112.42,72.89 112.6,72.71 113.71,72.71 113.78,72.78 113.78,73.06 113.67,73.17 v2(113.34,73.17)
DDR_B_DQS7: length 93.9
  TOP w0.089: CPU1.L9 v2(177.22,58.82)
  TOP w0.14: v2(114.01,79.3) 114.39,79.3 114.57,79.12 114.57,78.94 114.33,78.7 112.63,78.7 112.22,78.29 112.22,77.41 112.11,77.3 111.77,77.3 111.65,77.43 JDIMM3.242
  IN4 w0.089: 168.74,65.68 168.76,65.67 168.76,65.63 170.13,64.25 170.13,62.37 173,59.51 174.85,59.51 175.42,58.94 175.42,58.79 175.78,58.43 176.17,58.43 176.19,58.45 176.85,58.45 v2(177.22,58.82)
  IN4 w0.147: 168.74,65.68 166.15,68.28 165.78,68.28 164.31,69.75 161.04,69.75 157.93,72.85 157.93,73.54 156.82,74.64 151.65,74.64 150.77,75.52 148.59,75.52 144.27,79.83 142.18,79.83 135.9,86.11 133.47,86.11 132.34,87.24 126.05,87.24 123.3,84.49 119.69,84.49 118.25,83.06 118.25,82.16 116.53,80.44 114.52,80.44 114.16,80.08 114.16,79.45 v2(114.01,79.3)
  BOTTOM w0.14: v2(114.01,79.3) 114.69,79.98 115.61,79.98 115.98,79.84 116.26,79.56 116.28,79.53 117.68,77.66 117.81,77.53 117.92,77.43 JDIMM4.242
DDR_B_DQS8: length 87.4
  TOP w0.089: CPU1.AW9 v2(177.22,36.91)
  TOP w0.14: JDIMM3.97 117.65,39.17 117.42,38.94 117.42,38.59 115.96,37.12 115.15,37.12 114.96,37.32 114.96,37.61 115.11,37.77 v2(115.23,37.77)
  IN3 w0.089: v2(177.22,36.91) 177.22,36.91 177.32,36.81 177.32,36.57 177.25,36.5 177.05,36.5 176.96,36.58 175.81,36.58 175.52,36.87 175.52,37.41 174.75,38.18 174.5,38.18 174.32,38.35 173.72,38.35 173.44,38.07 172.8,38.07 172.76,38.12 172.75,38.12
  IN3 w0.17: v2(115.23,37.77) 115.13,37.77 114.98,37.62 114.98,37.37 115.22,37.13 118.61,37.13 118.89,37.41 118.89,38.2 119.47,38.78 123.44,38.78 123.77,39.12 123.77,41.13 125.47,42.83 140.76,42.83 141.3,42.29 146.56,42.29 150.39,38.45 151.67,38.45 152.02,38.11 152.02,37.93 152.14,37.8 152.74,37.8 152.87,37.93 152.87,38.65 153.17,38.95 154.01,38.95 154.31,38.65 154.31,37.93 154.44,37.8 155.04,37.8 155.16,37.93 155.16,38.65 155.47,38.95 156.31,38.95 156.61,38.65 156.61,37.93 156.74,37.8 157.29,37.8 157.42,37.93 157.42,38.59 157.72,38.89 159.72,38.89 160.16,38.45 171.54,38.45 171.88,38.12 172.75,38.12
  BOTTOM w0.14: JDIMM4.97 112.66,39.17 113.28,38.56 113.63,38.56 113.83,38.77 114.66,38.77 115.09,38.34 115.09,37.92 v2(115.23,37.77)
DDR_B_DQS#0: length 89.3
  TOP w0.089: CPU1.BP9 v2(177.74,25.71)
  TOP w0.14: v2(115.78,16.01) 115.91,16.13 117,16.13 117.29,16.42 117.29,16.96 117.01,17.24 116.81,17.24 116.74,17.3 116.74,17.56 117.22,18.04 117.41,18.04 117.65,17.8 117.95,17.8 118.07,17.68 JDIMM3.11
  IN4 w0.089: v2(177.74,25.71) 177.89,25.56 178.19,25.56 178.77,24.98 178.77,23.81 177.13,22.16 177.13,21.66 176.8,21.33 176.8,21.29 176.8,21.28
  IN4 w0.147: 176.8,21.28 176.52,21 174.64,19.13 174.64,14.07 171.17,10.6 164.66,10.6 162.97,12.29 161.95,12.29 161.54,12.69 160.46,12.69 160.06,12.29 155.26,12.29 154.45,13.09 131.03,13.09 130.69,12.76 127.72,12.76 126,14.48 120.56,14.48 118.9,16.14 115.91,16.14 v2(115.78,16.01)
  BOTTOM w0.14: v2(115.78,16.01) 115.63,16.17 115,16.17 113.98,17.2 112.51,17.2 111.91,17.8 111.77,17.8 111.65,17.68 JDIMM4.11
DDR_B_DQS#1: length 83.3
  TOP w0.089: CPU1.BL9 177.42,27.34 v2(177.87,27.79)
  TOP w0.14: JDIMM3.32 111.65,22.93 111.77,23.05 111.91,23.05 112.05,22.91 112.05,22.33 112.28,22.1 114.3,22.1 114.54,21.86 114.54,21.55 114.43,21.44 v2(114.08,21.44)
  IN4 w0.089: 169.02,21.93 171.69,24.6 173.99,24.6 174.86,25.48 174.86,26.32 175.97,27.43 177.51,27.43 v2(177.87,27.79)
  IN4 w0.147: 169.02,21.93 168.06,20.97 160.77,20.97 159.3,19.5 157.69,19.5 157.39,19.79 157.39,20.1 157.24,20.25 156.65,20.25 156.51,20.1 156.51,19.79 156.21,19.5 155.41,19.5 154.97,19.93 153.77,19.93 153.33,19.5 145.71,19.5 145.27,19.94 130.4,19.94 130.2,20.15 126.58,20.15 126.47,20.03 118.37,20.03 117.77,20.63 114.61,20.63 114.27,20.98 114.27,21.25 v2(114.08,21.44)
  BOTTOM w0.14: JDIMM4.32 117.81,22.93 117.67,22.79 117.39,22.79 116.95,22.35 116.95,21.15 116.52,20.71 114.51,20.71 114.21,21.01 114.21,21.3 v2(114.08,21.44)
DDR_B_DQS#2: length 83.3
  TOP w0.089: CPU1.BG9 v2(177.22,30.51)
  TOP w0.14: JDIMM3.53 117.97,28.17 117.85,28.3 117.34,28.3 117.24,28.19 117.24,27.62 116.98,27.36 116.18,27.36 115.89,27.64 115.89,27.83 115.72,28 115.17,28 115.03,27.87 115.03,26.85 115.15,26.73 115.33,26.73 v2(115.53,26.93)
  IN4 w0.089: v2(177.22,30.51) 177.22,30.59 176.93,30.88 175.74,30.88 174.47,29.61 172.24,29.61 167.12,24.5 166.58,24.5
  IN4 w0.147: 166.58,24.5 166.16,24.5 165.53,25.12 141.2,25.12 141.03,24.96 137.76,24.96 136.92,25.79 134.38,25.79 133.84,26.33 133.35,26.33 133.24,26.22 133.24,25.56 132.98,25.31 132.06,25.31 131.8,25.56 131.8,26.22 131.7,26.33 131.08,26.33 130.54,25.79 124.04,25.79 123.49,25.24 119.71,25.24 117.42,27.53 115.36,27.53 115.18,27.35 115.18,27.11 115.36,26.93 v2(115.53,26.93)
  BOTTOM w0.14: JDIMM4.53 111.5,28.17 112.4,27.28 112.4,26.83 113.17,26.07 114.94,26.07 115.21,26.34 115.21,26.61 v2(115.53,26.93)
DDR_B_DQS#3: length 82.1
  TOP w0.089: CPU1.BC9 v2(177.22,33.25)
  TOP w0.14: JDIMM3.74 111.52,33.42 111.64,33.55 111.85,33.55 111.99,33.41 111.99,32.52 113.1,31.41 114.99,31.41 115.35,31.76 115.35,32 v2(115.52,32.17)
  IN4 w0.089: v2(177.22,33.25) 176.84,33.63 175.56,33.63 174.89,32.96 173.4,32.96 173.4,32.96 173.22,32.96 173.12,32.85 172.27,32.85 172.25,32.83 172.22,32.83
  IN4 w0.147: 172.22,32.83 168.43,32.83 165.89,30.28 165.71,30.28 165.16,29.73 165.16,29.55 164.59,28.99 142.02,28.99 140,31.01 139.45,31.01 139.15,30.7 138.44,30.7 138.16,30.98 137.6,30.98 137.32,30.7 136.7,30.7 136.12,31.28 119.37,31.28 118.61,32.04 118.04,32.04 117.77,32.3 117.77,32.88 117.67,32.99 117.24,32.99 116.85,32.59 116.02,32.59 115.63,32.98 115.17,32.98 115.05,32.87 115.05,32.33 115.21,32.17 v2(115.52,32.17)
  BOTTOM w0.14: JDIMM4.74 117.72,33.42 117.59,33.55 117.28,33.55 117.15,33.41 117.15,33.24 117.45,32.94 117.45,32.52 117.12,32.2 116.69,32.2 116.24,32.65 115.18,32.65 115.02,32.49 115.02,32.23 115.18,32.07 115.42,32.07 v2(115.52,32.17)
DDR_B_DQS#4: length 90.1
  TOP w0.089: v2(177.22,49.7) CPU1.AC9
  TOP w0.14: v2(114.52,63.38) 114.44,63.31 114.36,63.31 114.28,63.39 114.28,63.63 114.46,63.81 114.74,63.81 115.01,64.08 116.18,64.08 117.04,63.21 117.04,62.1 117.73,61.42 117.82,61.42 118.06,61.17 JDIMM3.177
  IN4 w0.089: v2(177.22,49.7) 176.85,50.07 175.65,50.07 175.35,50.36 169,50.36 167,52.37 166.51,52.37 162.57,56.31 161.95,56.31
  IN4 w0.147: 161.95,56.31 157.7,56.31 152.29,61.72 143.53,61.72 137.58,67.67 134.16,67.67 134.03,67.54 134.03,67.34 133.77,67.08 132.55,67.08 132.29,67.34 132.29,67.54 132.16,67.67 131.26,67.67 130.24,68.69 126.59,68.69 125.83,67.93 125.38,67.93 124,66.56 119.74,66.56 119.36,66.18 119.36,65.79 118.97,65.4 118.58,65.4 118.32,65.14 118.32,64.74 117.73,64.15 117.2,64.15 117.07,64.28 116.07,64.28 115.83,64.04 115.01,64.04 114.77,64.28 114.31,64.28 114.2,64.18 114.2,63.52 114.34,63.38 v2(114.52,63.38)
  BOTTOM w0.14: v2(114.52,63.38) 114.4,63.38 113.91,62.89 112.89,62.89 112.57,63.2 112.35,63.2 112.21,63.06 112.21,62.27 112.28,62.2 112.65,62.2 112.89,61.96 112.89,61.51 112.56,61.17 JDIMM4.177
DDR_B_DQS#5: length 90.4
  TOP w0.089: v2(177.22,52.44) CPU1.W9
  TOP w0.14: JDIMM3.198 112.08,66.43 112.32,66.67 112.32,67.03 112.01,67.34 112.01,67.58 112.16,67.73 112.42,67.73 113.23,66.92 113.96,66.92 114.22,67.18 114.22,67.53 113.86,67.89 113.86,68.07 v2(114.01,68.23)
  IN4 w0.089: v2(177.22,52.44) 176.85,52.81 170.35,52.81 163.16,60 163.12,60
  IN4 w0.147: v2(114.01,68.23) 113.99,68.21 113.71,68.21 113.6,68.31 113.6,68.41 113.42,68.58 113.42,68.8 113.8,69.17 116.88,69.17 119.8,72.08 123.44,72.08 125.35,73.99 132.45,73.99 134.04,72.4 138.32,72.4 145.13,65.59 153.9,65.59 158.36,61.12 161.64,61.12 162.5,60.26 162.86,60.26 163.12,60
  BOTTOM w0.14: v2(114.01,68.23) 113.96,68.17 113.71,68.17 113.6,68.27 113.6,68.42 113.9,68.72 116.07,68.72 116.76,68.03 116.76,67.74 118.07,66.43 JDIMM4.198
DDR_B_DQS#6: length 93.1
  TOP w0.089: CPU1.R9 v2(177.22,55.2)
  TOP w0.14: v2(114.19,73.18) 114.06,73.05 113.91,73.05 113.78,73.18 113.78,73.39 114,73.6 116.14,73.6 117.64,72.1 117.64,71.9 117.87,71.67 JDIMM3.219
  IN4 w0.089: 165.57,63.02 165.59,63 165.63,63 167.41,61.22 167.41,59.32 167.63,59.1 171.14,55.59 174.71,55.59 175.04,55.92 175.45,55.92 175.81,55.56 176.86,55.56 v2(177.22,55.2)
  IN4 w0.147: v2(114.19,73.18) 113.97,73.18 113.77,73.38 113.77,73.79 114.15,74.17 116.29,74.17 121.74,79.62 124.98,79.62 126.94,81.58 129.09,81.58 130.13,80.54 133.97,80.54 134.35,80.16 136.02,80.16 142.53,73.66 143.92,73.66 144.38,73.21 144.38,72.87 144.06,72.56 144.06,72.13 146.69,69.5 155.46,69.5 159.97,64.99 163.25,64.99 164.1,64.13 164.47,64.13 165.57,63.02
  BOTTOM w0.14: v2(114.19,73.18) 114.04,73.02 114.04,72.67 113.82,72.45 112.49,72.45 112.31,72.63 112.02,72.63 111.95,72.56 111.95,72.17 111.46,71.67 JDIMM4.219
DDR_B_DQS#7: length 93.9
  TOP w0.089: CPU1.M9 v2(177.22,57.95)
  TOP w0.14: v2(115,79.29) 114.83,79.12 114.83,78.83 114.43,78.44 112.74,78.44 112.48,78.18 112.48,77.3 112.22,77.05 111.77,77.05 111.65,76.92 JDIMM3.240
  IN4 w0.089: 168.56,65.5 168.57,65.5 168.61,65.5 169.94,64.17 169.94,62.29 172.92,59.31 174.76,59.31 175.22,58.86 175.22,58.71 175.7,58.23 176.25,58.23 176.27,58.26 177.01,58.26 177.22,58.04 v2(177.22,57.95)
  IN4 w0.147: v2(115,79.29) 114.56,79.29 114.41,79.44 114.41,79.97 114.62,80.18 116.64,80.18 118.51,82.05 118.51,82.95 119.79,84.23 123.4,84.23 126.15,86.98 132.24,86.98 133.36,85.86 135.8,85.86 142.08,79.58 144.17,79.58 148.48,75.27 150.66,75.27 151.54,74.39 156.72,74.39 157.67,73.43 157.67,72.75 160.93,69.49 164.21,69.49 165.68,68.02 166.04,68.02 168.56,65.5
  BOTTOM w0.14: v2(115,79.29) 114.68,79.29 114.58,79.39 114.58,79.51 114.8,79.72 115.57,79.72 115.83,79.62 116.07,79.38 117.47,77.5 118.05,76.92 JDIMM4.240
DDR_B_DQS#8: length 87.3
  TOP w0.089: CPU1.AY9 v2(177.22,35.99)
  TOP w0.14: v2(114.55,37.77) 114.7,37.63 114.7,37.21 115.04,36.87 116.06,36.87 117.87,38.68 JDIMM3.95
  IN3 w0.089: v2(177.22,35.99) 176.85,36.37 175.72,36.37 175.3,36.78 175.3,37.32 174.66,37.96 174.41,37.96 174.23,38.14 173.81,38.14 173.53,37.86 172.8,37.86 172.76,37.82 172.75,37.82
  IN3 w0.17: v2(114.55,37.77) 114.68,37.64 114.68,37.25 115.09,36.84 118.74,36.84 119.19,37.29 119.19,38.07 119.6,38.49 123.56,38.49 124.07,38.99 124.07,41.01 125.59,42.53 140.64,42.53 141.18,41.99 146.44,41.99 150.27,38.16 151.55,38.16 151.72,37.99 151.72,37.81 152.02,37.5 152.86,37.5 153.17,37.81 153.17,38.53 153.29,38.65 153.89,38.65 154.02,38.53 154.02,37.81 154.32,37.5 155.16,37.5 155.46,37.81 155.46,38.53 155.59,38.65 156.19,38.65 156.31,38.53 156.31,37.81 156.61,37.5 157.41,37.5 157.71,37.81 157.71,38.47 157.84,38.6 159.6,38.6 160.04,38.16 171.42,38.16 171.76,37.82 172.75,37.82
  BOTTOM w0.14: JDIMM4.95 111.46,38.68 111.48,38.65 111.62,38.65 111.67,38.71 111.67,38.87 111.72,38.92 112.56,38.92 113.17,38.3 113.73,38.3 113.94,38.51 114.56,38.51 114.83,38.23 114.83,37.91 114.69,37.77 v2(114.55,37.77)
DDR_B_DRAMRST#: length 16.4
  TOP w0.102: RD15.2 104.96,41.07 CD124.1 105.49,42.46 106.71,42.46 CD123.1 107.73,41.93 107.9,42.11 v1(108.34,42.11) 109,42.11 109.18,41.92 JDIMM3.108 111.55,41.92 v2(111.91,41.57)
  IN3 w0.127: v2(111.91,41.57) 112.49,40.98 114.09,40.98 v2(114.62,41.51)
  BOTTOM w0.102: v2(114.62,41.51) 114.92,41.21 117.26,41.21 117.98,41.92 JDIMM4.108
DDR_B_MA0: length 82.1
  TOP w0.089: v2(177.3,44.22) 176.9,43.82 CPU1.AJ9
  TOP w0.203: v2(114.31,53.01) 113.72,52.42 112.09,52.42 111.5,51.82 111.5,51.02 111.4,50.92 JDIMM3.144
  IN4 w0.089: v2(177.3,44.22) 177.42,44.22 177.52,44.33 177.52,44.58 177.4,44.71 177.22,44.71 177.1,44.59 175.75,44.59 175.47,44.87 171.69,44.87 171.44,45.12 164.37,45.12 163.45,46.03 162.14,46.03
  IN4 w0.208: v2(114.31,53.01) 114.05,53.27 114.05,53.44 114.2,53.58 120.05,53.58 120.31,53.32 125.51,53.32 125.84,53.65 126.01,53.82 128.11,53.82 128.11,53.82 128.49,53.82 128.49,53.82 128.82,53.82 129.2,53.82 129.2,53.82 129.54,53.82 130.05,53.82 130.18,53.69 130.18,53.58 130.31,53.45 130.92,53.45 131.04,53.58 131.04,53.69 131.17,53.82 131.68,53.82 131.8,53.69 131.8,53.56 131.93,53.44 132.47,53.44 132.59,53.56 132.59,53.69 132.72,53.82 136.52,53.82 136.69,53.64 136.69,53.47 136.81,53.36 137.52,53.36 139.77,51.1 148.25,51.1 153.32,46.03 162.14,46.03
  BOTTOM w0.203: v2(114.31,53.01) 115.08,53.78 116.29,53.78 118,52.07 118,51.01 118.09,50.92 JDIMM4.144
DDR_B_MA1: length 80.6
  TOP w0.089: CPU1.AK6 174.94,43.06 v2(174.62,42.75)
  TOP w0.203: JDIMM3.133 117.91,48.17 117.08,49 115.01,49 114.88,48.88 113.27,48.88 112.58,48.19 v2(112.58,48.13)
  IN4 w0.089: 161.7,40.44 162.38,40.44 163.03,41.09 163.03,41.55 163.41,41.93 173.39,41.93 173.81,42.35 174.22,42.35 v2(174.62,42.75)
  IN4 w0.208: 161.7,40.44 154.06,40.44 153.43,41.08 146.37,41.08 144.03,43.42 144.03,43.76 144.03,44.28 142.24,46.07 137.38,46.07 136.21,47.24 134.11,47.24 133.66,46.8 131.23,46.8 130.81,47.21 125,47.21 123.89,48.32 121.34,48.32 120.82,48.83 119.9,48.83 119.71,49.02 115.68,49.02 115.55,49.14 112.45,49.14 112.32,49.02 112.32,48.25 112.45,48.13 v2(112.58,48.13)
  BOTTOM w0.203: v2(112.58,48.13) 113.09,48.63 113.09,48.84 112.86,49.07 112.58,49.07 111.69,48.17 JDIMM4.133
DDR_B_MA2: length 79.3
  TOP w0.089: v2(173.96,42.76) 174.29,43.09 CPU1.AK5
  TOP w0.203: v2(115.9,49.64) 115.89,49.64 115.58,49.32 114.89,49.32 114.75,49.18 112.81,49.18 111.55,47.92 JDIMM3.132
  IN4 w0.089: v2(173.96,42.76) 173.72,42.76 173.68,42.72 173.68,42.46 173.33,42.12 163.2,42.12 162.57,41.49 162.57,40.98
  IN4 w0.208: v2(115.9,49.64) 115.97,49.57 119.94,49.57 120.13,49.38 121.05,49.38 121.57,48.87 124.12,48.87 124.81,48.18 125.19,48.18 125.33,48.04 125.33,47.89 125.45,47.76 126.13,47.76 126.26,47.89 126.26,48.2 126.38,48.32 131.18,48.32 131.49,48.01 131.49,47.56 131.69,47.35 133.44,47.35 133.88,47.79 134.12,47.79 134.65,48.32 135.75,48.32 135.84,48.24 136.26,48.24 137.84,46.65 142.44,46.65 144.97,44.12 144.97,43.83 144.84,43.7 144.84,43.4 145.13,43.11 145.43,43.11 145.56,43.24 145.85,43.24 146.15,42.94 146.15,42.65 146.02,42.52 146.02,42.22 146.31,41.93 146.61,41.93 146.74,42.06 147.03,42.06 147.46,41.63 153.65,41.63 154.29,40.99 159.15,40.99 159.28,41.12 159.28,41.23 159.4,41.36 159.92,41.36 160.05,41.23 160.05,41.12 160.18,40.99 160.68,40.99 160.81,41.12 160.81,41.22 160.94,41.35 161.41,41.35 161.54,41.22 161.54,40.98 161.66,40.85 162.44,40.85 162.57,40.98
  BOTTOM w0.203: v2(115.9,49.64) 115.89,49.64 115.44,49.19 115.44,48.95 115.74,48.65 116.17,48.65 116.37,48.85 116.37,49.13 116.58,49.33 116.98,49.33 117.68,48.63 117.68,48.14 117.89,47.92 JDIMM4.132
DDR_B_MA3: length 79.6
  TOP w0.089: v2(173.96,41.97) 174.29,42.3 CPU1.AL5
  TOP w0.203: JDIMM3.131 117.98,47.68 116.95,48.7 115.13,48.7 115.01,48.57 113.99,48.57 113.85,48.43 v2(113.85,48.13)
  IN4 w0.089: v2(173.96,41.97) 173.96,41.82 173.87,41.72 172.57,41.72 172.44,41.6 172.44,41.38 172.32,41.26 172.11,41.26 171.99,41.38 171.99,41.59 171.88,41.7 171.72,41.7 171.61,41.59 171.61,41.2 171.51,41.1 163.94,41.1
  IN4 w0.208: v2(113.85,48.13) 113.85,48.48 113.96,48.58 115.31,48.58 115.42,48.47 119.48,48.47 120.6,47.36 124.07,47.36 124.77,46.66 130.58,46.66 131,46.25 133.89,46.25 134.33,46.69 135.94,46.69 137.11,45.51 142.02,45.51 143.48,44.05 143.48,43.76 143.48,43.19 146.14,40.53 153.2,40.53 153.83,39.89 162.31,39.89 162.57,40.15 163.48,40.15 163.61,40.28 163.61,40.77 163.94,41.1
  BOTTOM w0.203: JDIMM4.131 112.44,47.68 112.82,47.29 112.82,46.34 113.08,46.09 113.34,46.09 113.6,46.34 113.6,47.87 v2(113.85,48.13)
DDR_B_MA4: length 79.8
  TOP w0.089: CPU1.AL6 174.94,42.3 v2(174.61,41.97)
  TOP w0.203: v2(116.86,47.98) 116.83,48 116.83,48.18 116.62,48.39 115.26,48.39 114.97,48.1 114.97,47.86 114.69,47.58 113.41,47.58 113.13,47.3 112.82,47.3 112.46,47.66 112.03,47.66 111.75,47.39 111.75,47.07 111.61,46.92 JDIMM3.128
  IN4 w0.089: v2(174.61,41.97) 174.88,41.97 175.01,41.84 175.01,41.65 174.88,41.52 172.98,41.52 172.85,41.39 172.85,41.02 172.72,40.89 169.6,40.89 169.47,40.76 164.79,40.76
  IN4 w0.208: v2(116.86,47.98) 116.92,47.91 119.26,47.91 120.38,46.79 123.85,46.79 124.54,46.11 130.35,46.11 130.77,45.7 134.12,45.7 134.56,46.14 135.66,46.14 136.87,44.93 141.82,44.93 142.92,43.83 142.92,42.97 145.92,39.97 152.97,39.97 153.61,39.34 162.28,39.34 162.64,39.69 163.72,39.69 164.04,40.01 164.04,40.61 164.18,40.76 164.78,40.76 164.79,40.76
  BOTTOM w0.203: v2(116.86,47.98) 116.83,47.95 116.83,47.6 116.7,47.47 115.23,47.47 115.05,47.28 115.05,46.93 115.21,46.77 116.98,46.77 117.38,47.17 117.75,47.17 117.99,46.92 JDIMM4.128
DDR_B_MA5: length 80.1
  TOP w0.089: CPU1.AM6 174.94,41.46 v2(174.61,41.13)
  TOP w0.203: v2(115.46,47.93) 115.93,47.45 115.93,47.25 115.81,47.13 113.39,47.13 112.42,46.16 111.82,46.16 111.55,46.42 JDIMM3.126
  IN4 w0.089: 165.03,40.44 169.6,40.44 169.84,40.68 174.54,40.68 174.61,40.76 v2(174.61,41.13)
  IN4 w0.208: 165.03,40.44 165.01,40.43 164.62,40.43 164.49,40.3 164.49,39.52 164.25,39.28 162.8,39.28 162.31,38.79 153.38,38.79 152.74,39.42 145.69,39.42 142.37,42.74 142.37,43.61 141.64,44.33 136.61,44.33 135.8,45.14 126.2,45.14 125.88,45.47 124.37,45.47 123.59,46.24 120.15,46.24 119.03,47.36 115.59,47.36 115.46,47.5 v2(115.46,47.93)
  BOTTOM w0.203: JDIMM4.126 114.2,46.42 114.03,46.59 114.03,47.48 114.19,47.65 114.68,47.65 115.1,48.06 115.32,48.06 v2(115.46,47.93)
DDR_B_MA6: length 80.7
  TOP w0.089: CPU1.AN7 v2(175.92,41.48)
  TOP w0.203: JDIMM3.127 113.69,46.68 v2(112.63,45.62)
  IN4 w0.089: 165.75,40.14 169.71,40.14 170.08,40.5 174.66,40.5 175.32,41.17 175.61,41.17 v2(175.92,41.48)
  IN4 w0.208: 165.75,40.14 164.49,38.88 163.15,38.88 162.5,38.24 153.15,38.24 152.51,38.87 145.46,38.87 141.82,42.52 141.82,43.38 141.44,43.75 136.41,43.75 135.57,44.59 125.97,44.59 125.65,44.91 124.14,44.91 123.36,45.69 119.92,45.69 118.81,46.81 112.73,46.81 112.53,46.6 112.53,45.72 v2(112.63,45.62)
  BOTTOM w0.203: JDIMM4.127 111.4,46.68 111.9,47.18 112.3,47.18 112.43,47.05 112.43,45.82 v2(112.63,45.62)
DDR_B_MA7: length 80.2
  TOP w0.089: CPU1.AN10 v2(177.87,41.48)
  TOP w0.203: JDIMM3.122 111.93,45.42 112.21,45.14 115.2,45.14 v2(115.43,45.38)
  IN4 w0.089: 161.95,37.13 162.4,37.13 163.45,38.18 164.89,38.18 166.12,39.4 169.82,39.4 170.46,40.05 174.7,40.05 175.42,40.76 176.06,40.76 176.41,41.11 177.67,41.11 177.87,41.31 v2(177.87,41.48)
  IN4 w0.208: 161.95,37.13 152.51,37.13 152.38,37.26 152.38,37.45 152.25,37.57 151.67,37.57 151.55,37.45 151.55,37.26 151.42,37.13 150.84,37.13 150.71,37.26 150.71,37.64 150.59,37.77 150.01,37.77 149.88,37.64 149.88,37.26 149.75,37.13 149.19,37.13 149.06,37.26 149.06,37.64 148.94,37.77 145,37.77 140.14,42.63 134.73,42.63 134.25,43.11 125.86,43.11 125.19,43.78 123.72,43.78 123.34,44.16 119.9,44.16 118.35,45.71 115.76,45.71 v2(115.43,45.38)
  BOTTOM w0.203: JDIMM4.122 117.61,45.42 117.43,45.6 117.43,45.91 117.31,46.03 116.79,46.03 116.57,45.8 115.99,45.8 115.76,46.03 115.39,46.03 115.27,45.91 115.27,45.53 v2(115.43,45.38)
DDR_B_MA8: length 78.7
  TOP w0.089: CPU1.AN8 v2(176.57,41.48)
  TOP w0.203: v2(114.08,45.6) 114.65,46.17 JDIMM3.125
  IN4 w0.089: 165.98,39.77 169.76,39.77 170.27,40.28 174.68,40.28 175.35,40.94 175.99,40.94 176.53,41.48 v2(176.57,41.48)
  IN4 w0.208: v2(114.08,45.6) 114.06,45.63 114.06,46.06 114.26,46.26 118.58,46.26 120.13,44.71 123.57,44.71 123.94,44.33 125.42,44.33 125.72,44.03 135.28,44.03 136.13,43.18 140.37,43.18 145.23,38.32 152.28,38.32 152.92,37.68 162.57,37.68 163.34,38.45 164.66,38.45 165.98,39.77
  BOTTOM w0.203: JDIMM4.125 111.73,46.17 111.93,45.97 111.93,45.61 112.48,45.07 114.24,45.07 114.33,45.17 114.33,45.35 v2(114.08,45.6)
DDR_B_MA9: length 83.1
  TOP w0.089: CPU1.AR11 v2(178.52,39.65)
  TOP w0.203: v2(113.2,43.69) 113.91,44.41 116.65,44.41 117.41,45.17 JDIMM3.121
  IN4 w0.089: v2(178.52,39.65) 177.97,40.2 176.48,40.2 176.28,40.4 175.56,40.4 174.75,39.59 174.57,39.59 174.11,39.14 171.09,39.14 170.3,38.35 168.17,38.35 166.97,37.15 164.53,37.15 163.41,36.03 163.1,36.03
  IN4 w0.208: 163.1,36.03 144.94,36.03 139.87,41.1 132.04,41.1 131.14,42 125.2,42 124.55,42.65 119.85,42.65 117.89,44.6 115.9,44.6 115.79,44.72 113.95,44.72 113.2,43.97 v2(113.2,43.69)
  BOTTOM w0.203: JDIMM4.121 111.58,45.17 112.02,44.74 113.67,44.74 113.85,44.56 113.85,44.35 v2(113.2,43.69)
DDR_B_MA10: length 80.7
  TOP w0.089: v2(175.96,45.14) 175.63,44.68 CPU1.AH7
  TOP w0.203: JDIMM3.146 112.4,53.43 112.75,53.78 115.8,53.78 v2(116.71,54.68)
  IN4 w0.089: v2(175.96,45.14) 175.96,45.4 175.9,45.46 175.46,45.46 175.39,45.38 175.39,45.31 175.3,45.22 171.95,45.22 171.87,45.3 171.87,45.47 171.8,45.55 164.51,45.55 163.5,46.56 162.82,46.56 162.69,46.69 162.69,47
  IN4 w0.208: v2(116.71,54.68) 120.51,54.68 120.77,54.43 125.04,54.43 125.96,55.35 131.06,55.35 131.18,55.23 131.18,55.06 131.32,54.92 131.88,54.92 132.02,55.06 132.02,55.51 132.15,55.63 132.82,55.63 132.93,55.52 132.93,55.07 133.08,54.92 137.58,54.92 140.3,52.2 143.54,52.2 143.67,52.33 143.67,52.8 143.79,52.93 144.37,52.93 144.49,52.8 144.49,52.33 144.62,52.2 145.11,52.2 145.24,52.33 145.24,52.8 145.37,52.93 145.94,52.93 146.07,52.8 146.07,52.33 146.2,52.2 146.78,52.2 146.9,52.33 146.9,52.8 147.03,52.93 147.63,52.93 147.76,52.8 147.76,52.33 147.88,52.2 148.71,52.2 153.78,47.13 162.55,47.13 162.69,47
  BOTTOM w0.203: JDIMM4.146 118.12,53.43 117.79,53.09 117.51,53.09 117.29,53.31 117.29,53.51 117.49,53.72 117.49,53.88 117.33,54.05 116.56,54.05 116.44,54.16 116.44,54.43 116.69,54.68 v2(116.71,54.68)
DDR_B_MA11: length 83.8
  TOP w0.089: CPU1.AN11 v2(178.52,41.48)
  TOP w0.203: v2(116.1,45.24) 116.1,45.25 115.64,44.79 111.97,44.79 111.83,44.92 JDIMM3.120
  IN4 w0.089: 163.21,36.58 163.54,36.58 164.35,37.39 166.71,37.39 167.98,38.66 169.49,38.66 170.69,39.86 174.77,39.86 175.49,40.59 176.13,40.59 176.49,40.94 177.98,40.94 v2(178.52,41.48)
  IN4 w0.208: v2(116.1,45.24) 116.18,45.16 118.12,45.16 120.05,43.23 124.75,43.23 125.43,42.55 132.01,42.55 132.14,42.42 132.14,41.78 132.27,41.65 132.97,41.65 133.1,41.78 133.1,42.42 133.23,42.55 133.99,42.55 134.47,42.08 139.85,42.08 145.35,36.58 145.8,36.58 145.93,36.71 145.93,37.09 146.05,37.22 146.62,37.22 146.75,37.09 146.75,36.71 146.88,36.58 147.46,36.58 147.59,36.71 147.59,37.09 147.72,37.22 148.3,37.22 148.43,37.09 148.43,36.71 148.56,36.58 163.21,36.58
  BOTTOM w0.203: JDIMM4.120 117.82,44.92 117.66,44.76 117.66,44.36 117.54,44.23 115.22,44.23 115.1,44.36 115.1,44.76 115.22,44.89 115.98,44.89 116.11,45.02 116.11,45.23 v2(116.1,45.24)
DDR_B_MA12: length 80.1
  TOP w0.089: CPU1.AR10 v2(177.87,39.65)
  TOP w0.203: v2(114.42,43.57) 114.42,43.83 114.62,44.03 117.01,44.03 117.66,44.68 JDIMM3.119
  IN4 w0.089: 163.1,35.48 163.34,35.48 164.76,36.9 167.12,36.9 168.29,38.07 170.82,38.07 171.68,38.93 174.16,38.93 174.57,39.34 174.76,39.34 175.64,40.22 176.2,40.22 176.4,40.02 177.5,40.02 v2(177.87,39.65)
  IN4 w0.208: 163.1,35.48 144.71,35.48 139.64,40.55 130.43,40.55 129.92,41.05 125.24,41.05 124.2,42.1 119.62,42.1 117.67,44.05 115.57,44.05 115.51,44.11 114.65,44.11 114.42,43.89 v2(114.42,43.57)
  BOTTOM w0.203: v2(114.42,43.57) 114.08,43.22 112.53,43.22 111.92,43.83 111.92,44.33 111.58,44.68 JDIMM4.119
DDR_B_MA13: length 82.2
  TOP w0.089: CPU1.AF9 v2(177.22,46.97)
  TOP w0.203: JDIMM3.158 111.5,56.43 111.85,56.77 111.85,57.06 113.29,58.5 115.74,58.5 116.05,58.81 116.05,58.89 v2(116.19,59.03)
  IN4 w0.089: v2(177.22,46.97) 176.86,47.33 175.8,47.33 175.77,47.3 172.26,47.3 171.94,47.63 171.94,47.63 171.83,47.73 166.62,47.73 164,50.36
  IN4 w0.208: 164,50.36 162.57,51.78 155.19,51.78 149.76,57.21 141.35,57.21 139.06,59.49 137.4,59.49 137.23,59.65 136.1,59.65 135.08,60.67 132.91,60.67 132.78,60.8 132.78,61.03 132.66,61.16 132,61.16 131.87,61.03 131.87,60.8 131.74,60.68 131.02,60.68 130.9,60.8 130.9,61.03 130.77,61.16 126.74,61.16 125.72,60.13 124.39,60.13 124.16,59.91 119.81,59.91 118.93,59.03 v2(116.19,59.03)
  BOTTOM w0.203: JDIMM4.158 117.92,56.43 117.32,57.03 117.32,57.37 117.6,57.65 117.6,57.99 117.36,58.23 117.03,58.23 116.51,57.72 116.24,57.72 115.73,58.22 115.73,58.45 116.19,58.91 v2(116.19,59.03)
DDR_B_MA14: length 78.5
  TOP w0.089: CPU1.AH11 v2(178.52,45.14)
  TOP w0.203: v2(116.5,56.32) 117.69,55.14 117.69,54.91 117.92,54.68 JDIMM3.151
  IN4 w0.089: 163.45,47.99 163.84,47.6 163.84,46.99 164.65,46.18 172.04,46.18 172.47,45.75 174.74,45.75 174.97,45.99 176.17,45.99 176.48,45.69 177.97,45.69 v2(178.52,45.14)
  IN4 w0.208: 163.45,47.99 162.65,48.79 154.47,48.79 148.67,54.58 140.29,54.58 138.27,56.6 134.49,56.6 133.55,57.54 125.81,57.54 124.73,56.46 120.61,56.46 120.59,56.44 116.62,56.44 v2(116.5,56.32)
  BOTTOM w0.203: JDIMM4.151 111.71,54.68 112.23,55.19 113.43,55.19 113.93,55.68 115.93,55.68 116.5,56.26 v2(116.5,56.32)
DDR_B_MA15: length 83.4
  TOP w0.089: CPU1.AF8 v2(176.58,46.97)
  TOP w0.203: JDIMM3.156 112.28,55.92 112.54,56.18 113.49,56.18 113.7,56.39 v2(113.7,56.97)
  IN4 w0.089: 163.4,50.15 166.22,47.33 171.73,47.33 172.14,46.92 175.39,46.92 175.7,46.6 176.15,46.6 176.51,46.97 v2(176.58,46.97)
  IN4 w0.208: 163.4,50.15 162.85,50.71 154.74,50.71 149.32,56.13 140.9,56.13 138.62,58.42 136.95,58.42 136.79,58.58 134.88,58.58 134.21,59.25 134.21,59.47 134.08,59.6 133.38,59.6 133.25,59.47 133.25,59.27 133.13,59.14 132.49,59.14 132.36,59.27 132.36,59.47 132.24,59.6 131.63,59.6 131.5,59.47 131.5,59.24 131.37,59.11 130.77,59.11 130.65,59.24 130.65,59.53 130.52,59.66 126.74,59.66 126.62,59.53 126.62,59.22 126.49,59.09 125.16,59.09 124.5,58.43 119.85,58.43 119.38,57.95 113.39,57.95 113.26,57.83 113.26,57.49 113.39,57.36 113.57,57.36 113.7,57.23 v2(113.7,56.97)
  BOTTOM w0.203: JDIMM4.156 117.57,55.92 117.28,56.22 117.28,56.64 116.75,57.17 116.15,57.17 115.48,57.84 114.57,57.84 v2(113.7,56.97)
DDR_B_MA16: length 82.9
  TOP w0.089: CPU1.AH10 v2(177.87,45.14)
  TOP w0.203: v2(115.26,56.32) 115.26,56.88 115.02,57.11 114.62,57.11 114.36,56.86 114.36,56.09 114.01,55.74 112.83,55.74 112.02,54.92 JDIMM3.152
  IN4 w0.089: 163.29,47.63 163.53,47.39 163.53,47.05 164.62,45.96 172.02,45.96 172.4,45.58 174.81,45.58 175.05,45.81 176.1,45.81 176.4,45.51 177.5,45.51 v2(177.87,45.14)
  IN4 w0.208: 163.29,47.63 162.68,48.24 154.24,48.24 148.45,54.03 140.06,54.03 138.04,56.05 134.26,56.05 133.32,56.99 128.36,56.99 127.84,56.46 125.51,56.46 124.96,55.91 120.84,55.91 120.72,55.79 115.51,55.79 115.26,56.04 v2(115.26,56.32)
  BOTTOM w0.203: JDIMM4.152 117.58,54.92 116.98,55.53 116.98,56.51 116.62,56.87 114.77,56.87 114.54,56.63 114.54,56.35 114.73,56.16 115.09,56.16 v2(115.26,56.32)
DDR_B_ODT0: length 78.8
  TOP w0.089: CPU1.AF7 v2(175.95,46.97)
  IN4 w0.089: v2(175.95,46.97) 175.82,47.1 172.22,47.1 171.76,47.56 166.4,47.56 163.71,50.25
  IN4 w0.178: v2(112.44,56.92) 112.44,56.03 112.25,55.84 111.74,55.84 111.55,56.03 111.55,58.25 111.79,58.49 119.15,58.49 120.03,59.37 123.45,59.37 123.58,59.24 123.58,59.09 123.71,58.96 124.28,58.96 124.4,59.09 124.4,59.24 124.79,59.63 125.93,59.63 126.48,60.19 130.79,60.19 130.84,60.14 134.85,60.14 135.56,59.43 135.87,59.12 137.01,59.12 137.17,58.96 138.84,58.96 141.13,56.67 149.54,56.67 154.96,51.25 162.71,51.25 163.71,50.25
  BOTTOM w0.165: JDIMM4.155 111.96,55.68 112.44,56.15 v2(112.44,56.92)
DDR_B_ODT1: length 79.2
  TOP w0.089: CPU1.AE8 v2(176.57,47.88)
  IN4 w0.089: v2(176.57,47.88) 176.5,47.88 176.14,48.24 175.84,48.24 175.43,47.84 172.52,47.84 172.09,48.27 167.24,48.27 165.13,50.38
  IN4 w0.178: 165.13,50.38 162.23,53.28 156.47,53.28 151.04,58.71 142.28,58.71 139.47,61.52 139.03,61.52 138.88,61.67 138.88,62.11 137.87,63.11 126.88,63.11 126.47,63.52 125.65,63.52 123.54,61.41 119.26,61.41 118.75,60.9 117.24,60.9 116.38,60.04 114.17,60.04 114.05,59.93 112.46,59.93 112.31,59.77 112.31,59.2 112.45,59.07 v2(113.65,59.07)
  BOTTOM w0.165: v2(113.65,59.07) 113.58,59.07 111.69,57.17 JDIMM4.161
DDR_B_ODT2: length 79.7
  TOP w0.089: CPU1.AE9 v2(177.22,47.88)
  TOP w0.165: v2(116.17,60.53) 116.71,59.98 116.71,56.9 117.93,55.68 JDIMM3.155
  IN4 w0.089: 165.31,50.62 167.49,48.45 172.17,48.45 172.6,48.02 175.36,48.02 175.76,48.42 176.21,48.42 176.38,48.25 176.71,48.25 176.81,48.15 176.89,48.15 176.99,48.25 177.33,48.25 177.41,48.17 177.41,48.07 v2(177.22,47.88)
  IN4 w0.178: 165.31,50.62 162.17,53.77 156.67,53.77 151.25,59.19 142.48,59.19 138.07,63.6 137.51,63.6 137.38,63.72 137.38,63.91 137.25,64.04 136.69,64.04 136.57,63.91 136.57,63.72 136.44,63.6 135.87,63.6 135.74,63.72 135.74,63.91 135.62,64.04 134.36,64.04 134.23,63.91 134.23,63.72 134.1,63.6 133,63.6 132.87,63.72 132.87,63.89 132.72,64.04 131.57,64.04 131.42,63.89 131.42,63.72 131.3,63.6 130.36,63.6 130.23,63.72 130.23,63.91 130.1,64.04 125.49,64.04 123.34,61.89 120.09,61.89 119.66,62.31 119.48,62.31 118.55,61.38 116.45,61.38 116.05,60.99 116.05,60.64 v2(116.17,60.53)
DDR_B_ODT3: length 79.4
  TOP w0.089: CPU1.AE11 v2(178.52,47.88)
  TOP w0.165: JDIMM3.161 117.78,57.17 116.98,57.98 116.98,60.44 116.37,61.04 115.96,61.04 115.52,60.61 v2(115.52,60.5)
  IN4 w0.089: 162.98,53.43 165.72,50.69 167.79,48.62 172.24,48.62 172.67,48.19 175.29,48.19 175.69,48.6 176.28,48.6 176.45,48.43 177.97,48.43 v2(178.52,47.88)
  IN4 w0.178: v2(115.52,60.5) 115.52,61.15 116.24,61.87 118.35,61.87 119.33,62.85 123.62,62.85 125.29,64.52 137.83,64.52 142.68,59.67 151.45,59.67 156.87,54.25 162.17,54.25 162.98,53.43
DDR_B_PARITY: length 83.6
  TOP w0.089: CPU1.AJ7 175.8,43.77 v2(176.13,44.22)
  TOP w0.203: v2(115.81,52.98) 115.81,52.53 117.67,50.68 JDIMM3.143
  IN4 w0.089: v2(176.13,44.22) 175.86,44.22 175.39,44.69 171.62,44.69 171.42,44.89 165.49,44.89 165.36,44.76 164.38,44.76 163.96,45.18 162.86,45.18
  IN4 w0.208: 162.86,45.18 162.56,45.48 153.07,45.48 152.66,45.89 152.34,45.89 151.93,45.49 151.46,45.49 151.18,45.77 151.19,45.95 151.82,46.58 151.82,46.76 151.41,47.17 151.23,47.17 150.6,46.53 150.42,46.53 150.01,46.94 150.01,47.12 150.64,47.76 150.64,47.94 150.23,48.35 150.05,48.35 149.42,47.71 149.24,47.71 148.83,48.12 148.83,48.3 149.46,48.93 149.46,49.11 149.05,49.53 148.87,49.53 148.24,48.9 148.06,48.9 147.66,49.31 147.66,49.49 148.04,49.87 148.04,50.05 147.63,50.46 147.45,50.46 147.12,50.13 146.82,50.13 146.4,50.55 139.55,50.55 137.31,52.79 134.15,52.79 134.03,52.92 134.03,53.13 133.9,53.26 133.15,53.26 133.02,53.13 133.02,52.92 132.9,52.79 132.1,52.79 132.01,52.88 125.86,52.88 125.85,52.88 125.74,52.77 120.08,52.77 119.82,53.03 115.86,53.03 v2(115.81,52.98)
  BOTTOM w0.203: JDIMM4.143 111.39,50.68 112.23,51.51 113.06,51.51 114.08,52.53 115.35,52.53 v2(115.81,52.98)
DDR_PG_CTRL: length 159.2
  TOP w0.089: CPU1.BT13 179.79,24.01 179.79,22.46
  TOP w0.102: v2(46.95,11.51) UD1.2 45,11.51 44.87,11.39 v3(44.37,11.39) ; v2(179.4,17.19) 179.33,17.19 178.63,17.89 178.63,18.15 178.34,18.44 178.34,21.01 179.79,22.46
  IN3 w0.127: v2(179.4,17.19) 179.11,16.9 179.11,15.8 177.3,13.99 174.29,13.99 171,10.7 166.37,10.7 164.82,12.25 164.82,12.78 163.94,13.67 159.91,13.67 159.22,14.37 156.29,14.37 155.71,14.95 155.71,15.82 155.71,16.03 155.28,16.47 154.62,16.47 154.62,16.47 154.04,16.47 154.03,16.47 147.24,16.47 144.25,13.48 140.94,13.48 136.56,9.1 135.07,9.1 133.79,10.38 110.01,10.38 106.95,13.44 95.14,13.44 91.67,16.91 75.1,16.91 74.27,17.74 65.77,17.74 63.67,15.64 57.57,15.64 56.43,14.5 53.38,14.5 52.3,13.42 52.3,13.09 51.36,12.15 47.59,12.15 v2(46.95,11.51)
DDR_RCOMP0: length 5
  TOP w0.254: CPU1.G1 171.69,61.29 170.41,62.57 170.41,62.95
  TOP w0.381: RD18.2 169.9,63.46 170.41,62.95
DDR_RCOMP1: length 4.5
  TOP w0.254: CPU1.H1 171.52,60.27 169.92,61.86 169.71,61.86
  TOP w0.381: 169.71,61.86 168.45,61.86 RD21.2
DDR_RCOMP2: length 5.3
  TOP w0.254: 169.11,61.34 v1(169.6,61.34) 169.97,61.34 171.42,59.89 172.26,59.89 CPU1.J2
  TOP w0.381: RD22.2 168.04,60.41 168.97,61.34 169.11,61.34
DDR_XDP_WAN_SMBCLK: length 421.1
  TOP w0.102: v2(110.23,128.84) 110.02,128.62 QH4.1 ; JDIMM3.253 120.71,80.18 121.33,80.79 121.33,82.25 v2(121.53,82.46) ; U88.1 v1(6.06,47.24) 6.06,47.75 v2(6.6,48.28) R502.2 ; JDIMM1.253 131.83,80.18 131.74,80.27 131.74,82.51 131.54,82.71 131.54,82.79 131.1,83.23 131.01,83.23 130.34,83.9 128.25,83.9 127.42,83.08 v2(127.42,82.44) ; v2(156.36,7.64) 156.48,7.52 157.01,7.52 157.36,7.17 JXDP1.53
  IN1 w0.109: v2(107.22,78.86) 107.22,79.45 108.12,80.35 115.29,80.35 118.34,83.4 121.07,83.4 121.45,83.01 121.45,82.53 v2(121.53,82.46) ; v2(106.05,11.39) 106.13,11.31 107.28,11.31 109.2,9.39 109.2,7.69 111.95,4.94 125.38,4.94 139.61,4.94 141.05,6.37 141.05,6.96 141.9,7.81 152.79,7.81 153.04,8.06 155.68,8.06 156.1,7.64 v2(156.36,7.64)
  IN3 w0.127: v2(106.05,11.39) 105.92,11.26 92.32,11.26 89.56,14.02 80.89,14.02 80.42,14.48 68.94,14.48 66.98,12.53 60.8,12.53 59.49,11.22 57.55,11.22 56.09,9.76 49.66,9.76 49.58,9.68 45.76,9.68 45.44,9.36 40.53,9.36 39.02,7.86 28.77,7.86 25.34,4.43 18.36,4.43 16.54,6.25 16.54,7.85 15.43,8.96 15.43,10.39 8.43,17.39 8.43,31 4.09,35.34 4.09,43.67 4.64,44.21 4.64,46.32 v2(6.6,48.28) ; v2(127.42,82.44) 126.85,83.01 126.53,83.01 125.33,81.81 121.71,81.81 121.53,81.99 v2(121.53,82.46) ; v2(110.23,128.84) 107.87,128.84 107.74,128.97 107.74,129.81 107.87,129.94 110.28,129.94 110.41,130.07 110.41,130.32 109.83,130.89 105.96,130.89 105.91,130.84 104.32,130.84 v2(104.15,130.68)
  IN4 w0.109: v2(106.05,11.39) 106.1,11.34 106.1,11.34 109.94,15.17 109.94,32.27 109.25,32.96 108.17,32.96 104.72,36.41 104.72,47.92 104.29,48.36 104.29,51.73 105.48,52.92 105.48,55.01 103.66,56.83 103.66,63.78 105.83,65.94 105.83,73.65 106.01,73.83 106.01,75.55 106.83,76.36 106.83,77.99 107.39,78.55 107.39,78.69 v2(107.22,78.86)
  BOTTOM w0.102: v2(104.15,130.68) 103.98,130.86 103.71,130.86 103.53,130.68 103.53,130.4 104.42,129.51 104.42,123.29 104.07,122.93 104.07,120.46 104.32,120.21 104.32,118.9 103.84,118.42 103.84,116.54 103.51,116.21 103.51,112.24 97.47,106.2 97.47,102.43 98.91,100.99 98.91,96.34 94.64,92.08 94.64,88.62 96.12,87.14 96.12,82.64 100.63,78.13 107.05,78.13 107.42,78.5 107.42,78.66 v2(107.22,78.86) 107.22,79.9 107.09,80.03 106.72,80.03 106.6,79.9 106.6,78.93 106.47,78.8 105.49,78.8 105.36,78.93 105.36,79.19 105.49,79.32 105.96,79.32 106.09,79.45 106.09,79.74 105.96,79.86 105.55,79.86 105.43,79.99 105.43,80.28 105.55,80.41 107.5,80.41 107.62,80.28 107.62,79.71 107.75,79.59 107.99,79.59 108.12,79.71 108.12,80.05 108.25,80.18 108.5,80.18 108.63,80.05 108.63,79.84 108.75,79.71 109.01,79.71 109.14,79.84 109.14,80.05 109.26,80.18 JDIMM4.253 ; v2(127.42,82.44) 127.42,82.13 127.2,81.9 126.8,81.9 126.36,81.46 126.36,81.06 125.47,80.18 JDIMM2.253
DDR_XDP_WAN_SMBDAT: length 420.7
  TOP w0.102: U88.4 4.56,47.11 v1(4.08,47.6) v2(3.39,48.28) 3.84,48.73 R501.2 ; QH4.4 107.87,127.62 108.23,127.98 110.03,127.98 v2(110.88,128.83) ; v2(107.84,78.86) 107.84,79.2 107.71,79.33 106.68,79.33 106.56,79.2 106.56,78.54 106.68,78.42 107.41,78.42 107.54,78.29 107.54,78.05 107.41,77.92 106.19,77.92 106.06,78.05 106.06,79.65 106.19,79.78 108.12,79.78 108.25,79.9 108.25,80.11 108.13,80.22 107.55,80.22 107.42,80.35 107.42,80.67 107.55,80.79 108.63,80.79 108.75,80.67 108.75,79.97 108.88,79.84 109.01,79.84 109.14,79.97 109.14,80.3 109.26,80.43 JDIMM3.254 ; JXDP1.51 156.86,5.65 156.93,5.72 156.93,6.99 156.83,7.09 156.4,7.09 v2(156.36,7.06) ; JDIMM1.254 125.72,80.43 126.34,81.05 126.34,82 v2(126.79,82.44)
  IN1 w0.109: v2(156.36,7.06) 156.07,7.35 155.78,7.35 155.5,7.63 153.22,7.63 152.97,7.38 142.08,7.38 141.48,6.78 141.48,6.19 139.8,4.5 126.17,4.5 126.17,4.5 125.2,4.5 125.2,4.5 111.77,4.5 108.76,7.51 108.76,9.21 107.1,10.87 106.13,10.87 v2(106.05,10.8) ; v2(107.84,78.86) 107.65,79.05 107.65,79.41 108.2,79.97 115.42,79.97 118.47,83.01 120.95,83.01 121.14,82.82 121.14,82.65 v2(120.93,82.44)
  IN3 w0.127: v2(120.93,82.44) 120.93,82.01 121.39,81.55 125.9,81.55 v2(126.79,82.44) ; v2(106.05,10.8) 92.13,10.8 89.37,13.56 80.7,13.56 80.23,14.03 69.13,14.03 67.17,12.07 60.99,12.07 59.68,10.76 57.73,10.76 56.28,9.31 49.85,9.31 49.21,8.67 46.82,8.67 46.57,8.91 40.72,8.91 39.21,7.4 28.96,7.4 25.53,3.98 18.18,3.98 16.09,6.06 16.09,7.66 14.98,8.77 14.98,10.2 7.98,17.21 7.98,30.81 3.64,35.15 3.64,43.85 4.18,44.4 4.18,47.49 v2(3.39,48.28) ; v2(104.15,131.26) 104.32,131.1 105.8,131.1 105.86,131.15 109.94,131.15 110.66,130.43 110.66,129.05 v2(110.88,128.83)
  IN4 w0.109: v2(106.05,10.8) 106.05,10.82 106.13,10.9 106.28,10.9 110.37,14.99 110.37,32.45 109.43,33.4 108.35,33.4 105.16,36.59 105.16,48.1 104.72,48.54 104.72,51.54 105.92,52.74 105.92,55.19 104.1,57.01 104.1,63.6 106.27,65.76 106.27,73.46 106.45,73.65 106.45,75.37 107.26,76.18 107.26,77.81 107.82,78.37 107.82,78.85 v2(107.84,78.86)
  BOTTOM w0.102: JDIMM2.254 131.75,80.43 131.54,80.63 131.54,80.92 131.5,80.96 131.5,82.8 131.32,82.98 131.07,83.23 129.62,83.23 129.04,83.81 128.16,83.81 v2(126.79,82.44) ; v2(104.15,131.26) 103.98,131.08 103.61,131.08 103.31,130.78 103.31,130.3 104.2,129.41 104.2,123.38 103.84,123.03 103.84,120.37 104.09,120.11 104.09,118.99 103.61,118.51 103.61,116.63 103.28,116.3 103.28,112.33 97.24,106.29 97.24,102.27 98.66,100.86 98.66,96.41 94.42,92.17 94.42,88.46 95.86,87.02 95.86,82.57 100.54,77.9 107.14,77.9 107.65,78.4 107.65,78.67 v2(107.84,78.86) ; v2(120.93,82.44) 120.93,81.22 120.13,80.43 JDIMM4.254
DE0_A_UN8: length 2.9
  TOP w0.102: UN8.6 25.46,31.59 24.82,32.23 RN54.2 RN103.1
DE0_A_UN9: length 4.6
  TOP w0.102: v1(34.95,32.32) 34.07,32.32 RN59.2 33.95,31.48 RN120.1 34.51,30.92 36.11,30.92 UN9.6
DE0_B_UN8: length 3.6
  TOP w0.102: RN102.1 RN52.2 24.36,26.04 v1(24.39,26.07) 24.4,26.08 25.02,26.08 25.46,26.52 UN8.13
DE0_B_UN9: length 3.5
  TOP w0.102: UN9.13 36.44,26.6 v1(35.95,26.11) 35.51,25.67 RN119.1 35.01,24.68 RN62.2
DE1_A_UN8: length 6.9
  TOP w0.102: v1(24.03,35.32) RN101.1 RN50.2 23.25,33.4 23.42,33.22 23.42,32.3 23.8,31.92 23.8,30.47 24.4,29.88 UN8.8
DE1_A_UN9: length 5.9
  TOP w0.102: UN9.8 35.32,29.95 34.95,29.59 34.52,29.59 34.17,29.94 33.79,29.94 33.61,30.12 33.61,30.88 RN118.1 33.15,32.02 v1(32.95,32.23) 32.72,32.46 RN61.2
DE1_B_UN8: length 4.6
  TOP w0.102: RN99.2 RN100.1 22.99,31.28 22.67,30.96 v1(22.67,30.57) 22.78,30.46 23.25,30.46 24.34,29.38 UN8.9
DE1_B_UN9: length 7.5
  TOP w0.102: UN9.9 35.18,29.45 34.98,29.26 v1(34.57,29.26) 34.35,29.26 34.12,29.03 33.38,29.03 32.69,29.71 32.69,31.21 32.57,31.34 RN117.1 32.24,32.1 31.81,32.53 RN116.2
DETECT_PWR_EN: length 209.7
  TOP w0.102: v2(53.64,35.85) JIO2.56
  IN2 w0.127: v2(53.64,35.85) 54.16,35.33 56.37,35.33 57.2,36.16 59.79,36.16 60.16,35.78 66.92,35.78 68.75,37.61 70.18,37.61 72.72,40.15 72.72,41.09 74.76,43.13 78.34,43.13 95.77,60.56 95.77,71.85 97.91,73.99 97.91,74.91 98.42,75.43 98.66,75.43 100.37,77.13 102.68,77.13 106.85,81.3 108.03,81.3 108.64,80.69 119.08,80.69 120.01,81.62 125.28,81.62 127.48,83.81 130.26,83.81 132.29,81.78 134.24,81.78 134.57,82.11 136.94,82.11 142.46,76.59 149.81,76.59 151.67,78.45 151.67,79.14 154.94,82.42 156.53,82.42 156.57,82.38 165.67,82.38 165.93,82.13 169.08,82.13 170.22,83.26 173.4,83.26 173.84,82.82 177.17,82.82 177.42,82.57 182.02,82.57 184.5,85.04 184.5,89.54 186.83,91.88 186.83,93.86 186.59,94.11 186.24,94.11 186,93.86 186,93.7 185.75,93.45 185.4,93.45 185.16,93.7 185.16,94.33 185.31,94.48 185.31,94.94 184.11,96.13 181.67,96.13 181.54,96 180.29,96 179.68,96.61 v2(179.15,96.61)
  IN3 w0.127: v2(179.15,96.61) 179.26,96.72 179.26,100.29 178.43,101.13 177.94,101.61 177.94,103.43 177.61,103.76 177.61,105.59 177.63,105.61 177.63,108.14 177.94,108.45 177.94,109.05 176.85,110.15 176.85,113.9 v2(176.94,113.99)
  BOTTOM w0.102: v2(176.94,113.99) 176.89,113.99 176.89,114.04 176.59,114.34 176.59,114.9 176.3,115.19 U46.B3
DGPU_ALERT#: length 61.5
  IN1 w0.109: v2(186.58,111.51) 187.03,111.05 187.03,110.21 187.11,110.13 187.11,107.46 186.16,106.51 186.16,104.8 186.69,104.26 186.69,104.03 v2(186.69,104.03)
  IN3 w0.127: v2(186.69,104.03) 186.69,104.03 186.69,103.33 187.08,102.95 187.08,100.31 187.09,100.29 187.09,97.86 190.25,94.69 190.25,94.34 189.81,93.9 189.81,85.07 192.54,82.34 192.54,80.83 194.38,78.98 194.38,78.58 195.43,77.53 195.77,77.53 195.89,77.41 201.19,77.41 v2(202.35,78.58)
  BOTTOM w0.102: Q5.1 201.38,79.38 201.63,79.63 202.68,79.63 v1(202.98,79.34) 202.98,78.98 202.58,78.58 v2(202.35,78.58) ; v2(186.58,111.51) 186.55,111.51 186.55,111.45 186.55,111.45 186.55,111.46 186.57,111.47 187.3,111.47 RP3.5 ; v2(186.69,104.03) 186.34,104.38 185.77,104.38 185.46,104.07 183.2,104.07 182.76,103.64 180.63,103.64 180.57,103.58 178.74,103.58 178.46,103.86 178.46,105.22 U46.A42
DGPU_HOLD_RST#: length 212.5
  TOP w0.089: UH1.AL36 117.37,117.24 117.89,117.8 v2(117.89,117.79)
  TOP w0.102: v2(208.89,110.2) 209.11,110.2 209.38,110.46 209.38,110.93 209.08,111.23 209.08,114.55 208.44,115.19 208.44,116.77 208.16,117.05 208.16,118.61 205.89,120.88 205.89,124.15 204.68,125.37 204.68,133.5 205.02,133.84 205.02,137.63 201.91,140.74 192.6,140.74 191.55,141.8 189.53,141.8 189.21,141.49 182.13,141.49 182.02,141.6 181.85,141.76 180.95,141.76 180.78,141.6 179.15,141.6 178.77,141.22 175.99,141.22 175.66,141.55 174.64,141.55 174.26,141.17 174.26,139.57 170.04,135.35 170.04,135.18 168.62,133.76 163.23,133.76 163.05,133.94 160.7,133.94 v2(159.11,132.35) ; v2(175.68,77.93) 175.68,77.93 175.49,77.93 175.37,77.81 175.37,76.72 R19.2 175,75.79 175.23,75.56 R51.1 174.87,74.19 U16.1
  IN1 w0.089: 139.22,126.2 139.11,126.09 139.11,125.69 139.11,124.99 134.73,120.6 134.73,118.52 133.27,117.06 128.96,117.06 127.99,116.1 127.49,116.1 127.23,116.35 123,116.35 122.2,117.16 118.94,117.16 118.3,117.79 v2(117.89,117.79)
  IN1 w0.109: 139.22,126.2 140.06,127.04 141.37,127.04 141.64,126.77 143.97,126.77 145.27,128.07 148.1,128.07 148.76,128.72 151.17,128.72 151.3,128.59 155.47,128.59 155.83,128.95 157.1,130.22 157.1,131.02 158.48,132.4 159.06,132.4 v2(159.11,132.35)
  IN3 w0.127: v2(217.51,102.72) 217.22,102.72 216.82,103.12 216.82,103.53 216.46,103.89 216.46,105.78 216.09,106.15 216.09,107.08 216.42,107.4 216.42,107.82 215.91,108.33 215.2,108.33 213.65,109.88 209.21,109.88 v2(208.89,110.2)
  BOTTOM w0.102: v2(175.68,77.93) 175.69,77.93 191.41,77.93 192.51,79.03 192.51,80.81 195.86,84.16 203.32,84.16 v1(204.47,85.31) 209.53,90.37 209.53,90.47 210.42,91.36 213.08,91.36 214.16,92.44 214.16,96.54 215.42,97.8 215.42,98.69 215.89,99.16 215.89,100.35 216.3,100.75 216.3,101.14 217.51,102.35 v2(217.51,102.72)
DGPU_PEX_RST#: length 65.5
  TOP w0.089: 167.92,68.22 168.18,68.22 168.38,68.01 170.06,68.01 v2(170.74,67.33) 170.9,67.18 171.41,67.18 171.75,67.51 171.75,68.73 173.57,70.55 173.57,70.91
  TOP w0.102: R19.1 173.6,76.83 172.85,76.83 R3750.1 172.11,75.93 173.18,74.86 173.18,72.46 173.57,72.07 U16.4 173.57,70.91 ; R19.1 174.08,75.8 174.34,75.55 v2(174.32,75.55) ; R19.1 174.28,76.54 174.28,77.94 174.75,78.41 JMXM1.184 ; Q4.2 165.52,69.1 166.25,68.37 167.21,68.37 167.36,68.22 167.92,68.22
  IN2 w0.127: v2(198.65,74.7) 199.11,74.23 199.11,72.35 198.61,71.84 197.65,71.84 196.45,73.04 192.15,73.04 190.86,71.75 182.25,71.75 180.95,73.05 176.93,73.05 174.43,75.55 v2(174.32,75.55)
  BOTTOM w0.089: v2(170.74,67.33) 170.74,67.15 167.14,63.55 166.1,63.55
  BOTTOM w0.102: 166.1,63.55 D95.1 ; Q5.2 v1(199.48,76.59) 199.48,76.33 198.51,75.36 198.51,74.84 v2(198.65,74.7)
DGPU_PEX_RST#_D: length 35.3
  TOP w0.102: v2(156.29,73.43) 156.83,73.43 157.56,74.15 157.56,74.43 157.44,74.55 U25.1 ; U27.1 145.16,75.06 145.39,74.82 145.39,73.56 v2(145.08,73.24) ; U14.1 150.37,75.06 150.6,74.82 150.6,74.06 150.32,73.78 v3(149.64,73.78) 149.23,73.37 v2(149.23,73.24)
  IN2 w0.127: v2(145.08,73.24) 145.08,73.43 145.33,73.68 148.8,73.68 v2(149.23,73.24) 149.67,73.68 156.04,73.68 v2(156.29,73.43)
  BOTTOM w0.102: D95.2 165.48,65.76 C1470.1 164.27,65.77 R72.1 163.39,67.51 R71.2 160.27,67.51 157.14,70.63 157.14,73.12 156.83,73.43 v2(156.29,73.43)
DGPU_PWR_EN: length 104.1
  TOP w0.102: v2(211.75,78.56) 211.75,78.57 JMXM1.44
  IN1 w0.109: v2(176.38,108.16) 176.64,108.16 177.11,107.69 177.11,107.35 176.18,106.42 175.33,106.42 174.21,107.54 174.21,110.1 173.6,110.71 173,110.71 172.66,110.38 172.66,106.33 172.52,106.19 172.24,106.19 171.83,105.78 171.83,105.38 170.5,104.05 169.09,104.05 168.61,103.58 168.61,103 166.17,100.56 162.05,100.56 161.09,99.59 159.89,99.59 159.15,98.86 158.33,98.86 158.2,98.72 157.57,98.1 157.57,94.11 158.05,93.63 158.58,93.63 159.99,92.22 159.99,92.01 160.32,91.68 161.87,91.68 165.88,87.68 165.88,86.46 166.87,85.47 168.21,85.47 v2(171.05,82.63)
  IN2 w0.127: v2(211.75,78.56) 210.53,79.78 208.57,79.78 203.84,84.5 184.31,84.5 182.13,82.32 177.31,82.32 177.06,82.57 173.65,82.57 173.59,82.63 v2(171.05,82.63)
  BOTTOM w0.102: U46.B45 178.3,106.53 178.13,106.7 178.13,106.71 177.71,107.14 176.85,108 176.54,108 v2(176.38,108.16)
DGPU_PWROK: length 245.3
  TOP w0.089: UH1.AJ38 116.59,116.5 v2(116.77,116.69)
  TOP w0.102: 211.56,77.55 211.56,76.83 210.7,75.97 207.73,75.97 v2(206.95,76.74) ; 211.56,77.55 212.12,77.55 212.39,77.82 212.39,78.95 212.25,79.09 JMXM1.42 ; 211.56,77.55 211.24,77.87 209.75,77.87 R1977.2 ; v2(168.3,111.34) 168,111.04 v1(168,110.83) 168,110.26 169.11,109.14 169.11,106.8 168.04,105.73 168.04,103.56 167.74,103.26 167.74,101.43 168.27,100.9 168.27,99.76 v2(169.55,98.48)
  IN2 w0.089: 199.9,70.34 199.43,69.87 197.84,69.87 197.27,70.44 194.35,70.44 193.65,69.74 193.15,69.74 192.99,69.9 192.99,70.91 ; 141.76,111.43 140.06,111.43 139.71,111.77 136.28,111.77 133.16,114.88 128.02,114.88 127.73,115.17 127.73,115.31 126.81,116.23 125.39,116.23 124.02,117.6 122.01,117.6 121.81,117.4 117.49,117.4 v2(116.77,116.69) ; 173.29,70.91 171.17,68.79 167.92,68.79
  IN2 w0.127: 192.99,70.91 192.99,71.67 192.6,72.07 191.54,72.07 190.93,71.46 181.84,71.46 180.51,72.79 175.18,72.79 173.29,70.91 ; 141.76,111.43 146.77,111.43 147.66,110.54 148.25,110.54 148.7,110.98 152.53,110.98 153.32,111.77 164.61,111.77 165.03,111.35 168.29,111.35 168.3,111.34 v2(168.3,111.34) ; 167.92,68.79 163.94,68.79 160.57,72.16 159.3,72.16 156.7,74.76 156.7,77.43 156.06,78.06 156.06,78.59 v2(156.13,78.66) ; v2(186.22,86.7) 191.05,91.52 191.05,93.96 189.64,95.37 185.23,95.37 184.22,96.39 181.57,96.39 181.43,96.25 180.67,96.25 179.68,97.24 177.52,97.24 176.93,96.65 176.93,95.44 176.5,95 175.59,95 174.96,94.38 173.61,94.38 169.8,98.19 169.8,98.23 v2(169.55,98.48) ; 199.9,70.34 200.13,70.57 200.13,72.85 202.48,75.2 205.41,75.2 v2(206.95,76.74)
  BOTTOM w0.102: U46.A56 173.4,110.51 173.08,110.83 172.89,110.83 171.94,111.78 168.74,111.78 168.3,111.35 168.3,111.35 v2(168.3,111.34) ; v2(186.22,86.7) 185.4,87.52 182.35,87.52 181.28,86.45 181.28,84.99 179.18,82.9 174.28,82.9 173.26,81.87 158.35,81.87 156.44,79.97 156.44,78.98 v2(156.13,78.66) 154.16,76.69 154.16,73.24 160.76,66.63 R72.2 R135.1
DGPU_SELECT: length 12.5
  TOP w0.102: v2(157.54,137.15) 156.87,137.82 156.44,137.82 155.24,136.62 155.24,135.86 154.95,135.57 154.46,135.57 154.35,135.67 RV47.2
  BOTTOM w0.102: U630.54 153.25,136.78 153.65,137.18 RV46.1 155.86,137.69 156.58,137.69 157.34,138.45 QV1.1 157.65,137.3 157.54,137.18 v2(157.54,137.15)
DGPU_SELECT#: length 156.1
  TOP w0.102: v2(151.2,145.76) 151.32,145.76 152.28,144.8 153.78,144.8 156.89,141.69 156.89,138.83 157.94,137.78 157.94,136.98 157.65,136.69 157.37,136.69 v2(156.89,137.18) 156.13,137.18 155.47,136.52 155.47,135.28 154.9,134.72 154.41,134.72 153.93,135.19 152.71,135.19 151.94,135.96 RV49.2 ; v2(182.63,123.8) 182.63,124.04 182.28,124.39 182.28,126.81 183.72,128.25 184.41,128.25 185.08,128.93 185.08,129.37 184.45,130 184.45,132.06 185.14,132.76 185.81,132.76 187.59,134.55 187.59,134.67 187.75,134.82 187.75,137.03 188.38,137.66 189.79,137.66 190.64,138.51 v1(190.64,139.9) 190.64,140.34 v2(191.01,140.71)
  IN1 w0.109: v2(109.77,156.64) 109.8,156.64 109.99,156.83 111.75,156.83 113.33,155.26 113.33,151.91 115.93,149.31 122.23,149.31 126.66,144.88 126.66,144.68 126.67,144.68 126.67,144.34 126.66,144.33 126.66,144.21 127.52,143.36 128.68,143.36 129.09,142.95 135.21,142.95 135.97,143.71 136.86,143.71 137.57,144.42 150.6,144.42 151.17,144.99 151.17,145.74 151.19,145.76 v2(151.2,145.76) ; v2(181.59,114.51) 182.7,115.61 182.7,117.97 183.25,118.52 183.25,122.47 182.63,123.1 v2(182.63,123.8)
  IN2 w0.127: v2(151.2,145.76) 151.3,145.76 151.72,145.33 152.59,145.33 153.28,146.02 157.55,146.02 158.21,145.36 159.63,145.36 160.04,145.77 165.04,145.77 168.23,142.58 189.84,142.58 191.01,141.41 v2(191.01,140.71)
  BOTTOM w0.102: U46.B14 181.8,114.94 181.59,114.73 v2(181.59,114.51) ; RV46.2 v2(156.89,137.18) 157.36,136.71 157.94,136.71 158.28,137.05 158.28,137.83 QV1.2 ; v2(109.77,156.64) 109.58,156.45 U3.1
DH_1.2V: length 8.3
  IN4 w1.016: 70.84,22.12 70.46,22.12 67.42,19.07 63.85,19.07
  vias: v1(73.11,22.37) v2(62.45,18.31) v2(63.08,18.31) v2(72.29,22.63) v2(72.29,21.99)
DIFFOUT_3PH_A: length 4.9
  TOP w0.203: PR1131.2 260.13,49.87 259.69,49.87 259.36,49.54 258.33,49.54 258.15,49.35 v1(258.15,49.28) PU1100.4
  TOP w0.254: PR1131.2 260.64,51.24 PC1114.2
DIFFOUT_3PH_B: length 4.4
  TOP w0.203: PR1136.2 258.87,39.39 258.36,39.9 258.04,39.9 257.64,40.3 v1(257.64,40.74) 257.64,41.07 257.75,41.17 PU1100.35
  TOP w0.254: PR1136.2 258.93,38.53 PR1134.1
DIMM1_SA0: length 105.7
  TOP w0.102: v2(129.33,9.1) v1(129.33,7.07) RD30.1 RD17.2 ; JDIMM1.256 123.73,80.92 123.38,81.27 123.38,82 123.72,82.33 124.55,82.33 124.71,82.48 124.71,85.25 125.61,86.16 125.61,87.37 125.07,87.9 125.07,88.41 125.35,88.69 125.35,88.69 125.45,88.79 125.81,88.79 v2(126.2,88.4)
  IN1 w0.109: v2(126.2,88.4) 126.2,87.17 124.87,85.84 124.87,58.74 123.55,57.42 120.82,57.42 118.74,55.35 118.74,16.89 125.39,10.24 128.5,10.24 129.33,9.41 v2(129.33,9.1)
DIMM1_SA1: length 99.3
  TOP w0.102: RD13.2 127.49,7.02 RD29.1 127.48,8.62 v2(127.94,9.09) ; v2(125.52,88.29) 125.84,87.97 125.84,86.06 125.32,85.54 125.32,84.08 125.51,83.89 125.51,82.09 125.34,81.92 JDIMM1.260
  IN1 w0.109: v2(127.94,9.09) 127.02,10.01 125.29,10.01 118.51,16.79 118.51,55.45 120.72,57.66 123.45,57.66 124.63,58.84 124.63,85.94 125.52,86.83 v2(125.52,88.29)
