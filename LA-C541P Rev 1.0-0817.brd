# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PBATT+: length 113.4
  TOP w0.381: 286.62,49.36 298.49,49.36 v2(299.13,48.72) ; PR1008.1 v2(326.99,55.96)
  TOP w0.508: v2(279.6,38.65) 279.6,38.3 280.35,37.55 283.54,37.55 284.15,38.16 284.15,39.25 283.68,39.72 PD702.2 283.68,40.99 284.05,41.36 284.87,41.36 285.16,41.65 285.16,42.77 284.27,43.66 284.27,44.28 282.62,45.93 282.62,48.34 283.63,49.36 v1(284.32,49.36) 286.62,49.36
  IN2 w0.381: v2(299.13,48.72) 299.13,49.04 299.7,49.61 305.16,49.61 305.99,50.44 316.08,50.44 318.88,47.65 323.16,47.65 325.15,49.64 325.15,49.83 326.26,50.94 326.26,52.71 327.01,53.46 327.01,55.94 v2(326.99,55.96)
  BOTTOM w0.508: v2(264.5,16.09) 265.42,16.09 267.96,18.62 267.96,22.42 267.59,22.78 267.59,24.21 267.96,24.58 267.96,26.1 265.25,28.8 265.25,30.43 265.96,31.14 265.96,34.01 266.38,34.43 267.85,34.43 271.13,31.15 274.24,31.15 275.41,32.32 275.41,34.21 277.89,36.7 278.55,36.7 279.6,37.74 v2(279.6,38.65)
PBATT+_C:
  vias: v1(268.03,10.54)
PBATT_IN_SS:
  vias: v1(282.2,8.84) v2(256.57,6.69) v2(256.57,6.05) v2(257.2,6.69) v2(257.2,6.05) v2(257.84,6.69) v2(257.84,6.05) v2(258.47,6.69) v2(258.47,6.05) v2(259.11,6.69) v2(259.11,6.05) v2(259.74,6.69) v2(259.74,6.05) v2(284.27,11.7) v2(284.25,11.07) v2(284.25,10.43) v2(284.89,11.7) v2(284.89,11.07) v2(284.89,10.43) v2(285.52,11.7) v2(285.52,11.07) v2(285.52,10.43) v2(286.17,11.7) v2(286.16,11.07) v2(286.16,10.43)
PCH_2_CPU_TRIGGER: length 110.8
  TOP w0.089: CPU1.H23 187.82,60.11 v2(188.21,60.51) ; 141.76,114.53 139.73,114.53 v2(139.49,114.76)
  TOP w0.102: 141.76,114.53 143.27,114.53 144.25,115.5 v1(144.25,116.73) 144.25,117 144.02,117.23 142.8,117.23 RH42.2
  IN3 w0.089: 167.72,65.17 172.7,65.17 173.27,65.74 176.45,65.74 177.56,64.63 180.35,64.63 180.82,64.16 187.56,64.16 187.79,63.93 187.79,60.83 188.11,60.51 v2(188.21,60.51) ; 136.39,99.28 136.39,100.29 137.26,101.16 137.26,105.62 136.86,106.02 136.86,106.32 136.86,113.27 137.52,113.93 137.52,113.94 138.41,114.83 139.42,114.83 v2(139.49,114.76)
  IN3 w0.127: 167.72,65.17 148.22,65.17 141.03,72.36 141.03,75.03 140.49,75.57 140.49,81.25 140.19,81.55 140.19,83.52 136.06,87.65 136.06,95.99 136.02,96.03 136.02,97.9 136.39,98.27 136.39,99.28
PCH_2_CPU_TRIGGER_R: length 7.6
  TOP w0.089: 137.71,118.03 137.42,118.03 136.77,117.38 134.74,117.38 UH1.AL2
  TOP w0.102: 137.71,118.03 138.87,118.03 138.93,117.96 v1(139.34,117.96) 139.97,117.96 140.26,117.67 RH42.1
PCH_AAC_SMBCLK: length 237.7
  TOP w0.089: UH1.AR38 116.6,118.93 v2(116.36,118.69)
  TOP w0.102: R41.2 246.69,103.31 v2(247.13,103.76)
  IN2 w0.127: v2(97.2,128.42) 97.39,128.61 97.39,129.69 99.09,131.39 99.09,132.53 105.67,139.11 106.79,139.11 107.75,138.15 110.8,138.15 111,138.35 112.42,138.35 112.63,138.15 117.97,138.15 122.91,143.09 128.08,143.09 128.42,143.43 134.88,143.43 135.99,144.55 140.49,144.55 141.05,145.11 141.05,145.73 v2(140.89,145.89)
  IN3 w0.089: 113.79,120.36 113.79,120.34 113.77,120.32 113.77,119.91 114.43,119.25 115.9,119.25 116.36,118.79 v2(116.36,118.69)
  IN3 w0.127: v2(140.89,145.89) 141.05,146.06 141.05,146.78 141.86,147.59 141.86,151.05 149.28,158.47 202.55,158.47 206.79,154.22 209.02,154.22 212.09,151.15 212.09,149.42 211.21,148.53 211.21,147.22 215.96,142.46 222.33,142.46 231.93,132.87 231.93,128.14 234.55,125.52 235.18,125.52 235.78,124.92 236.77,124.92 237.24,125.39 238.18,125.39 240.59,122.98 240.59,117.45 241,117.04 241,108.53 242.73,106.81 242.73,104.36 243.26,103.83 245.11,103.83 245.42,103.53 246.36,103.53 246.59,103.76 v2(247.13,103.76) ; v2(97.2,128.42) 97.36,128.58 97.36,128.8 98.04,129.48 99.82,129.48 100.56,130.22 103.54,130.22 106,127.76 106,122.83 106.74,122.09 107.37,122.09 107.87,122.6 112.86,122.6 113.44,122.02 113.44,121.05 113.79,120.7 113.79,120.36
PCH_AAC_SMBDAT: length 232.4
  TOP w0.089: UH1.AT42 114.58,119.24 114.18,118.84 v2(114.18,118.74)
  TOP w0.102: v2(240.45,103.37) 240.89,103.8 R40.2
  IN2 w0.127: v2(97.78,128.42) 97.64,128.56 97.64,129.59 99.34,131.29 99.34,132.43 105.77,138.86 106.68,138.86 107.65,137.89 110.9,137.89 111.11,138.09 112.32,138.09 112.52,137.89 118.08,137.89 123.02,142.83 128.19,142.83 128.53,143.17 134.98,143.17 136.1,144.29 140.59,144.29 141.3,145 141.3,145.73 v2(141.47,145.89)
  IN3 w0.089: v2(114.18,118.74) 114.18,119.2 113.56,119.82 113.56,120.32 113.54,120.34 113.54,120.36
  IN3 w0.127: v2(240.45,103.37) 241.91,103.37 242.47,103.93 242.47,106.7 240.75,108.43 240.75,116.94 240.34,117.34 240.34,122.88 238.07,125.14 237.34,125.14 236.87,124.67 235.67,124.67 235.08,125.27 234.45,125.27 231.68,128.04 231.68,132.76 222.23,142.21 215.85,142.21 210.95,147.11 210.95,148.64 211.84,149.53 211.84,151.05 208.92,153.97 206.68,153.97 202.44,158.21 149.38,158.21 142.12,150.95 142.12,147.49 141.3,146.68 141.3,146.06 v2(141.47,145.89) ; v2(97.78,128.42) 97.62,128.58 97.62,128.7 98.15,129.23 99.93,129.23 100.66,129.97 103.43,129.97 105.74,127.66 105.74,122.73 106.63,121.84 107.47,121.84 107.98,122.35 112.75,122.35 113.19,121.91 113.19,120.95 113.54,120.6 113.54,120.36
PCH_ALW_ON: length 426.9
  IN2 w0.089: 192.68,70.91 192.68,69.76 192.88,69.57 193.73,69.57 194.29,70.13 197.18,70.13 197.88,69.43 199.9,69.43
  IN2 w0.127: v2(211.94,78) 212.31,78.37 212.31,79.01 211.26,80.06 208.65,80.06 203.64,85.06 203.28,85.06 202.42,85.93 202.42,86.76 202.04,87.14 201.53,87.14 200.26,85.87 188.32,85.87 187.94,86.25 187.94,87.52 191.56,91.14 191.56,93.49 191.95,93.88 v2(192.18,93.88) ; v2(176.76,11.45) 176.64,11.45 176.1,11.98 172.72,11.98 172.01,11.27 166.79,11.27 163.75,14.31 161.08,14.31 160.75,13.99 139.55,13.99 138.72,13.16 130.48,13.16 130.28,12.96 120,12.96 119.74,13.23 117.2,13.23 115.68,14.75 115.68,14.76 115.16,15.27 113.4,15.27 112.59,14.46 102.5,14.46 100.94,16.02 100.94,34.31 101.32,34.69 101.32,67.96 v2(101.18,68.1) ; 199.9,69.43 200.76,69.43 203.05,67.14 206.67,67.14 209.88,70.35 v2(210.01,70.35) ; 192.68,70.91 192.68,71.14 192.74,71.2 192.74,71.57 192.49,71.81 191.65,71.81 191.04,71.2 181.74,71.2 180.4,72.54 175.28,72.54 171.68,68.94 171.68,67.42 v2(170.72,66.46)
  IN4 w0.089: v2(170.72,66.46) 170.72,66.49 171.05,66.82 171.68,66.82 172.44,66.06 176.34,66.06 179.18,63.22 179.18,62.54 179.17,62.54 179.17,62.24 179.18,62.24 179.18,61.91 179.18,61.61 179.18,61.61 179.18,48.79 179.68,48.28 179.68,42.82 179.3,42.44 179.3,34.69 179.68,34.31 179.68,32.91 179.43,32.66 179.43,31.77 179.68,31.52 179.68,29.23 179.94,28.98 179.94,27.87 179.72,27.65 179.72,21.64 179.3,21.23 179.3,18.82 178.38,17.89
  IN4 w0.109: v2(176.76,11.45) 177.02,11.7 177.02,12.72 177.52,13.23 177.52,17.04 178.38,17.89 ; v2(96.24,127.58) 95.1,127.58 90.9,123.38 90.9,117.19 92.23,115.86 95.2,115.86 97.54,113.53 97.54,111.38 98.4,110.51 100.69,110.51 101.2,111.02 v2(101.2,111.65)
  BOTTOM w0.102: 192.76,105.06 194.11,105.06 194.57,105.52 194.62,105.52 194.85,105.75 194.85,106.09 194.64,106.3 194.64,106.46 194.61,106.5 194.61,106.52 194.52,106.6 194.52,106.66 194.52,106.66 194.52,107.54 194.84,107.86 U51.A34 ; 192.76,105.06 192.65,105.06 191.86,104.27 191.86,102.3 192.55,101.61 v1(195.91,101.61) 198.91,101.61 199.05,101.75 199.05,102.19 199.27,102.41 200.36,102.41 200.61,102.15 200.61,101.65 201.81,100.45 203.05,100.45 203.8,99.7 ; 192.76,105.06 192.76,105.75 192.51,106 190.99,106 190.73,106.26 R417.1 ; v2(101.2,111.65) 101.2,110.68 99.8,109.28 96.24,105.72 96.24,105.04 95.66,104.46 95.66,101.06 96.24,100.48 96.24,96.29 93.53,93.57 93.53,87.95 94.86,86.62 94.86,75.47 101.18,69.14 v2(101.18,68.1) ; v2(211.94,78) 211.94,77.68 213.66,75.97 213.66,75.33 212.04,73.71 212.04,72.39 v2(210.01,70.35) ; v2(96.24,127.58) 96.65,127.17 97.16,127.17 97.67,127.68 97.99,127.68 98.47,128.16 98.63,128.16 PR809.1 ; RP7.7 205.39,99.61 205.14,99.37 204.13,99.37 203.8,99.7 ; 203.8,99.7 203.8,95.52 204.07,95.25 204.07,94.47 203.07,93.47 202.69,93.47 201.78,92.56 201.78,92.18 200.73,91.13 192.13,91.13 191.42,91.84 191.42,93.18 192.12,93.88 v2(192.18,93.88)
PCH_BATLOW#: length 6.8
  TOP w0.089: UH1.BD13 129.16,123.58 129.33,123.75 129.33,124.7 129.73,125.1 v2(129.73,125.3)
  BOTTOM w0.089: v2(129.73,125.3) 129.2,125.82 129.2,126.2
  BOTTOM w0.102: RH94.1 128.62,129.1 128.62,127.01 129.14,126.49 129.2,126.43 129.2,126.2
PCH_CL_CLK1: length 94.8
  TOP w0.089: 137.71,121.52 137.68,121.52 137.57,121.41 136.16,121.41 135.29,120.53 134.52,120.53 134.43,120.44 UH1.AV2
  TOP w0.102: 137.71,121.52 137.83,121.52 138.42,122.12 140.36,122.12 140.68,122.44 143.84,122.44 v2(144.02,122.26)
  IN4 w0.109: v2(144.02,122.26) 144.13,122.26 144.61,122.74 146.07,122.74 146.18,122.85 150.83,122.85 151.06,123.08 152.51,123.08 152.93,122.66 154.07,122.66 155.2,123.8 156.03,123.8 157.03,122.8 164.48,122.8 164.88,122.8 165.76,121.92 166.26,121.92 166.98,121.21 167.76,121.21 168.07,120.9 173.16,120.9 173.69,120.37 178.43,120.37 179.21,121.15 179.21,121.37 179.51,121.67 192.43,121.67 193.82,123.06 195.88,123.06 196.14,122.79 198.61,122.79 199.93,124.11 205.39,124.11 205.89,123.61 214.03,123.61 216.13,121.5 216.13,119.45 216.8,118.78 217.31,118.78 v2(217.66,118.43)
  BOTTOM w0.102: v2(217.66,118.43) 217.81,118.59 219.22,118.59 219.35,118.45 JNGFF1.34
PCH_CL_DATA1: length 95.1
  TOP w0.089: UH1.AV3 134.14,120.45 134.44,120.75 135.2,120.75 136.07,121.62 137.48,121.62 137.59,121.74 137.61,121.74 137.61,121.75 137.68,121.75 137.69,121.75 137.71,121.75
  TOP w0.102: 137.71,121.75 137.74,121.75 138.33,122.35 140.27,122.35 140.59,122.67 143.84,122.67 v2(144.02,122.84)
  IN4 w0.109: v2(217.66,119.02) 216.89,119.02 216.37,119.54 216.37,121.6 214.13,123.84 205.99,123.84 205.49,124.35 199.83,124.35 198.51,123.03 196.24,123.03 195.97,123.29 193.72,123.29 192.33,121.9 179.41,121.9 178.98,121.47 178.98,121.25 178.34,120.61 173.79,120.61 173.26,121.14 168.17,121.14 167.86,121.44 167.08,121.44 166.36,122.16 165.86,122.16 164.98,123.04 164.58,123.04 157.13,123.04 156.13,124.04 155.1,124.04 153.97,122.9 153.03,122.9 152.61,123.32 150.96,123.32 150.73,123.08 146.08,123.08 145.97,122.98 144.51,122.98 144.31,122.78 144.08,122.78 v2(144.02,122.84)
  BOTTOM w0.102: JNGFF1.32 219.35,118.95 219.22,118.81 217.86,118.81 v2(217.66,119.02)
PCH_CL_RST1#: length 94.8
  TOP w0.089: UH1.AW2 134.47,121.04 134.68,121.25 135.2,121.25 135.86,121.91 v2(135.86,122.34)
  IN4 w0.089: v2(135.86,122.34) 136.15,122.63 136.96,122.63 137.99,123.65 139.49,123.65 140.47,122.67 141.76,122.67
  IN4 w0.109: 141.76,122.67 142.43,122.67 143.26,123.5 143.6,123.5 143.7,123.4 145.88,123.4 145.93,123.45 149.11,123.45 149.33,123.68 152.76,123.68 153.18,123.26 153.82,123.26 155.12,124.56 156.12,124.56 157.28,123.4 165.13,123.4 165.9,122.63 166.42,122.63 166.86,122.19 168.7,122.19 169.37,121.52 173.62,121.52 174.12,121.03 176.47,121.03 176.97,121.52 177.38,121.52 177.99,122.13 179.13,122.13 179.27,122.27 191.35,122.27 192.74,123.66 194.12,123.66 194.78,124.33 198.21,124.33 198.6,124.71 205.64,124.71 206.14,124.2 214.28,124.2 216.96,121.52 216.96,120.35 v2(217.66,119.65)
  BOTTOM w0.102: JNGFF1.30 219.5,119.45 219.23,119.72 217.72,119.72 v2(217.66,119.65)
PCH_CPU_BCLK_D: length 6.2
  TOP w0.089: UH1.G2 134.65,105.51 135.6,105.51 136,105.11 136.54,105.11 136.55,105.1 136.56,105.1
  TOP w0.102: RH161.2 139.79,105.1 v4(137.22,105.1) 136.56,105.1
PCH_CPU_BCLK_D#: length 6.2
  TOP w0.089: UH1.H2 135.68,105.71 136.08,105.31 136.54,105.31 136.55,105.32 136.56,105.32
  TOP w0.102: RH166.2 140.05,105.43 139.94,105.32 v4(138.87,105.32) 136.56,105.32
PCH_CPU_BCLK_R_D: length 84
  TOP w0.089: CPU1.B31 194.11,64.07 193.82,64.37 193.82,65.05 193.86,65.1 193.86,65.32 v2(194.27,65.72)
  TOP w0.102: RH161.1 141.4,105.28 143.24,105.28 145.55,102.97 145.55,101.86 146.18,101.23 v4(149.43,101.23) 150.41,101.23 150.76,100.87 153.05,100.87 157.44,96.48 159.06,96.48 159.33,96.75 159.54,96.75 v2(159.81,96.48)
  IN3 w0.089: v2(194.27,65.72) 194.27,65.64 194.59,65.32 194.8,65.32 195.11,65.64 195.11,70.88 195.1,70.89 195.1,70.91
  IN3 w0.127: v2(159.81,96.48) 160.05,96.72 160.22,96.72 161.02,95.93 161.02,94.84 162.68,93.18 162.88,93.18 163.18,92.88 163.18,90.72 163.58,90.31 163.58,88.84 165.78,86.64 165.78,85.36 167.41,83.73 172.75,83.73 174.21,82.27 182.74,82.27 183.27,81.74 186.95,81.74 189.25,79.45 189.25,77.68 189.53,77.4 190.62,77.4 192,76.02 192.31,76.02 193.16,75.17 193.16,74.56 195.1,72.62 195.1,70.91
PCH_CPU_BCLK_R_D#: length 84
  TOP w0.089: CPU1.A32 194.56,64.55 194.35,64.34 194.13,64.34 194.02,64.45 194.02,64.97 194.17,65.11 v2(194.28,65.11)
  TOP w0.102: RH166.1 141.21,105.49 143.33,105.49 145.76,103.06 145.76,101.95 146.27,101.44 150.5,101.44 150.85,101.09 v4(151.59,101.09) 153.14,101.09 157.53,96.7 158.97,96.7 159.24,96.96 159.7,96.96 v2(159.81,97.07)
  IN3 w0.089: 195.34,70.91 195.34,70.89 195.33,70.88 195.33,65.55 194.89,65.11 v2(194.28,65.11)
  IN3 w0.127: v2(159.81,97.07) 159.81,97.07 159.9,96.97 160.33,96.97 161.27,96.03 161.27,94.94 162.78,93.43 162.98,93.43 163.43,92.98 163.43,90.82 163.83,90.42 163.83,88.94 166.03,86.75 166.03,85.47 167.52,83.98 172.85,83.98 174.31,82.52 182.84,82.52 183.37,81.99 187.05,81.99 189.5,79.55 189.5,77.78 189.63,77.65 190.72,77.65 192.1,76.27 192.41,76.27 193.41,75.27 193.41,74.66 195.34,72.73 195.34,70.91
PCH_CPU_NSSC_CLK_D: length 4
  TOP w0.089: UH1.G1 134.99,105.03 135.69,105.03 136.97,103.74 137.68,103.74 137.71,103.77
  TOP w0.102: RH169.2 137.71,103.77
PCH_CPU_NSSC_CLK_D#: length 4
  TOP w0.089: 137.71,103.51 137.67,103.54 136.89,103.54 135.61,104.82 134.99,104.82 UH1.F1
  TOP w0.102: RH170.2 137.71,103.51
PCH_CPU_PCIBCLK_D: length 6.6
  TOP w0.089: 136.36,106.25 136.34,106.25 136.34,106.24 135.21,106.24 134.95,106.5 134.71,106.5 UH1.J2
  TOP w0.102: 136.36,106.25 136.76,106.25 137.01,106.5 v4(137.44,106.5) 138.12,106.5 139.07,107.45 139.74,107.45 RH167.1
PCH_CPU_PCIBCLK_D#: length 6.5
  TOP w0.089: 136.36,106.03 136.34,106.03 136.34,106.04 135.13,106.04 135.03,105.94 134.76,105.94 134.66,106.04 134.66,106.1 UH1.J1
  TOP w0.102: RH168.1 139.99,107.06 139.82,107.23 139.16,107.23 v4(138.86,106.93) 138.21,106.28 137.1,106.28 136.85,106.03 136.36,106.03
PCH_CPU_PCIBCLK_R_D: length 88.9
  TOP w0.089: v2(196.78,62.62) 196.55,62.85 CPU1.D35
  TOP w0.102: RH167.2 141.16,107.45 142.26,107.45 144.44,105.27 145.59,105.27 146.3,104.57 147.53,104.57 147.84,104.26 149.93,104.26 150.6,103.59 150.6,102.22 151.11,101.71 153.93,101.71 v4(155.42,100.22) 156.68,98.95 159.07,98.95 159.3,99.18 159.3,99.52 159.62,99.84 160.06,99.84 160.34,99.56 160.34,99.3 v2(160.55,99.09)
  IN3 w0.089: v2(196.78,62.62) 196.78,62.85 197.07,63.14 197.07,65.74 196.53,66.28 196.53,70.88 196.55,70.89 196.55,70.91
  IN3 w0.127: 196.55,70.91 196.55,71.45 196.25,71.75 196.25,73.19 195.61,73.84 195.61,75.37 195.13,75.85 193.9,75.85 192.61,77.13 192.35,77.13 191.08,78.4 191.08,79.29 187.68,82.69 183.79,82.69 183.28,83.2 174.59,83.2 173.14,84.66 168.96,84.66 167.2,86.42 167.2,86.66 164.51,89.35 164.51,90.7 164.11,91.1 164.11,94.65 162.16,96.61 162.16,98 161.78,98.38 160.63,98.38 160.38,98.64 160.38,98.92 v2(160.55,99.09)
PCH_CPU_PCIBCLK_R_D#: length 88.9
  TOP w0.089: CPU1.C36 196.66,63.15 196.48,63.15 196.33,63.3 v2(196.33,63.36)
  TOP w0.102: v2(159.96,99.09) 160.13,99.25 160.13,99.47 159.97,99.63 159.71,99.63 159.52,99.43 159.52,99.09 159.16,98.74 v4(157.18,98.74) 156.6,98.74 153.84,101.49 151.02,101.49 150.39,102.13 150.39,103.5 149.84,104.04 147.75,104.04 147.44,104.35 146.21,104.35 145.5,105.05 144.35,105.05 142.17,107.23 141.04,107.23 140.9,107.1 RH168.2
  IN3 w0.089: v2(196.33,63.36) 196.33,63.3 196.56,63.08 196.7,63.08 196.86,63.23 196.86,65.65 196.32,66.19 196.32,70.88 196.3,70.89 196.3,70.91
  IN3 w0.127: v2(159.96,99.09) 160.13,98.92 160.13,98.53 160.53,98.13 161.67,98.13 161.91,97.9 161.91,96.5 163.86,94.55 163.86,90.99 164.26,90.6 164.26,89.25 166.95,86.56 166.95,86.32 168.86,84.41 173.03,84.41 174.49,82.95 183.17,82.95 183.68,82.44 187.57,82.44 190.83,79.19 190.83,78.3 192.24,76.89 192.51,76.89 193.79,75.6 195.03,75.6 195.36,75.27 195.36,73.73 196,73.09 196,71.65 196.3,71.35 196.3,70.91
PCH_DPB_CTRL_CLK: length 73
  TOP w0.089: UH1.BA5 132.86,122.2 v2(133.17,122.5)
  IN3 w0.127: v2(173.84,118.26) 173.85,118.26 173.85,118.27 173.71,118.41 173.71,120.42 172.51,121.63 172.51,127.82 171.35,128.98 170.34,128.98 170.1,129.22 170.1,129.81 173.14,132.86 173.14,133.55 173.59,134 173.59,135.06 173.06,135.59 172.95,135.59 172.64,135.91 172.08,135.91 v2(172.03,135.95)
  IN4 w0.089: 141.76,120.77 141.51,120.77 140.61,121.67 140.13,121.67 139.72,122.08 138.29,122.08 137.68,121.48 135.56,121.48 135.24,121.8 135.07,121.97 135.07,122.97 134.82,123.22 133.53,123.22 133.17,122.85 v2(133.17,122.5)
  IN4 w0.109: 141.76,120.77 142.39,120.77 142.4,120.78 145.63,120.78 145.98,121.13 147.38,121.13 148,121.76 150.84,121.76 151.24,121.36 152.49,121.36 152.7,121.57 162.43,121.57 162.58,121.71 163.39,121.71 164.8,120.31 166.34,120.31 166.53,120.12 166.88,120.12 168.61,118.39 172,118.39 172.6,117.78 173.37,117.78 v2(173.84,118.26)
  BOTTOM w0.089: RH222.1 134.85,122.95 v1(134.44,122.53) 134.29,122.38 133.29,122.38 v2(133.17,122.5)
  BOTTOM w0.102: v2(172.03,135.95) 172.08,135.91 172.56,135.91 172.59,135.93 172.98,135.93 173.15,136.11 U629.25
PCH_DPB_CTRL_DATA: length 69
  TOP w0.089: v2(133.2,123.43) 133.29,123.34 UH1.BC4
  IN3 w0.127: v2(173.14,118.19) 173.46,118.51 173.46,120.31 172.25,121.52 172.25,127.72 171.25,128.72 170.23,128.72 169.84,129.12 169.84,129.92 172.88,132.96 172.88,133.66 173.28,134.05 173.28,134.05 173.33,134.11 173.33,134.96 172.95,135.34 172.57,135.34 v2(172.44,135.47)
  IN4 w0.089: v2(133.2,123.43) 134.91,123.43 135.28,123.06 135.28,122.06 135.45,121.89 135.65,121.7 137.59,121.7 138.2,122.3 139.81,122.3 140.22,121.89 140.88,121.89 141.76,121.01
  IN4 w0.109: 141.76,121.01 142.29,121.01 142.3,121.02 145.53,121.02 145.88,121.37 147.28,121.37 147.9,121.99 150.94,121.99 151.34,121.59 152.39,121.59 152.6,121.8 162.33,121.8 162.48,121.95 163.49,121.95 164.9,120.54 166.43,120.54 166.63,120.35 166.98,120.35 168.71,118.62 172.09,118.62 172.53,118.19 v2(173.14,118.19)
  BOTTOM w0.089: v2(133.2,123.43) 133.2,123.15 133.32,123.02 133.45,123.02 133.84,123.41 RH223.1
  BOTTOM w0.102: v2(172.44,135.47) 172.68,135.71 U629.24
PCH_DPB_HPD: length 65.4
  TOP w0.089: UH1.AW4 133.79,120.94 133.79,120.96 v2(133.82,120.96)
  TOP w0.102: v2(177.19,132.64) v1(177.74,132.09) 179.19,130.64 180.76,130.64 181.08,130.32 181.08,126.99 179.81,125.71 179.81,122.7 179.51,122.4 178.56,122.4 177.7,121.54 v2(177.7,121.26)
  IN2 w0.089: v2(133.82,120.96) 136.86,117.93 141.38,117.93 141.55,118.1 141.76,118.1
  IN2 w0.127: v2(177.7,121.26) 177.48,121.04 171.87,121.04 167.97,117.14 164.85,117.14 164.06,117.93 161.65,117.93 161.4,117.69 153.92,117.69 153.57,117.33 144.7,117.33 143.93,118.1 141.76,118.1
  BOTTOM w0.102: U629.13 v2(177.19,132.64)
PCH_DPC_CTRL_CLK: length 111.9
  TOP w0.089: UH1.BB3 134.16,122.35 134.08,122.27 133.93,122.27 133.8,122.39 v2(133.8,122.77)
  TOP w0.102: v2(162.82,120.16) 162.9,120.24 163.03,120.24 163.14,120.13 163.14,119.88 162.57,119.31 162.01,119.31 160.32,117.62 160.32,114.39 161.83,112.87 161.83,108.54 160.89,107.59 160.89,106.32 161.19,106.01 161.19,99.59 161.29,99.49 161.29,98.98 160.52,98.21 160.52,93.7 159.43,92.62 156.56,92.62 156.22,92.96 153.23,92.96 152.61,93.57 152.01,93.57 151.67,93.91 151.08,93.91 150.88,93.71 150.66,93.71 150.54,93.58 v2(150.54,93.37)
  IN4 w0.089: 141.76,119.79 141.68,119.86 141.68,119.87 139.67,121.88 138.41,121.88 137.81,121.28 135.49,121.28 134.83,121.94 134.83,122.26 134.79,122.3 134.53,122.3 134.42,122.4 134.42,122.55 134.53,122.65 134.8,122.65 134.89,122.74 134.89,122.88 134.75,123.02 134.28,123.02 134.19,122.93 134.19,122.45 134.07,122.32 133.89,122.32 133.8,122.41 v2(133.8,122.77) 133.53,122.5 133.53,122.35 133.32,122.14 133.02,122.14 132.81,122.35 132.81,123.1 132.64,123.26 132.36,123.54 121.92,123.54 121.73,123.34 121.03,123.34 120.82,123.55 120.53,123.55 118.81,125.27 118.35,125.27 117.42,126.2
  IN4 w0.109: v2(162.82,120.16) 162.56,120.43 162.42,120.43 162.3,120.3 162.3,120.19 162.41,120.07 162.41,119.92 162.29,119.8 160.85,119.8 160.65,119.8 159.54,118.68 159.04,118.68 159.03,118.67 158.69,118.67 158.67,118.68 154.68,118.68 153.79,119.57 153.6,119.57 153.6,119.57 152.57,119.57 152.44,119.43 151.64,119.43 150.93,120.15 146.38,120.15 146,119.76 141.78,119.76 141.76,119.79 ; v2(109.2,132.61) 109.05,132.46 108.94,132.35 108.94,132.12 110.63,130.43 113.19,130.43 117.42,126.2
  BOTTOM w0.102: v2(109.2,132.61) 109.14,132.54 109.14,131.52 108.78,131.16 RH220.1 ; v2(150.54,93.37) 150.73,93.56 150.73,94.19 150.51,94.41 U631.25
PCH_DPC_CTRL_DATA: length 112
  TOP w0.089: UH1.BD6 132.7,122.99 v2(132.39,122.68)
  TOP w0.102: v2(151.17,93.37) 151.17,93.62 151.24,93.68 151.58,93.68 151.92,93.35 152.52,93.35 153.14,92.73 156.13,92.73 156.47,92.39 159.53,92.39 160.75,93.61 160.75,98.11 161.52,98.89 161.52,99.59 161.42,99.69 161.42,106.11 161.12,106.41 161.12,107.49 162.06,108.44 162.06,112.97 160.55,114.49 160.55,117.53 160.61,117.59 162.1,119.08 162.67,119.08 163.36,119.78 163.36,120.23 162.98,120.61 v2(162.98,120.73)
  IN4 w0.089: 117.08,126.2 118.23,125.05 118.72,125.05 120.44,123.33 120.73,123.33 121.5,122.56 123.86,122.56 124.63,123.32 131.08,123.32 131.24,123.17 131.42,123.17 131.56,123.3 131.75,123.3 131.81,123.24 131.81,123.12 131.56,122.86 131.56,122.73 131.66,122.64 131.79,122.64 132.31,123.16 132.44,123.16 132.58,123.02 132.58,122.87 v2(132.39,122.68) 132.56,122.5 132.56,122.29 132.69,122.17 132.93,121.92 133.41,121.92 133.62,122.13 134.33,122.13 134.35,122.11 134.81,121.65 135.4,121.06 137.9,121.06 138.5,121.66 139.58,121.66 141.47,119.78 141.47,119.77 141.5,119.73 141.5,119.73 141.52,119.71 141.52,119.69 141.59,119.62
  IN4 w0.109: v2(162.98,120.73) 162.98,120.58 163.23,120.33 163.23,119.99 162.92,119.68 162.5,119.68 162.39,119.57 160.75,119.57 159.63,118.45 159.14,118.45 159.12,118.44 158.59,118.44 158.58,118.45 154.58,118.45 153.7,119.33 152.67,119.33 152.54,119.2 152.34,119.2 151.54,119.2 150.83,119.91 146.48,119.91 146.09,119.53 141.68,119.53 141.59,119.62 ; v2(108.56,132.62) 108.72,132.46 108.71,132.45 108.71,132.02 110.53,130.2 113.09,130.2 117.08,126.2
  BOTTOM w0.102: U631.24 150.91,94.39 150.98,94.32 150.98,93.56 v2(151.17,93.37) ; RH221.1 108.56,131.39 108.69,131.39 108.91,131.61 108.91,132.27 v2(108.56,132.62)
PCH_DPC_HPD: length 49.7
  TOP w0.089: v2(133.79,121.75) 134.1,121.75 UH1.AY2
  TOP w0.102: v2(135.27,95.82) 135.65,95.82 135.99,96.16 142.87,96.16 v1(144.27,97.56) 145.42,98.71 153.37,98.71 v2(153.78,98.3)
  IN3 w0.089: 135.91,99.28 135.91,100.06 137.08,101.24 137.08,105.55 136.68,105.95 136.68,106.39 136.68,113.59 136.88,113.79 136.88,117.69 134.54,120.04 134.54,120.99 133.79,121.74 v2(133.79,121.75)
  IN3 w0.127: v2(135.27,95.82) 135.59,96.13 135.59,97.91 135.91,98.23 135.91,99.28
  BOTTOM w0.102: U631.13 v2(153.78,98.3)
PCH_DPD_CTRL_CLK: length 87.4
  TOP w0.089: UH1.BE5 132.96,124.11 133.06,124.21 133.06,124.52 133.61,125.08 133.9,125.37 v2(133.9,125.45)
  TOP w0.102: v2(174.05,95.08) 174.29,95.32 174.73,95.32 174.97,95.56 174.97,98.19 174.17,98.99 174.17,99.29 173.87,99.59 173.87,100.1 174.26,100.5 174.26,101.14 173.83,101.57 173.29,101.57 172.32,102.53 172.32,103.13 172.07,103.37 170.28,103.37 169.64,104.01 169.64,105.26 170.05,105.68 170.05,107.48 170.79,108.22 170.79,108.71 170.29,109.22 170.29,110.1 170.82,110.63 170.82,111.29 171.96,112.43 171.96,113.15 171.31,113.8 171.31,114.96 171.88,115.53 171.88,117.97 171.06,118.8 171.06,119.38 171.9,120.22 171.9,120.59 172.67,121.36 174.01,121.36 174.61,121.95 174.61,123.85 174.68,123.92 174.68,124.05 v2(174.7,124.06)
  IN4 w0.089: 140.85,124.83 140.6,124.83 140.59,124.84 140.52,124.84 140.51,124.85 138.25,124.85 137.65,125.44 136.13,125.44 135.98,125.3 135.45,125.3 135.33,125.43 135.19,125.56 134.01,125.56 v2(133.9,125.45)
  IN4 w0.109: v2(174.7,124.06) 174.68,124.05 174.68,124.04 174.3,123.65 169.05,123.65 168.92,123.52 168.15,123.52 166.88,124.79 157.77,124.79 155.95,126.61 154.52,126.61 153.95,127.18 153.6,127.18 152.87,127.91 152.31,127.91 152.18,127.78 152.18,127.16 151.76,126.75 151.54,126.75 151.3,126.5 150.22,126.5 148.89,125.17 146.4,125.17 146.01,124.78 145.08,124.78 145.03,124.72 144.49,124.72 144.33,124.88 142.76,124.88 142.7,124.82 142.4,124.82 142.39,124.83 140.85,124.83
  BOTTOM w0.089: v2(133.9,125.45) 134.14,125.69 134.14,126.2
  BOTTOM w0.102: v2(174.05,95.08) 173.52,95.08 173.28,94.84 U636.25 ; RH224.1 134.14,126.2
PCH_DPD_CTRL_DATA: length 88.2
  TOP w0.089: UH1.BE6 132.84,124.3 132.84,124.61 133.35,125.12 v2(133.35,125.56)
  TOP w0.102: v2(173.96,95.71) 174.12,95.55 174.64,95.55 174.74,95.66 174.74,98.09 173.94,98.89 173.94,99.19 173.64,99.5 173.64,100.2 174.03,100.59 174.03,101.04 173.73,101.34 173.19,101.34 172.09,102.44 172.09,102.97 171.91,103.14 170.18,103.14 169.41,103.92 169.41,105.36 169.82,105.77 169.82,107.58 170.57,108.32 170.57,108.62 170.06,109.13 170.06,110.2 170.59,110.73 170.59,111.39 171.73,112.53 171.73,113.06 171.09,113.7 171.09,115.06 171.65,115.63 171.65,117.88 170.83,118.7 170.83,119.48 171.67,120.31 171.67,120.68 172.57,121.58 173.92,121.58 174.38,122.05 174.38,123.8 v2(174.11,124.06)
  IN4 w0.089: v2(133.35,125.56) 133.35,125.67 133.49,125.81 134.01,125.81 134.05,125.78 135.28,125.78 135.48,125.58 135.54,125.52 135.89,125.52 136.04,125.66 137.74,125.66 138.34,125.06 140.62,125.06
  IN4 w0.109: v2(174.11,124.06) 173.94,123.89 168.95,123.89 168.82,123.76 168.24,123.76 166.98,125.02 157.87,125.02 156.05,126.84 154.62,126.84 154.04,127.42 153.7,127.42 152.97,128.15 152.21,128.15 151.94,127.88 151.94,127.26 151.66,126.98 151.44,126.98 151.2,126.74 150.13,126.74 148.79,125.4 146.3,125.4 145.91,125.01 144.99,125.01 144.93,124.96 144.59,124.96 144.43,125.12 142.66,125.12 142.6,125.05 142.5,125.05 142.49,125.06 140.62,125.06
  BOTTOM w0.089: v2(133.35,125.56) 133.71,125.92 133.71,126.2
  BOTTOM w0.102: 133.71,126.2 133.71,126.83 134.14,127.26 RH225.1 ; v2(173.96,95.71) 173.87,95.61 173.71,95.61 173.34,95.24 U636.24
PCH_DPD_HPD: length 67
  TOP w0.089: v2(133.08,121.03) 133.17,120.94 133.17,120.48 UH1.AV4
  IN2 w0.089: v2(133.08,121.03) 133.08,121.56 133.78,122.26 135.11,122.26 136.1,123.25 136.1,123.58 136.93,124.4 137.23,124.4 137.41,124.21 140.86,124.21 141.08,124.43 141.15,124.43 141.21,124.46 141.21,124.47
  IN2 w0.127: v2(166.14,123.51) 165.23,124.42 156.44,124.42 155.36,125.5 154.43,125.5 154.33,125.6 153.2,125.6 153.18,125.57 150.99,125.57 149.71,124.29 144.73,124.29 144.55,124.47 141.22,124.47 141.21,124.47
  IN3 w0.127: v2(169.2,97.99) 167.8,99.39 167.8,103.18 169.23,104.61 169.23,105.3 168.9,105.63 168.9,105.9 167.6,107.2 166.49,107.2 166.16,107.53 166.16,108.95 166.32,109.11 166.32,117.85 166.14,118.03 v2(166.14,123.51)
  BOTTOM w0.102: v2(169.2,97.99) 169.38,97.81 U636.13
PCH_DPWROK: length 78.9
  TOP w0.089: UH1.AV11 v2(130.58,120.24)
  IN4 w0.089: v2(130.58,120.24) 130.66,120.16 130.66,119.88 131.31,119.23 131.96,119.23 132.1,119.37 135.39,119.37 136.02,118.74 141.16,118.74 141.34,118.56 141.76,118.56
  IN4 w0.109: 141.76,118.56 143.48,118.56 143.72,118.32 150.64,118.32 151.93,117.03 153.91,117.03 154.29,117.41 154.44,117.41 154.46,117.43 160.67,117.43 160.75,117.51 162.02,117.51 162.37,117.85 164.43,117.85 165.21,117.08 166.3,117.08 167.25,116.12 170.59,116.12 171.47,115.25 172.65,115.25 175.3,112.6 176.55,112.6 177.37,111.78 183.77,111.78 185.29,110.26 188.3,110.26 188.82,110.78 190.38,110.78 191.2,109.96 v2(191.49,109.96)
  BOTTOM w0.089: RH215.1 131.09,122.85 v1(131.09,123.51) 131.09,123.67 ; v2(130.58,120.24) 130.8,120.46
  BOTTOM w0.102: 130.8,120.46 131.04,120.7 131.04,121.99 RH215.1 ; 131.09,123.67 131.42,123.99 131.42,124.47 131.27,124.62 131.27,125.39 CH266.1 RH308.1 ; v2(191.49,109.96) 191.49,108.99 192.24,108.24 R802.1
PCH_INTRUDER_HDR#: length 7
  TOP w0.089: 129.96,126.2 129.96,125.95 130.34,125.57 130.34,125.13 129.77,124.56 UH1.BE11
  TOP w0.102: RH198.2 129.96,130.18 v1(129.96,128.8) 129.96,126.2
PCH_JTAG_TCK: length 260.2
  TOP w0.089: UH1.AN3 134.14,118.13 134.39,118.38 134.88,118.38 135.07,118.57 136.63,118.57 137.14,119.08 137.81,119.08 ; T188.1 140.89,119.27 141.39,119.78 RH313.2 141.76,120.32
  TOP w0.102: v2(142.46,121.48) 142.46,121.02 141.76,120.32 ; JXDP1.55 v2(157.86,7.64) ; 137.81,119.08 139.11,119.08 T188.1
  IN1 w0.109: v2(106.28,102.06) 106.34,102 107.93,102 108.38,101.55 112.1,101.55 112.79,100.86 114.28,100.86 114.41,100.73 116.37,100.73 117.94,99.17 117.94,95.15 116.55,93.77 115.78,93.77 114.5,92.48 111.34,92.48 110.86,92 107.9,92 106.8,93.1 106.08,93.1 101.8,88.82 101.8,84 101.07,83.27 99.8,83.27 93.54,77.01 93.54,74.35 94.41,73.48 94.41,37.56 94.85,37.13 94.85,37.1 100.16,31.79 100.16,16.17 102.33,14 107.03,14 114.15,6.88 130.12,6.88 130.12,6.88 130.52,6.88 130.67,7.02 132.47,7.02 132.48,7.03 133.39,7.03 135.7,9.34 138.9,9.34 139.05,9.49 139.8,9.49 139.95,9.34 141.14,9.34 141.18,9.3 143.15,9.3 143.25,9.32 144.03,10.1 145.47,10.1 145.84,9.73 157.14,9.73 157.87,9.01 157.87,7.64 v2(157.86,7.64)
  BOTTOM w0.089: 112.37,111.56 112.84,111.56 113.64,110.76 114.72,110.76 115.23,111.27 119.99,111.27 120.76,112.03 120.76,115.97 121.14,116.35 126.79,116.35 127.49,117.05 128.06,117.05 128.5,116.61 129.46,116.61 130.03,116.03 134.03,116.03 135.23,114.83 137.91,114.83 138.03,114.96 138.03,116.23 138.66,116.86 141.2,116.86 141.52,117.18 141.52,118.36 141.76,118.6
  BOTTOM w0.102: 141.76,118.6 141.92,118.76 141.92,120.51 142.21,120.8 142.21,121.27 142.42,121.48 v2(142.46,121.48) ; v2(106.28,102.06) 105.39,102.06 104.82,101.49 v3(103.37,101.49) 101.32,101.49 100.69,102.13 100.69,104.73 103.22,107.26 103.22,108.85 104.08,109.71 106.74,109.71 107.29,110.27 107.29,110.38 108.47,111.56 112.37,111.56
PCH_JTAG_TDI: length 159.4
  TOP w0.089: 137.71,120.04 137.6,120.04 136.49,118.93 134.69,118.93 134.45,118.69 UH1.AP2
  TOP w0.102: v2(163.92,74.23) 164.27,73.87 164.27,72.1 160.09,67.92 160.09,60.19 159.51,59.6 159.51,47.56 157.69,45.74 157.69,29.1 166.87,19.92 171.01,19.92 173.67,17.25 173.67,13.96 170.14,10.43 170.14,9.09 RC308.2 ; 137.71,120.04 138.22,120.04 v2(138.54,120.35)
  IN3 w0.089: v2(138.54,120.35) 139.05,119.84 139.05,118.7 139.86,117.89 139.86,115.66 140.25,115.27 140.25,114.05 137.75,111.55 137.75,106.39 138.15,105.99 138.15,102.64 138.71,102.09 138.71,99.28
  IN3 w0.127: v2(163.92,74.23) 164.41,73.74 164.41,72.68 163.76,72.03 153.08,72.03 150.47,74.63 145.65,74.63 144.46,75.82 144.46,83.56 138.79,89.23 138.79,95.27 139.74,96.22 139.74,97.56 139.42,97.87 139.24,97.87 138.71,98.4 138.71,99.28
  BOTTOM w0.089: T187.1 139.16,121.44 RH314.2 138.76,120.67 138.54,120.44 v2(138.54,120.35)
PCH_JTAG_TDO: length 166.7
  TOP w0.089: 137.71,119.81 137.62,119.81 136.56,118.75 134.86,118.75 UH1.AP1
  TOP w0.102: v2(163.92,75.41) 164.73,74.6 164.73,71.91 160.55,67.73 160.55,47.95 158.55,45.95 158.55,28.89 167.06,20.38 171.2,20.38 174.13,17.44 174.13,13.77 170.71,10.35 170.71,8.38 169.91,7.58 RC309.2 ; v2(138.54,119.53) 138.25,119.81 137.71,119.81
  IN3 w0.089: v2(138.54,119.53) 138.54,118.41 137.57,117.44 137.57,115.28 137.67,115.18 139.14,115.18 139.25,115.29 139.25,115.29 139.33,115.37 139.9,115.37 140.07,115.2 140.07,114.12 137.57,111.62 137.57,106.32 137.97,105.92 137.97,102.48 138.45,102 138.45,99.28
  IN3 w0.127: 138.45,99.28 138.45,98.3 139.13,97.62 139.26,97.62 139.45,97.43 139.45,96.54 138.54,95.63 138.54,89.13 144.21,83.46 144.21,75.71 145.54,74.38 150.37,74.38 152.97,71.78 163.92,71.78 164.71,72.56 164.71,74.62 v2(163.92,75.41)
  BOTTOM w0.089: T186.1 141.41,118.97 139.47,118.97 139.16,119.28 RH315.2 138.76,119.78 138.54,119.55 v2(138.54,119.53)
PCH_JTAG_TMS: length 155.5
  TOP w0.089: UH1.AR2 134.6,119.11 136.42,119.11 137.58,120.27 137.71,120.27
  TOP w0.102: v2(163.75,73.6) 164.04,73.31 164.04,72.19 159.86,68.01 159.86,60.28 159.28,59.7 159.28,47.65 157.28,45.65 157.28,29.19 166.78,19.69 170.91,19.69 173.44,17.16 173.44,14.1 169.71,10.37 RC307.2 ; 137.71,120.27 137.84,120.27 138.54,120.97 v2(138.54,120.99)
  IN3 w0.089: v2(138.54,120.99) 139.23,120.29 139.23,118.77 140.03,117.96 140.03,115.74 140.43,115.34 140.43,113.98 137.93,111.48 137.93,106.46 138.33,106.06 138.33,102.72 138.96,102.08 138.96,99.28
  IN3 w0.127: 138.96,99.28 138.96,98.51 139.32,98.15 140.14,98.15 140.69,97.6 140.69,94.32 140,93.62 140,92.1 140.31,91.78 140.31,90.76 139.71,90.16 139.71,89.07 149.45,79.32 149.95,79.32 149.95,79.32 150.89,79.32 152.53,77.68 152.53,76.32 154.98,73.87 158.07,73.87 159.66,72.28 163.59,72.28 164.09,72.78 164.09,73.27 v2(163.75,73.6)
  BOTTOM w0.089: RH312.2 139.92,122.52 T183.1 139.32,122.57 138.54,121.78 v2(138.54,120.99)
PCH_JTAGX: length 145.4
  TOP w0.089: v2(137.48,120.69) 136.97,120.18 136.97,119.91 136.59,119.53 136.34,119.29 134.88,119.29 134.63,119.54 134.12,119.54 UH1.AR3
  TOP w0.102: v2(163.07,72.84) 163.06,72.83 163.06,72.57 158.83,68.34 158.83,66.14 157.92,65.23 156.88,65.23 148.45,56.8 148.45,34.4 163.16,19.69 163.16,18.19 164.22,17.14 164.22,15.92 163.86,15.56 RC166.1 RC143.2
  IN3 w0.089: v2(137.48,120.69) 137.59,120.69 138.46,121.56 138.93,121.56 139.42,121.06 139.42,118.83 139.61,118.64 140.21,118.04 140.21,115.94 140.61,115.54 140.61,113.9 138.1,111.4 138.1,106.54 138.51,106.14 138.51,103.11 138.98,102.64 138.98,102.5 139.47,102.01 139.47,99.28
  IN3 w0.127: 139.47,99.28 139.47,98.75 139.56,98.66 140.35,98.66 141.2,97.81 141.2,92.03 140.82,91.65 140.82,90.55 140.22,89.95 140.22,89.35 141.56,88.02 142.04,88.02 150.23,79.83 151.1,79.83 153.04,77.89 153.04,76.53 155.19,74.38 158.28,74.38 159.05,73.62 161.83,73.62 162.61,72.84 v2(163.07,72.84)
  BOTTOM w0.089: T182.1 137.75,120.96 v2(137.48,120.69)
PCH_PCIE_WAKE#: length 87.1
  TOP w0.089: UH1.BC13 129.16,122.82 129.33,122.64 129.33,122.18 v2(129.61,121.9)
  IN4 w0.089: v2(129.61,121.9) 130.14,121.38 130.81,121.38 130.97,121.23 130.97,121.14 131.76,120.35 134.8,120.35 136.23,118.92 141.28,118.92 141.39,118.8 141.76,118.8
  IN4 w0.109: v2(197.64,112.72) 197.38,112.98 196.19,112.98 195.86,112.64 194.16,112.64 194.01,112.49 193.37,112.49 192.16,111.28 191.08,111.28 190.9,111.1 185.63,111.1 185.62,111.11 184.77,111.11 183.86,112.02 177.47,112.02 176.65,112.83 175.46,112.83 173.95,114.35 173.95,115.12 173.22,115.84 172.13,115.84 171.64,116.33 171.64,116.97 171.43,117.17 167.26,117.17 165.61,118.82 162.09,118.82 161.01,117.74 160.65,117.74 160.57,117.67 154.36,117.67 154.35,117.65 153.4,118.6 152.97,118.6 152.83,118.46 150.83,118.46 150.74,118.56 143.82,118.56 143.58,118.8 141.76,118.8
  BOTTOM w0.089: v2(129.61,121.9) 129.23,122.29 129.23,123.49 v1(129.76,124.01) 130.13,124.39 130.13,126.2
  BOTTOM w0.102: RH92.1 129.58,129.04 129.58,127.26 130.13,126.7 130.13,126.2 ; v2(197.64,112.72) 197.37,112.99 196.45,112.99 196.08,112.61 U51.B46
PCH_PECI: length 9.8
  TOP w0.089: UH1.AL3 134.01,117.04 134.25,116.8 134.54,116.8 134.93,117.19 136.89,117.19 137.56,117.85 138.14,117.85
  TOP w0.102: RH73.1 141.47,116.78 RH74.1 141.4,116.84 140.46,116.84 v1(140.37,116.93) 139.91,116.93 139.12,117.72 138.84,117.72 138.71,117.85 138.14,117.85
PCH_PLTRST#: length 126.6
  TOP w0.089: v2(119.76,125.52) 120.24,126 v1(120.53,126) 120.98,126 121.45,125.53 121.45,124.82 121.44,124.8 121.44,123.81 121.58,123.68 121.58,122.94 121.57,122.93 121.57,122.72 121.58,122.71 121.58,122.7 121.78,122.5 UH1.BB27
  TOP w0.102: U638.2 107.42,119.55 107.65,119.32 v2(107.65,119.04) 106.96,119.04 106.77,119.24 U638.1
  IN2 w0.089: v2(119.76,125.52) 119.75,125.52 119.71,125.56 119.05,125.56 118.81,125.32 117.98,125.32 117.09,126.2
  IN2 w0.127: v2(107.65,119.04) 107.65,122.73 106.71,123.67 106.71,126.5 109.83,129.62 113.07,129.62 113.83,128.86 113.83,127.67 114.95,126.55 116.75,126.55 117.09,126.2
  IN4 w0.089: 141.76,122.3 140.59,122.3 139.41,123.48 138.07,123.48 137.04,122.45 136.43,122.45 136.28,122.3 136.28,122.19 136.06,121.97 135.71,121.97 135.46,122.22 135.46,123.13 134.58,124.01 131.78,124.01 131.51,123.74 120.92,123.74 119.76,124.91 v2(119.76,125.52)
  IN4 w0.109: 141.76,122.3 143.38,122.3 143.83,121.85 144.29,121.85 144.34,121.91 145.75,121.91 146.33,122.48 150.98,122.48 151.16,122.67 152.41,122.67 152.78,122.29 162.13,122.29 162.28,122.44 164.73,122.44 165.61,121.56 166.11,121.56 166.83,120.84 167.18,120.84 167.99,120.04 170.69,120.04 171.15,120.49 172.99,120.49 173.48,120.01 178.58,120.01 178.69,120.11 179.72,120.11 180.64,121.03 189.64,121.03 v2(189.65,121.05)
  BOTTOM w0.102: v2(189.65,121.05) 189.65,121.94 188.76,122.83 188.76,122.93 187.61,124.08 187.61,126.12 186.8,126.93 186.8,130.12 186.47,130.45 RH194.1 186.47,131.92 186.54,132 RH195.1 RH187.1 ; RH211.1 106.73,120.16 107.65,119.25 v2(107.65,119.04) 107.65,118.84 106.96,118.16 RH210.1
PCH_PLTRST#_AND: length 9.2
  TOP w0.102: RH346.1 110.01,123.16 v1(110.13,123.05) 110.19,122.98 110.19,122.55 109.86,122.22 RH337.1 108.84,122.22 108.4,121.77 U638.4 108.07,121.22 107.85,121 v2(107.22,121)
  BOTTOM w0.102: v2(107.22,121) 107.22,121.79 106.86,122.14 RH197.1 ; RH197.1 106.43,122.5 106.35,122.58 RH196.1 ; RH197.1 RH212.1
PCH_PLTRST#_EC: length 598.1
  TOP w0.102: RH337.2 109.33,120.28 v2(108.91,119.86) ; v2(206.89,137.62) 206.86,137.62 209.47,135.02 v2(209.47,131.27) 209.47,130.66 210.42,129.71 210.42,125.7 215.17,120.95 215.17,120.77 216.03,119.9 216.03,117.76 217.04,116.75 217.04,116.21 217.42,115.83 v2(218.22,115.83) ; v2(188.83,136.86) 188.83,136.86 188.31,136.35 188.31,135.34 188.58,135.07 188.58,133.9 187,132.32 187,126.71 187.55,126.16 187.55,125.08 186.29,123.82 186.29,117.33 186.66,116.96 187.1,116.96 187.51,116.56 188.7,116.56 190.38,114.88 191.64,114.88 192.28,114.23 192.28,112.58 v2(191.62,111.92) 192.16,111.38 192.16,108.55 193.45,107.26 v2(193.77,107.26)
  IN1 w0.089: 112.37,119.25 113.24,119.25 113.77,119.78 113.77,121.83 115.56,123.62 123.36,123.62 123.4,123.57 124.99,123.57 126.04,124.63 127.09,124.63 127.91,125.45 128.34,125.45 128.74,125.85 130.54,125.85 130.61,125.78 132.32,125.78 132.75,126.2
  IN1 w0.109: v2(154.11,133.44) 153.88,133.2 152.68,133.2 151.28,134.6 151.13,134.6 151.11,134.61 144.07,134.61 143.47,134.02 142.34,134.02 141.17,132.84 140.5,132.84 139.64,131.98 136.03,131.98 133.72,129.67 133.72,127.17 132.75,126.2 ; v2(56.11,68.09) 59.03,65.17 63.29,65.17 90.21,92.1 90.21,93.24 99.29,102.32 99.29,104.99 102.53,108.22 102.53,109.43 102.21,109.75 98.91,109.75 97.96,110.7 97.96,112.99 101.83,116.86 101.83,117.69 102.98,118.83 103.86,118.83 104.94,119.91 108.86,119.91 v2(108.91,119.86) 109.55,119.86 110.16,119.25 112.37,119.25 ; v2(218.22,115.83) 218.33,115.94 218.42,115.94 219.09,116.61 223.61,116.61 224.58,115.64 224.58,113.75 225.03,113.3 227.03,113.3 227.14,113.41 229.54,113.41 230.37,112.58 230.37,111.95 234.92,107.4 242.76,107.4 244.73,105.44 245.74,105.44 246.12,105.05 246.12,94.81 247.08,93.85 247.08,91.74 250.73,88.09 250.73,85.49 251.76,84.46 252.47,84.46 253.92,83.01 253.92,76.49 255.42,74.99 255.42,72.63 261.15,66.9 261.15,63.81 266.43,58.53 268.06,58.53 277.4,49.19 282.65,49.19 283.74,48.11 285.1,48.11 285.59,47.62 288.71,47.62 291.22,45.12 302.69,45.12 303.74,44.06 308.32,44.06 308.75,43.63 310.41,43.63 314.72,39.32 317.31,39.32 317.96,38.67 317.96,37.13 319.26,35.83 v2(319.26,35.83)
  IN2 w0.127: v2(206.89,137.62) 206.86,137.62 206.25,138.23 201.71,138.23 199.67,136.19 197.3,136.19 197.13,136.37 189.64,136.37 189.37,136.64 189.05,136.64 v2(188.83,136.86)
  IN3 w0.127: v2(173,116.25) 173,117.64 172.72,117.91 172.72,118.62 171.99,119.35 171.99,127.62 171.14,128.47 169.79,128.47 169.21,129.05 169.21,130.84 171.74,133.37 v2(171.88,133.37)
  IN4 w0.109: v2(173,116.25) 173.15,116.25 174.73,114.67 174.73,114.12 175.19,113.66 176.34,113.66 176.74,113.26 177.87,113.26 178.74,112.39 182.54,112.39 v2(182.58,112.43) 182.99,112.84 184.6,112.84 184.86,112.58 187.21,112.58 187.62,112.16 189.72,112.16 189.97,111.92 v2(191.62,111.92) ; v2(193.77,107.26) 193.89,107.39 194.08,107.39 194.62,107.92 194.89,107.92 195.97,109 196.81,109 196.97,109.16 v2(197.5,109.16) ; v2(171.88,133.37) 171.13,132.62 166.54,132.62 163.92,135.23 156.16,135.23 154.89,133.96 154.64,133.96 v2(154.11,133.44) ; v2(24.95,7.54) 24.95,8.9 22.46,11.39 22.46,22.69 22.08,23.07 20.93,23.07 19.63,24.37 19.63,29.2 11.85,36.98 6.32,36.98 2.26,41.03 2.26,56.73 10.58,65.04 17.44,65.04 18.71,66.31 53.89,66.31 55.67,68.09 v2(56.11,68.09)
  BOTTOM w0.102: v2(218.22,115.83) 218.66,115.83 218.78,115.95 JNGFF1.44 ; U51.B30 198.5,106.89 198.84,107.22 198.84,107.99 198.4,108.43 197.87,108.43 197.5,108.8 v2(197.5,109.16) ; JLPDE1.8 205.21,130.68 205.32,130.58 208.77,130.58 v1(208.95,130.76) v2(209.47,131.27) ; JNGFF2.42 319.41,35.68 v2(319.26,35.83) ; JNGFF3.50 15,10.19 15,9.73 17.2,7.54 v2(24.95,7.54) ; U46.B22 183.8,112.86 183.4,112.86 183.4,112.86 182.95,112.86 182.58,112.49 v2(182.58,112.43)
PCH_PWROK: length 230.5
  TOP w0.089: UH1.AW11 v2(130.58,121)
  TOP w0.203: PU1100.45 261.25,44.77 261.45,44.98 261.89,44.98 PR1114.2 ; v2(256.8,31.35) 256.82,31.33 PU1600.6
  TOP w0.254: v2(261.52,43.84) 261.52,43.98 PR1114.2
  IN1 w0.109: v2(257.38,34.53) 257.38,35.25 258.19,36.06 v2(258.83,36.06)
  IN3 w0.127: v2(221.9,102.94) 221.32,102.94 220.92,103.34 220.92,104.76 220.63,105.05 220.63,106.22 220.13,106.72 220.13,107.17 220.63,107.67 220.63,110.38 220.5,110.51 220.5,111.62 v2(218.66,113.46)
  IN3 w0.254: v2(257.38,34.53) 256.95,34.96 256.25,34.96 255.84,34.55 255.84,32.31 v2(256.8,31.35)
  IN4 w0.089: v2(130.58,121) 130.18,120.6 130.18,119.82 130.94,119.05 132.03,119.05 132.17,119.2 135.12,119.2 135.81,118.51 141.04,118.51 141.22,118.33 141.76,118.33
  IN4 w0.109: v2(241.47,100.99) 240.96,100.99 240.83,100.86 240.2,100.86 240,101.06 238.85,101.06 237.87,102.05 226.23,102.05 225.71,102.57 223.5,102.57 223.18,102.89 221.95,102.89 v2(221.9,102.94) ; 141.76,118.33 143.38,118.33 143.62,118.09 149.42,118.09 150.2,117.31 151.32,117.31 151.83,116.8 154.01,116.8 154.39,117.18 154.54,117.18 154.56,117.19 160.77,117.19 160.84,117.27 162.12,117.27 162.46,117.62 164.34,117.62 165.11,116.84 166.06,116.84 167.01,115.89 170.5,115.89 171.37,115.01 172.55,115.01 175.2,112.36 176.46,112.36 177.27,111.54 183.67,111.54 185.21,110 188.45,110 188.99,110.54 190.19,110.54 191.24,109.49 192.05,109.49 193.2,110.64 194.5,110.64 195.55,111.68 196.53,111.68 196.78,111.43 197.62,111.43 198.09,111.9 198.09,113.08 198.33,113.32 198.95,113.32 199.53,113.91 199.53,114.78 200.34,115.59 204.94,115.59 205.36,116.01 206.18,116.01 206.77,115.41 209.34,115.41 210.01,114.74 212.38,114.74 213.39,113.73 214.47,113.73 214.55,113.81 218.31,113.81 v2(218.66,113.46)
  BOTTOM w0.102: v2(241.47,100.99) 241.47,100.73 244.7,97.51 244.7,97.48 245.1,97.08 245.1,96.82 245.28,96.64 245.28,96.03 243.3,94.05 243.3,91.63 242.56,90.9 242.56,89.44 241.69,88.57 241.69,82.12 243.69,80.11 243.69,76.07 v1(244.99,74.77) 246.32,73.44 246.32,70.51 246.18,70.37 246.18,68.42 245.57,67.81 245.57,60.37 250.25,55.7 250.65,55.7 259.59,55.7 262.12,53.18 262.12,44.43 v2(261.52,43.84) 260.27,42.58 260.27,37.49 v2(258.83,36.06)
PCH_RSMRST#: length 18.7
  TOP w0.102: v2(189.46,114.31) 190.09,113.68 190.09,110.51 190.24,110.36 190.24,108.3 188.7,106.75 188.7,105.11 188.98,104.83 UC4.1
  IN4 w0.109: v2(193.73,112.92) 192.69,112.92 192.17,112.4 191.21,112.4 190.74,112.87 190.74,113.57 189.99,114.31 v2(189.46,114.31)
  BOTTOM w0.102: R892.2 193.26,113.4 v2(193.73,112.92) 194.17,113.36 U51.A45
PCH_RSMRST#_R: length 210.1
  TOP w0.089: UH1.BA11 v2(130.58,121.77)
  TOP w0.102: RC124.1 155.98,15.64 155.87,15.76 155.87,18.55 145.58,28.85 145.58,60.14 156.03,70.59 157.14,70.59 160.51,73.96 160.51,76.45 161.46,77.4 164.15,77.4 165.36,78.61 v2(166.79,78.61) ; RC154.2 190.66,102.48 RC318.1 189.26,102 188.53,102 v2(188.1,101.58) 188.1,101.58 187.66,102.02 187.66,102.02 187.63,102.05 187.63,104.55 188.47,105.39 188.47,106.85 190.01,108.39 190.01,110.26 189.15,111.13 189.15,111.98 189.77,112.6 189.77,113.27 v2(189.59,113.44)
  IN3 w0.127: v2(188.1,101.58) 188,101.48 188,98.16 191.16,95.01 191.16,88.16 191.95,87.37 v2(191.95,86.63)
  IN4 w0.089: v2(130.58,121.77) 130.91,121.77 131.3,121.38 131.3,121.06 131.83,120.53 134.87,120.53 136.31,119.09 141.46,119.09 141.51,119.04 141.76,119.04
  IN4 w0.109: v2(189.59,113.44) 189.23,113.44 188.84,113.05 187.42,113.05 186.79,113.68 182.46,113.68 182.21,113.42 178.04,113.42 177.97,113.49 176.83,113.49 176.44,113.89 175.29,113.89 174.96,114.22 174.96,114.77 173.44,116.3 173.44,116.4 173.03,116.8 172.18,116.8 171.58,117.41 167.35,117.41 165.71,119.06 161.93,119.06 160.85,117.98 160.55,117.98 160.47,117.9 154.43,117.9 153.49,118.84 152.87,118.84 152.73,118.7 151.35,118.7 151.25,118.8 143.92,118.8 143.68,119.04 141.76,119.04
  BOTTOM w0.089: v2(130.58,121.77) 130.59,121.77 RH215.2
  BOTTOM w0.102: v2(191.95,86.63) 191.95,85.75 190.05,83.84 187.57,83.84 182.77,79.04 167.26,79.04 166.86,78.63 166.82,78.63 v2(166.79,78.61) ; T191.1 188.54,101.14 v2(188.1,101.58)
PCH_RTCRST#: length 148.5
  TOP w0.089: UH1.BC10 130.34,123.28 130.2,123.41 130.2,123.65 130.22,123.66 130.22,124.24 130.25,124.27 130.25,124.51 130.71,124.98 130.71,125.01 130.73,125.03 130.73,125.7 130.69,125.74 130.69,126.2
  TOP w0.102: v1(222.76,103.96) 222.76,103.5 v2(222.93,103.34) ; 130.69,126.2 130.69,127.19 131.72,128.23 131.72,128.98 132.19,129.44 v2(132.19,129.81)
  IN3 w0.127: v2(222.93,103.34) 222.93,105.96 222.61,106.28 222.18,106.28 222.02,106.44 222.02,108.48 222.33,108.79 222.33,110.62 222.32,110.63 222.32,111.38 222.55,111.61 222.55,114.63 222.09,115.09 222.09,118.27 221.09,119.27 221.09,127.76 220.88,127.96 220.88,129.83 v2(218.36,132.35)
  IN4 w0.109: v2(218.36,132.35) 217.84,132.87 216.2,132.87 216,133.06 213.41,133.06 211.65,134.83 205.59,134.83 204.81,134.04 198.9,134.04 198.58,134.37 195.89,134.37 194.18,136.08 191.28,136.08 190.27,135.07 187.73,135.07 185.93,133.27 184.07,133.27 183.3,132.5 180.37,132.5 179.35,133.51 174.91,133.51 173.79,134.64 172,134.64 171.86,134.5 168.91,134.5 168.16,135.24 165.14,135.24 164.13,136.25 161.57,136.25 160.23,137.59 155.82,137.59 155.41,137.18 154.54,137.18 150.73,133.37 147.13,133.37 144.1,130.34 144.08,130.34 144.06,130.32 142.28,130.32 141.91,129.95 138.33,129.95 138.32,129.96 133.54,129.96 132.93,130.58 132.5,130.58 132.19,130.26 v2(132.19,129.81)
  BOTTOM w0.102: v2(222.93,103.34) 222.41,102.82 222.41,99.26 222.48,99.19 JAPS1.9 ; CMOS1.2 135.04,128.46 135.04,130.02 RH200.2 CH40.2 133.44,129.56 133.06,129.94 132.31,129.94 v2(132.19,129.81)
PCH_RTCX1: length 15.5
  TOP w0.089: 131.61,126.2 131.09,125.68 131.09,124.87 130.59,124.37 130.59,123.75 130.65,123.69 130.65,123.65 130.66,123.65 130.66,123.15 130.92,122.9 UH1.BC9
  TOP w0.102: v2(133.33,134.69) 133.33,134.69 RH43.2 RH44.1 ; v2(131.56,126.67) 131.7,126.53 131.7,126.29 131.61,126.2
  IN1 w0.109: v2(133.33,134.69) 133.72,134.69 133.9,134.51 133.9,133.25 133.37,132.72 133.37,131.76 131.72,130.11 131.72,126.81 131.58,126.67 v2(131.56,126.67)
PCH_RTCX1_R: length 5.9
  TOP w0.102: RH43.1 CH4.2 135.48,135.6 v1(136,135.08) 136.38,134.7 137.33,134.7 138.54,133.5 YH1.1
PCH_RTCX2: length 16.9
  TOP w0.089: UH1.BD10 130.43,123.64 130.4,123.67 130.4,124.04 130.42,124.06 130.42,124.44 130.88,124.9 130.88,124.94 130.9,124.95 130.9,125.77 130.92,125.79 130.92,126.2
  TOP w0.102: v2(131.09,127.02) 130.92,126.84 130.92,126.2 ; YH1.2 135.93,133.5 135.34,132.91 CH5.2 RH44.2 133.85,132.91 133.39,133.37 133.39,133.96 v2(133.28,134.08)
  IN1 w0.109: v2(131.09,127.02) 131.13,127.06 131.13,128.2 130.33,129 130.33,130.17 132.88,132.73 132.88,132.93 133.41,133.45 133.41,133.95 v2(133.28,134.08)
PCH_SATA_LED#: length 317.2
  TOP w0.089: UH1.AD44 113.08,113.71 112.8,113.99 112.37,113.99
  TOP w0.102: v2(296.9,22.56) 296.99,22.47 296.99,21.9 297.01,21.89 297.01,21.89 297.24,21.65 297.25,21.65 299.19,19.71 299.19,18.02 299.5,17.7 299.5,17.05 304.91,11.65 304.91,11.09 305.26,10.74 305.88,10.74 306.03,10.59 306.03,9.25 305.55,8.77 305.55,6.75 305.06,6.26 302.34,6.26 D97.1 300.36,5.39 R383.2 ; v2(110.11,113.88) 110.55,114.32 110.98,114.32 111.3,113.99 112.37,113.99
  IN2 w0.089: 112.37,113.88 113.19,114.7 119.99,114.7 120.69,115.4 123.76,115.4 123.99,115.17 123.99,114.92 124.27,114.64 124.52,114.64 124.76,114.41 124.76,114.16 125.04,113.88 127.23,113.88 127.49,113.62 133.65,113.62 136.64,110.64 141.76,110.64
  IN2 w0.127: v2(226.98,117.47) 226.19,118.26 226.19,122.09 222.81,125.47 221.03,125.47 220.1,126.39 216.23,126.39 215.81,125.97 211.91,125.97 211.19,125.25 206.3,125.25 205.64,125.9 201.63,125.9 200.56,124.83 196.49,124.83 196.29,124.63 194.47,124.63 193.72,123.88 192.55,123.88 191.06,122.4 188.48,122.4 187.61,121.52 184.66,121.52 184.19,121.05 180.93,121.05 180.44,120.56 180.44,120.19 179.92,119.67 179.08,119.67 178.92,119.51 173.51,119.51 171.93,117.93 171.14,117.93 169.94,116.73 169.94,116.33 170.38,115.89 170.38,113.95 170.39,113.95 170.39,111.59 169.7,110.9 169.37,110.9 169.22,110.75 169.22,110.25 168.72,109.75 167.51,109.75 166.67,110.59 164.71,110.59 164.29,111.01 153.63,111.01 152.85,110.22 149.01,110.22 148.57,109.77 147.29,109.77 146.43,110.64 141.76,110.64 ; 112.37,113.88 v2(110.11,113.88)
  BOTTOM w0.102: v2(296.9,22.56) 296.9,22.64 294,25.54 293.86,25.54 292.09,27.32 292.09,39.04 290.46,40.67 282.43,40.67 280.55,42.55 274.24,42.55 v1(265.34,51.45) 264.25,52.54 264.25,54.13 260.12,58.26 256.87,58.26 256.45,57.84 251.12,57.84 247.71,61.26 247.71,66.57 249.1,67.97 249.1,78.48 245.6,81.98 245.6,88.25 245.35,88.5 245.35,90.13 247.53,92.3 247.53,92.68 249.85,95.01 249.85,100.99 248.38,102.46 248.38,103.56 247.31,104.62 247.16,104.62 237.84,113.94 228.5,113.94 226.98,115.46 v2(226.98,117.47)
PCH_SMB_ALERT#: length 2.2
  TOP w0.089: UH1.BB41 115.06,122.88 115.32,122.88 115.33,122.87 v2(115.33,122.87)
  BOTTOM w0.102: RH61.2 114.56,123.86 115.33,123.09 v2(115.33,122.87)
PCH_SPI_CLK: length 71.3
  TOP w0.089: UH1.BC31 120.06,123.11 120.31,123.36 120.31,123.61 120.24,123.68 120.24,123.73 119.09,124.88 117.06,124.88 115.93,126 115.93,126.16
  TOP w0.102: v2(115.04,131.97) 114.91,131.85 v1(114.91,128.8) 114.91,128.4 115.36,127.95 115.36,127.41 115.93,126.84 115.93,126.16
  IN4 w0.109: v2(160.63,126.13) 160.05,126.71 160.05,128.64 159.78,128.91 157.53,128.91 156.76,129.68 153.85,129.68 152.76,130.77 147.04,130.77 143.7,127.43 139.99,127.43 139.83,127.28 137.64,127.28 137.33,127.59 135.87,127.59 135.39,127.11 132.98,127.11 132.12,126.26 130.85,126.26 130.42,126.69 130.42,127.29 129.82,127.9 125.55,127.9 125.07,128.38 122.4,128.38 120.27,130.51 118.59,130.51 117.32,131.78 115.23,131.78 v2(115.04,131.97)
  BOTTOM w0.102: RH181.2 161.21,122.05 161.21,122.95 160.62,123.54 JSPI1.8 160.62,126.12 v2(160.63,126.13)
