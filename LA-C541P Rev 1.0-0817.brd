# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Nets (continued)
N26822390: PR765.1 PU700.25
N26822393: PC734.2 PR765.2
N26949736: PR727.2 PU700.11
N26949739: PR729.2 PU700.12
N26975143: PQ1002.4 PR1006.1
N27069121: PC804.2 PR801.2
N27069164: PC807.1 PR805.2
N27069205: PR800.1 PU800.1
N27121902: R3722.1 U630.48
N27182711: PC1119.1 PR1137.2
N27207381: PC1703.2 PR1701.1
N27207408: PC1703.1 PU1700.27 PU1700.29
N27207421: PR1701.2 PU1700.30
N27207822: PU1700.8 PU1700.9 PU1700.10 PU1700.11
N27208984: PC1705.1 PL1700.1 PU1700.12 PU1700.13 PU1700.14 PU1700.15 PU1700.16 PU1700.17 PU1700.18
N27208988: PC1705.2 PR1702.1
N27209291: PC1702.1 PR1700.1 PU1700.6
N27222324: PC1269.1 PL1202.1 PU1202.12 PU1202.13 PU1202.14 PU1202.15 PU1202.16 PU1202.17 PU1202.18
N27222328: PC1269.2 PR1211.1
N27222382: PC1249.1 PR1209.1 PU1202.6
N27222513: PC1250.2 PR1208.1
N27222533: PC1250.1 PU1202.27 PU1202.29
N27222541: PR1208.2 PU1202.30
N27222595: PU1202.8 PU1202.9 PU1202.10 PU1202.11
N27223948: PL1202.3 PR1210.1
N27229436: PC1214.1 PL1200.1 PU1200.12 PU1200.13 PU1200.14 PU1200.15 PU1200.16 PU1200.17 PU1200.18
N27229440: PC1214.2 PR1206.1
N27229500: PC1209.1 PR1200.1 PU1200.6
N27229588: PC1210.2 PR1201.1
N27229600: PC1210.1 PU1200.27 PU1200.29
N27229608: PR1201.2 PU1200.30
N27229638: PU1200.8 PU1200.9 PU1200.10 PU1200.11
N27229674: PL1200.3 PR1204.1
N27236350: PC1215.1 PL1201.1 PU1201.12 PU1201.13 PU1201.14 PU1201.15 PU1201.16 PU1201.17 PU1201.18
N27236354: PC1215.2 PR1207.1
N27236394: PC1211.1 PR1203.1 PU1201.6
N27236502: PC1208.2 PR1202.1
N27236514: PC1208.1 PU1201.27 PU1201.29
N27236522: PR1202.2 PU1201.30
N27236552: PU1201.8 PU1201.9 PU1201.10 PU1201.11
N27236588: PL1201.3 PR1205.1
N27241431: PC1477.1 PL1402.1 PU1402.12 PU1402.13 PU1402.14 PU1402.15 PU1402.16 PU1402.17 PU1402.18
N27241435: PC1477.2 PR1411.1
N27241475: PC1457.1 PR1409.1 PU1402.6
N27241583: PC1438.2 PR1408.1
N27241595: PC1438.1 PU1402.27 PU1402.29
N27241603: PR1408.2 PU1402.30
N27241633: PU1402.8 PU1402.9 PU1402.10 PU1402.11
N27241669: PL1402.3 PR1410.1
N27245962: PC1414.1 PL1400.1 PU1400.12 PU1400.13 PU1400.14 PU1400.15 PU1400.16 PU1400.17 PU1400.18
N27245966: PC1414.2 PR1406.1
N27246006: PC1411.1 PR1400.1 PU1400.6
N27246076: PC1408.2 PR1401.1
N27246118: PC1408.1 PU1400.27 PU1400.29
N27246134: PR1401.2 PU1400.30
N27246164: PU1400.8 PU1400.9 PU1400.10 PU1400.11
N27246196: PL1400.3 PR1404.1
N27251330: PC1415.1 PL1401.1 PU1401.12 PU1401.13 PU1401.14 PU1401.15 PU1401.16 PU1401.17 PU1401.18
N27251334: PC1415.2 PR1407.1
N27251374: PC1409.1 PR1403.1 PU1401.6
N27251444: PC1410.2 PR1402.1
N27251486: PC1410.1 PU1401.27 PU1401.29
N27251502: PR1402.2 PU1401.30
N27251532: PU1401.8 PU1401.9 PU1401.10 PU1401.11
N27251564: PL1401.3 PR1405.1
N28146073: PR1607.1 PU1600.1
N28146077: PR1608.2 PU1600.2
N28146081: PR1609.2 PU1600.3
N28146095: PU1600.24 PU1600.25 PU1600.44
N28146103: PC1608.2 PR1605.1
N28146139: PC1606.2 PR1603.1 PU1600.39
N28146151: PC1600.2 PR1600.2 PU1600.38
N28146153: PC1603.1 PC1690.1 PR1601.1 PR1602.1 PU1600.37
N28146361: PH1601.2 PR1613.1 PR1616.1
N28146405: PC1613.2 PR1615.2
N28146444: PC1613.1 PU1600.10
N28146467: PR1611.2 PU1600.4
N28146568: PR1606.1 PU1600.31
N28152233: PC1111.1 PR1126.1 PU1100.38
N28152235: PC1111.2 PC1112.2 PR1127.2 PR1128.1
N28152339: PC1112.1 PR1127.1 PU1100.37
N28152401: PC1128.2 PR1150.2 PU1100.15
N28152437: PC1118.2 PR1132.2 PU1100.3
N28152465: PC1120.1 PR1135.1 PU1100.36
N28152580: PC1103.2 PC1140.1 PR1106.2 PR1107.1
N28152729: PC1103.1 PC1105.1 PR1108.2 PR1109.1
N28152784: PC1130.1 PR1151.2 PU1100.16
N28152844: PH1104.1 PR1166.2 PR1168.1
N28152958: PH1102.2 PR1141.2 PR1144.1
N28153047: PC1102.2 PC1104.2 PR1101.2 PR1102.1 PU1100.47
N28153073: PH1100.2 PR1101.1
N28153161: PC1106.2 PR1112.2 PU1100.46
N28153459: PH1103.1 PR1165.2 PR1167.1
N28153589: PR1198.1 PU1100.43
N28153620: PC1100.2 PR1116.2 PU1100.49
N28153632: PC1107.2 PC1108.2 PU1100.50
N28153954: PC1115.1 PR1133.2
N28154016: PC1109.1 PC1110.1 PR1122.2 PR1123.1
N28154283: PH1101.2 PR1140.2 PR1142.1
N28180064: PC1107.1 PR1118.2
N28185893: PC1116.1 PR1134.2
N28185971: PC1114.1 PR1130.2
N28194524: PC1640.2 PR1619.1
N28246475: PR502.2 PU500.7
N28252437: PR505.2 PR506.2 PU500.12
N28308683: PC1610.2 PR1614.1
N28781981: PR509.2 PU500.13
N29181478: JEDP1.18 R208.2
N29189335: D92.1 D93.1 R3727.1 U33.4
N30357948: R802.2 U51.A36
N30361613: T155.1(TP-1) U51.B15
N30472355: R797.2 U51.B5
N30479172: T165.1(TP-1) U46.B1
N30480309: R804.1 U46.B19
N30742939: C538.2 UZ25.12
N30743995: C436.2 UZ25.10
N31279764: C543.2 UZ20.12
N31279793: C544.2 UZ20.10
N32871435: C704.1 R756.2
N32871527: CE8.1 RE11.2
N32871556: CE9.1 RE12.2
N33080426: Q22.1 R423.2
N33211036: D59.1 Q74.3 R389.1
N33211312: Q86.1 R943.1
N33211319: Q74.6 Q86.2
N34391004: Q29.5 Q29.6 R513.2
N34950493: RZ20.1 U637.27
N34977399: CPU1.BT25 RC222.1
N35065265: CPU1.D1 T1.1(TP-1)
N35065285: CPU1.E1 T2.1(TP-1)
N35065297: CPU1.E3 T3.1(TP-1)
N35065301: CPU1.E2 T4.1(TP-1)
N35065321: CPU1.BR1 T5.1(TP-1)
N35065331: CPU1.BT2 T6.1(TP-1)
N35065345: CPU1.BN35 T7.1(TP-1)
N35065469: CPU1.BL34 T8.1(TP-1)
N35065471: CPU1.BN33 T11.1(TP-1)
N35065481: CPU1.J24 T9.1(TP-1)
N35065499: CPU1.H24 T10.1(TP-1)
N35065517: CPU1.AA14 T12.1(TP-1)
N35065519: CPU1.AE29 T15.1(TP-1)
N35065537: CPU1.N29 T14.1(TP-1)
N35065547: CPU1.R14 T13.1(TP-1)
N35067252: CPU1.B30 T18.1(TP-1)
N35067254: CPU1.C30 T19.1(TP-1)
N35067276: CPU1.G3 T21.1(TP-1)
N35067278: CPU1.J3 T20.1(TP-1)
N35067292: CPU1.BR31 T24.1(TP-1)
N35067294: CPU1.BH30 T22.1(TP-1)
N35067312: CPU1.BR35 T23.1(TP-1)
N35067374: CPU1.BM33 T26.1(TP-1)
N35067376: CPU1.BL33 T25.1(TP-1)
N35067398: CPU1.BJ14 T28.1(TP-1)
N35067408: CPU1.BJ13 T27.1(TP-1)
N35067430: CPU1.BK28 T29.1(TP-1)
N35067432: CPU1.BJ28 T30.1(TP-1)
N35067454: CPU1.BJ16 T31.1(TP-1)
N35067456: CPU1.BK16 T32.1(TP-1)
N35067478: CPU1.BK24 T34.1(TP-1)
N35067480: CPU1.BJ24 T33.1(TP-1)
N35067502: CPU1.BK21 T36.1(TP-1)
N35067504: CPU1.BJ21 T35.1(TP-1)
N35067526: CPU1.BT17 T37.1(TP-1)
N35067528: CPU1.BR17 T38.1(TP-1)
N35067550: CPU1.BJ34 T39.1(TP-1)
N35067552: CPU1.BJ33 T40.1(TP-1)
N35067718: CPU1.G13 T42.1(TP-1)
N35067720: CPU1.AJ8 T41.1(TP-1)
N35067742: CPU1.BL31 T44.1(TP-1)
N35067833: CPU1.B2 T43.1(TP-1)
N35067843: CPU1.B38 T45.1(TP-1)
N35067845: CPU1.BP1 T46.1(TP-1)
N35067855: CPU1.BR2 T47.1(TP-1)
N35067873: CPU1.C1 T48.1(TP-1)
N35067875: CPU1.C38 T49.1(TP-1)
N35171080: JDIMM1.162 T50.1(TP-1)
N35171100: JDIMM1.165 T51.1(TP-1)
N35224222: JDIMM2.165 T53.1(TP-1)
N35228093: JDIMM3.162 T54.1(TP-1)
N35228103: JDIMM3.165 T55.1(TP-1)
N35231774: JDIMM4.162 T56.1(TP-1)
N35231784: JDIMM4.165 T57.1(TP-1)
N35432783: D59.2 D62.2 Q74.1 R389.2 R932.2
N35434414: T58.1(TP-1) UH1.AE17
N35434416: T61.1(TP-1) UH1.AF17
N35434426: T59.1(TP-1) UH1.AG15
N35434444: T60.1(TP-1) UH1.AG14
N35435133: T62.1(TP-1) UH1.AN17
N35435135: T63.1(TP-1) UH1.AR19
N35468556: R3728.2 SW2.2
N35632688: T66.1(TP-1) UH1.AR22
N35632711: T67.1(TP-1) UH1.W13
N35632737: T68.1(TP-1) UH1.U13
N35632759: T71.1(TP-1) UH1.P27
N35632761: T72.1(TP-1) UH1.R27
N35632771: T74.1(TP-1) UH1.N29
N35632791: T76.1(TP-1) UH1.AN29
N35632799: T75.1(TP-1) UH1.R24
N35632831: T69.1(TP-1) UH1.P31
N35928091: CPU1.BP13 T199.1(TP-1)
N36146693: CD127.2 RD16.1
N36161597: CD136.2 RD34.1
N36161994: PH1600.1 PR1602.2
N36167915: RD14.2 RD46.2 RD47.1
N36357812: PC304.2 PR309.1
N36358256: PC309.1 PU300.5
N36363134: PR730.2 PU700.9
N36376984: PR307.2 PR311.2 PR314.1
N36552797: C35.1 U8.33
N36554430: C365.1 R373.2
N36983176: C1420.1 R375.2
N37419796: CC273.1 RC320.1 RC329.2 UC1.2
N37419798: RC320.2 UC1.4 UZ19.4
N37422512: LED5.2 R371.2
N37422518: R371.1 U8.43
N37462221: Q355.3 R2198.2
N37462233: Q353.5 Q353.6 R2197.2
N37462411: Q364.3 R3736.2
N37462435: Q364.6 R3737.2
N37463021: RV41.1 UV2.20
N37463172: CV42.1 UV2.17
N37758275: T70.1(TP-1) UH1.N31
N37986180: C437.2 UZ26.12
N37986182: C542.2 UZ26.10
N38685436: Q365.3 R2196.2
N38685448: Q365.6 R2195.2
N38717052: CPU1.A33 T194.1(TP-1)
N38949830: RC303.2 UZ18.4
N39322049: Q355.6 R2194.2
N39410700: PR1802.2 PU1800.7
N39410717: PR1805.2 PR1806.2 PU1800.12
N39410719: PR1810.2 PU1800.13
N39410732: PC1801.1 PR1804.2
N39467529: PC903.2 PR902.2 PR903.1 PU900.2
N39810242: JMXM1.57 R1971.2
N39900137: JMXM1.40 R1972.1
N40865409: Q367.5 Q367.6 R3744.2
N40865430: Q369.1 R3745.1
N40865432: Q369.4 R3747.1
N40900595: R3748.2 U46.B52
N41074937: R417.2 R418.2 UZ27.3
N41075951: C1444.2 UZ27.6
N41076988: C1423.1 UZ23.6
N41078830: C547.2 UZ28.6
N41079831: C539.1 UZ22.6
N41080862: C477.2 UZ21.6
N41081469: C541.1 UZ24.6
N41115318: C1466.1 R3755.2
N41175521: C713.1 R795.2
N41175710: C1469.1 R3757.2
N41251989: JMXM1.74 T211.1(TP-1)
N41251992: JMXM1.76 T212.1(TP-1)
N41251995: JMXM1.80 T213.1(TP-1)
N41251998: JMXM1.75 T214.1(TP-1)
N41252001: JMXM1.77 T215.1(TP-1)
N41252004: JMXM1.81 T216.1(TP-1)
N41682393: PR114.1 PU101.19
N42439176: JDIMM2.162 T52.1(TP-1)
N42877369: Q366.4 R39.2
N42877372: Q366.1 R38.2
N42901769: R42.2 U33.3
N42905932: RZ77.2 RZ83.2 U637.29
N43194116: PD704.1 PQ708.3 PR766.1
N43194174: PQ708.5 PQ708.6 PR769.2 PR770.1
N43204552: PD1101.1 PQ1005.3 PR1033.1
N43204589: PQ1005.2 PR1034.2 PR1035.1
N43204609: PQ1005.5 PQ1005.6 PR1036.2 PR1037.1
N43339931: QZ2.2 RZ84.2
N43843335: PQ708.2 PQ1073.5 PR767.1 PR768.2
N43843360: PQ1073.3 PR771.2 PR772.2
N43843390: PR772.1 PR773.2
N43901142: PD1103.1 PR1026.1
N43901144: PD1102.1 PR1010.1
N43928875: PQ707.1 PR758.2 PR764.1 PU700.21
N43928883: PQ707.6 PR760.2
N44147068: PQ1074.2 PU105.4
N44206069: JMXM1.67 T217.1(TP-1)
N45812508: PC501.1 PR504.2
N53085144: PC206.2 PR200.1
N53085275: PR205.2 PU200.9
N53866851: C747.1 R885.2
N66037766: JLOM1.11 R1167.2
N66058065: JLOM1.10 R1170.2
N66078140: JLOM1.13 R1171.2
N66971793: PR105.2 PU101.5
N66972075: PR106.2 PU101.1
N94639990: D68.2 U3.4
N97449521: Q359.1 R956.1
N104731395: PC400.1 PJP400.2 PU400.3
N104731470: PC405.1 PR403.2
N106386290: CE1.1 RE1.2

Pads without a net: CPU1 BM31 BT30; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDEG3 6; JEDP1 5 26 27; JIO1 21; JIO2 58; JKBTP1 10 17; JMXM1 46 48 50 52 60 62 64 65 66 69 71 189 191 193 195 197 199 201 204 205 206 207 210 211 212 213 216 217 218 219 222 223 224 225 228 230 257 259 261 263 265 266 267 269 271 273 275 277 279; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 12 14 16 17 20 30 32 34 36 38 40 48 50 51 52 53 54 55 56 57 59; JNGFF3 6 8 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 56 58 59; JSATA2 26; JSIM1 2 3 6 10; PJPDC1 1; PQ707 3 4 5; PQ1073 1 2 6; PR3 1 8; PU400 5; PU700 4 18; PU900 7; PU1001 31 35 36; PU1200 1 28 32; PU1201 1 28 32; PU1202 1 28 32; PU1400 1 28 32; PU1401 1 28 32; PU1402 1 28 32; PU1600 9; PU1700 1 28 32; R3748 1; RC217 1; RP4 1; RP7 5; U6 1; U8 6 7 8 11 12 15 16 17 22 23 28 29; U32 5; U46 A5 A57 B39 B40 B47 B51 B55 B56 B57 B61 B64 B65; U51 A57 B38; U629 50 53; U630 22 23 24 25 50 53; U631 50 53; U636 50 53; U637 2 4 5 6 7 10 11 12 15 25 26 28 30 31; UC6 1; UD1 1; UH1 A16 AA45 AB13 AB35 AB36 AB39 AB41 AB42 AB43 AD2 AD3 AE45 AG42 AG43 AG44 AH43 AH44 AJ11 AJ13 AJ33 AJ35 AJ39 AJ42 AJ44 AK45 AL27 AL35 AL42 AL43 AM43 AM44 AN24 AN36 AN42 AN43 AR17 AR27 AR29 AT43 AU41 AU43 AV43 AW33 AW35 B16 B36 BA4 BA33 BA35 BB17 BB31 BB33 BB36 BB38 BC8 BC19 BC22 BC32 BC33 BC35 BC36 BC38 BD1 BD18 BD21 BD27 BD32 BD33 BD34 BD35 BD36 BD38 BD39 BE2 BE34 BE39 C36 E35 G15 G35 H15 H43 H44 J45 K44 L37 L39 L43 L44 M45 N2 N3 N38 N39 N42 N43 N44 P1 P2 P3 P24 P29 P44 R2 R3 R4 R11 R13 R35 R36 R41 R42 R43 R44 T44 U2 U3 U35 U39 U42 V1 V2 W7 W10 W11 W39 W43 W44 Y5 Y41 Y43 Y44; UV2 2 14 58; YH2 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 916 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8339 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 128 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 324 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 17.8
  TOP w0.102: v1(47.86,8.53) v2(47.86,9.1)
  TOP w0.254: v2(47.86,9.1) 48.04,9.29 RD61.2 48.04,10.69 47.87,10.86 UD1.4
  IN4 w0.254: v2(54.77,16.29) 54.03,17.04 49.25,17.04 48.68,16.47 48.68,13.55 47.86,12.72 v2(47.86,9.1)
  BOTTOM w0.203: PR208.1 54.91,16.15 v2(54.77,16.29)
0.95V_MP_PWROK: length 4.5
  TOP w0.102: v1(329.2,23.52) PR315.2
  TOP w0.254: PU300.2 329.11,21.19 329.2,21.28 PR315.2
1.2V_B+: length 17.4
  IN4 w0.254: v2(54.83,18.05) 54.91,18.05 55.41,17.55 55.41,16.85 58.21,14.05 66.08,14.05 67.03,15.01 v2(67.03,17.1)
  BOTTOM w0.203: v2(54.83,18.05) 54.95,17.93 PR205.1
  vias: v1(68.11,15.32)
1.2V_FB: length 5
  TOP w0.254: PR207.1 56.86,16.97 56.7,17.14 56.32,17.14 v1(56.27,17.09) 56.16,16.98 PR204.1 PC211.1 v2(57.75,16.1)
  BOTTOM w0.203: v2(57.75,16.1) 57.75,16.49 57.87,16.62 PU200.6
1.2V_SUS_PWRGD: length 310.7
  TOP w0.102: U9.2 v2(321.67,5.93)
  IN1 w0.109: v2(139.42,8.59) 139.15,8.31 136.42,8.31 134.41,6.31 134.21,6.31 132.78,6.31 132.77,6.3 130.97,6.3 130.34,5.67 113.96,5.67 107.17,12.47 90.59,12.47 88.3,14.75 85.16,14.75 85.08,14.68 77.95,14.68 75.99,12.72 69.83,12.72 69.19,13.36 68.47,13.36 67.83,12.72 57.76,12.72 55.54,14.94 55.54,17.55 56.31,18.32 v2(56.31,18.56) ; v2(249.03,8.72) 248.26,7.96 247.37,7.96 246.59,7.17 246.59,6.08 247.06,5.61 252.14,5.61 253.22,6.69 253.22,8.34 256.71,11.83 259.88,11.83 262.99,14.93 271.75,14.93 271.95,15.13 281.73,15.13 282.24,14.63 285.6,14.63 288.59,11.64 288.59,7.51 288.9,7.2 290.75,7.2 292.93,9.38 303.73,9.38 304.5,8.61 304.5,8.14 304.74,7.9 312.96,7.9 313.99,6.88 315.95,6.88 316.59,6.24 321.35,6.24 v2(321.67,5.93)
  IN2 w0.127: v2(194.61,8.91) 194.8,8.91 195.37,8.34 199.75,8.34 202.04,6.05 222.48,6.05 223.18,6.75 227.88,6.75 228.77,7.64 246.3,7.64 246.55,7.89 248.2,7.89 v2(249.03,8.72)
  BOTTOM w0.102: v2(194.61,8.91) 194.48,9.04 194.48,9.16 194.26,9.38 192.22,9.38 191.63,8.79 187.36,8.79 185.81,10.34 182.51,10.34 181.84,9.67 166.92,9.67 164.45,12.14 164.45,12.36 164.04,12.78 164.04,13.4 162.61,14.83 151.69,14.83 147.68,10.82 145.77,10.82 143.55,8.59 141.41,8.59 141.18,8.36 140.84,8.36 140.62,8.59 v2(139.42,8.59) ; PR209.2 v2(56.31,18.56)
  BOTTOM w0.203: PR209.2 57.18,19.2 v1(57.21,19.17) 57.21,18.79 57.78,18.22 PU200.10
3.3V_CAM_EN#: length 49.8
  TOP w0.203: UH1.BD14 128.64,123.6 128.66,123.6 128.82,123.77 128.82,123.8 129.09,124.06 129.09,124.89 129.3,125.1 129.3,125.64 128.92,126.02 128.92,126.13 v2(128.67,126.39)
  IN1 w0.254: v2(103.51,119.27) 104.54,120.3 105.27,120.3 106.48,121.51 108.76,121.51 110.33,119.94 111.53,119.94 111.91,119.56 112.96,119.56 113.29,119.88 113.29,121.91 113.03,122.17 113.03,122.58 113.94,123.48 114.9,123.48 115.37,123.95 115.98,123.95 116.59,124.56 119.71,124.56 120.34,123.93 123.41,123.93 123.51,123.83 124.88,123.83 125.77,124.73 125.77,125.03 126.45,125.7 126.68,125.7 127.56,126.58 128.48,126.58 v2(128.67,126.39)
  BOTTOM w0.254: v2(103.51,119.27) 103.51,123.39 103.86,123.74 103.86,129.1 v1(103.14,129.83) 102.82,130.14 101.69,130.14 101.45,130.38 Q24.2
3.3V_RUN_GFX_ON: length 175.6
  TOP w0.102: v2(224.3,108.48) 223.85,108.92 223.85,110.8 224.77,111.72 226.8,111.72 227.45,112.37 Q87.2 ; v2(211.43,107.26) 213.05,105.65 213.59,105.65 214.18,105.05 v2(214.18,104.95)
  TOP w0.203: UZ26.5 210.8,93.74 210.81,93.74 210.81,93.5 210.81,93.5 210.86,93.45 210.9,93.4 211.14,93.16 211.14,92.54 ; 211.14,92.54 211.13,92.53 210.34,92.53 210.21,92.66 210.21,92.9 210.2,92.91 210.2,93.11 210,93.31 UZ26.3 ; 211.14,92.54 211.88,92.54 212.13,92.29 216.49,92.29 v1(216.76,92.55) 217.26,93.06 217.26,96.05 215.5,97.82 215.5,98.75 214.1,100.15 214.1,104.88 v2(214.18,104.95)
  IN2 w0.089: 141.76,106.64 136.02,106.64 133.66,109 129.91,109 v2(129.46,108.54)
  IN2 w0.127: v2(214.18,104.95) 214.72,104.41 215.73,104.41 216.43,105.11 218.32,105.11 219.09,105.88 219.09,106.24 220.72,107.86 220.72,108.35 221.43,109.07 223.51,109.07 223.96,108.62 224.15,108.62 v2(224.3,108.48) ; 141.76,106.64 143.93,106.64 145.39,108.1 150.03,108.1 150.6,107.53 152.32,107.53 154.66,109.88 163.55,109.88 165.08,108.35 165.08,107.97 166.63,106.42 168.9,106.42 169.63,107.15 169.63,108.79 171.06,110.22 v2(173.08,110.22) 173.22,110.22 174.18,111.18 175.65,111.18 176.48,110.34 177.78,110.34 178.93,111.5 183.69,111.5 184.76,112.57 186.77,112.57 188.77,110.57 189.76,110.57 190.84,109.49 192.2,109.49 193.33,110.62 194.39,110.62 194.99,111.22 197.35,111.22 197.35,111.22 201.2,111.22 203.05,109.38 203.57,109.38 203.79,109.6 207.72,109.6 209.08,108.24 210.46,108.24 v2(211.43,107.26)
  IN3 w0.089: v2(129.46,108.54) 129.14,108.86 128.57,108.86 128.19,109.24 128.19,110.76 127.23,111.72 127.23,115.91 126.85,116.29 124.5,116.29 121.07,119.72 121.07,121.05 120.63,121.5 120.12,121.5 119.8,121.81 119.8,123.97 118.86,124.92 118.86,126.2
  IN3 w0.127: v2(114.46,131.73) 115.1,131.08 116,131.08 118.86,128.23 118.86,126.2
  BOTTOM w0.102: v2(114.46,131.73) 114.41,131.73 114.41,131.78 113.88,132.31 QH3.2 ; v2(173.08,110.22) 173.09,110.2 173.49,110.2 173.68,110.01 U46.A55
3.3V_TP_EN: length 5.5
  TOP w0.089: UH1.BC27 121.82,122.91 122.1,123.19 122.1,124.33 122.04,124.38 122.04,124.38 v2(122.05,124.38)
  BOTTOM w0.089: 121.22,126.2 121.42,126.01 121.42,124.57 121.61,124.38 122.04,124.38 v2(122.05,124.38)
  BOTTOM w0.102: RH79.2 120.88,126.54 121.22,126.2
3.3V_WWAN_EN: length 199.2
  TOP w0.102: UZ24.3 323.57,35.03 323.12,35.48 322.38,35.48 R720.1 319.84,34.82 v2(319.76,34.89)
  IN1 w0.109: v2(318.48,27.88) 320.11,29.51 320.11,34.22 319.76,34.56 v2(319.76,34.89)
  IN2 w0.127: v2(179.92,106.87) 180.65,106.13 183.9,106.13 185.41,104.62 185.41,104.08 186.19,103.3 189.09,103.3 189.87,102.52 190.65,102.52 192.19,100.97 193.03,100.97 194.22,99.78 196.02,99.78 196.16,99.64 199.8,99.64 200.34,99.11 201.23,99.11 202.19,98.14 203.2,98.14 203.24,98.1 203.8,98.1 205.09,96.81 207.34,96.81 209.74,94.41 209.74,92.6 211.96,90.38 212.54,90.38 213.21,89.71 213.21,86.95 215.36,84.81 218.19,84.81 221.5,81.5 222.72,81.5 223.61,80.62 237.87,80.62 241.61,76.88 241.61,76.31 243.84,74.08 245.09,74.08 245.87,73.3 248.26,73.3 250.55,71.01 250.55,66.06 249.98,65.49 249.98,61.23 252.11,59.09 258.95,59.09 275.55,42.49 278.15,42.49 281.89,38.75 285.25,38.75 288.98,35.02 289.52,35.02 291.33,33.21 291.33,30.51 293.54,28.3 296.92,28.3 297.62,27.6 304.01,27.6 304.77,26.84 310.56,26.84 312.55,28.83 312.55,29.66 312.8,29.9 314.01,29.9 315.73,28.19 318.17,28.19 v2(318.48,27.88)
  BOTTOM w0.102: U46.B42 179.8,106.75 v2(179.92,106.87)
3V_5V_EN: length 11.4
  TOP w0.102: PU101.6 349.87,29.32 349.71,29.15 v2(349.04,29.15) 348.57,28.68 v1(348.57,28.27) 348.08,28.27 347.84,28.51 PC119.1 347.37,27.91 347.42,27.86 PR113.2 ; v2(347.94,32.72) 348.58,32.72 348.96,33.1 349.71,33.1 349.87,32.94 PU101.20
  IN4 w0.109: v2(349.04,29.15) 349.04,32 348.32,32.72 v2(347.94,32.72)
5VUSB_OFF: length 186.5
  TOP w0.102: JIO2.68 54.25,38.85 v2(54.74,39.35)
  IN2 w0.127: v2(177.73,89.15) 179.43,87.44 179.43,86.64 180.19,85.88 180.19,85.07 179.85,84.73 178.48,84.73 178.1,85.11 178.1,86.25 177.27,87.08 175.62,87.08 174.01,85.47 169.05,85.47 167.89,84.31 167.44,84.31 166.77,84.98 161.64,84.98 159,87.62 156.36,87.62 152.11,83.37 143.92,83.37 143.18,84.12 138.5,84.12 138.03,84.6 136.7,84.6 135.95,85.34 131.89,85.34 131.23,86 126.39,86 125.3,84.92 123.53,84.92 122.7,85.75 116.97,85.75 116.63,86.09 112.19,86.09 111.44,85.34 108.23,85.34 106.85,83.95 106.05,83.95 105.39,83.29 103.03,83.29 99.93,80.2 98.47,80.2 92.65,74.37 92.65,62.01 78.86,48.22 75.72,48.22 74.23,46.72 74.23,46.42 68.24,40.43 68.24,39.69 66.95,38.4 61.6,38.4 61.41,38.59 58.61,38.59 58.06,39.14 54.96,39.14 v2(54.74,39.35)
  IN3 w0.127: v2(177.73,89.15) 177.73,89.86 176.89,90.7 176.89,94.09 176.93,94.13 176.93,99.33 176.01,100.25 176.01,103.87 v2(176.15,104.01)
  BOTTOM w0.102: v2(176.15,104.01) 176.23,104.01 176.55,104.33 U46.A46
+0.6V_DDR_VTT: length 21.6
  TOP w0.305: JDIMM1.258 125.45,81.43 125.84,81.81 125.84,84.88
  TOP w0.457: v2(120.29,84.93) 120.49,84.73 123.3,84.73 125.01,86.44 125.01,87.36 124.64,87.72 124.64,88.59 125.17,89.12 125.17,89.12 125.67,89.62 128.88,89.62
  TOP w0.508: 125.84,84.88 129.11,88.16 129.14,88.16
  vias: v2(63.45,14.6) v2(64.04,14.63) v2(64.62,14.75) v2(65.21,14.77) v2(65.8,15.24) v2(65.79,14.65) v2(101,72.88) v2(101.51,73.24) v2(101.82,73.74) v2(102.12,73.24) v2(102.45,74.38) v2(102.45,73.74) v2(108.75,81.25) v2(109.36,81.22) v2(132.56,88.4) v2(133.82,88.41) v3(66.67,13.66)
+0.6V_P:
  vias: v1(60.86,14.83)
+0.9V_LAN: length 21.7
  TOP w0.203: U31.37 254.59,107.74 254.8,107.53 254.8,107.02 ; 246.79,110.94 U31.16 ; 255.15,111.74 254.75,111.34 U31.46 ; 255.15,111.74 v2(255.19,111.78) ; 255.15,111.74 U31.47 ; v2(249.09,108.54) 248.08,108.54 U31.22 ; v2(253.22,110.07) 253.29,110.14 U31.43 ; U31.8 v2(250.53,111.99) ; U31.40 253.39,108.94 v2(253.22,109.11) ; U31.11 v2(249.33,111.97)
  TOP w0.508: 246.79,110.94 246.41,110.56 C467.1 C463.1 244.02,110.56 C462.1 243.84,110.54 L29.2 242.36,110.6 v2(242.36,111.4) ; v2(257.56,106.41) C1177.1 255.49,105.51 C469.1 254.8,105.7 254.8,107.02 ; v2(255.19,111.78) 255.63,112.23 C468.1 255.94,111.28 C466.1
  vias: v1(254.79,106.45)
+1.0V_AAZPLL: length 9.5
  TOP w0.152: UH1.AN19 v2(126.23,117.87)
  BOTTOM w0.254: RH240.2 133.84,116.61 132.44,116.61 131.98,117.07 v1(129.19,117.07) 128.51,117.07 128.21,117.37 127.3,117.37 127.25,117.31 126.71,117.31 126.23,117.8 v2(126.23,117.87)
+1.0V_ALW_PCH: length 25.5
  IN1 w0.508: v2(140.79,117.27) 139.61,118.45 ; 139.61,118.45 139.16,118 138.35,118 137.84,117.5 v2(137.84,113.74) ; 139.61,118.45 140.06,118.9 140.06,121.11 141.08,122.13 142.68,122.13 143.06,121.75 143.06,121.49 143.1,121.45 v2(143.1,121.45)
  BOTTOM w0.508: v2(143.1,121.45) 143.12,121.43 143.12,121.42 143.13,121.43 143.13,122.04 142,123.17 142,123.78 141.39,124.39 141.39,126.11 141.3,126.2 RH286.1 RH255.1 RH287.1 ; RH290.1 112.32,106.95 110.72,106.95 ; RH238.1 140.14,117.91 v2(140.79,117.27)
  vias: v2(104.69,107.34) v2(104.69,106.7) v2(105.33,107.65) v2(105.33,107.02) v2(105.33,106.38) v2(105.9,107.46) v2(105.9,106.83) v2(105.9,106.19) v2(107.67,102.83) v2(108.18,102.45) v2(108.75,102.76) v2(108.75,102.13) v2(109.38,102.71) v2(109.38,102.12) v2(109.97,102.71) v2(109.99,102.11) v3(111.08,101.61)
+1.0V_AMPHYPLL: length 2.1
  TOP w0.102: CH267.1 109.47,101.49 108.25,101.49 v1(108.12,101.62)
+1.0V_APLLEBB: length 12
  TOP w0.381: UH1.V28 v2(121.29,111.16)
  IN4 w0.254: v2(121.29,111.16) 120.95,110.82 120.95,110.8 120.2,110.05 118.84,110.05 116.94,108.15 115.19,108.15 114.92,108.42 114.92,109.27 v2(115.2,109.55)
  BOTTOM w0.508: v2(115.2,109.55) v1(114.46,108.81) 113.89,108.24 RH290.2
+1.0V_AUSB: length 5.1
  TOP w0.254: v2(132.48,117.79) 132.48,117.53 UH1.AL5 UH1.AJ5
  BOTTOM w0.254: v2(132.48,117.79) 132.48,117.41 132.84,117.06 v3(133.12,117.06) 133.13,117.06 134.41,118.34 RH239.2
+1.0V_CLK1: length 10.4
  TOP w0.254: v2(127.65,108.43) 127.38,108.16 127.22,108.07 UH1.N17
  BOTTOM w0.254: RH256.2 136.27,109.51 v1(135.03,108.27) 134.79,108.04 129.07,108.04 128.68,108.43 v2(127.65,108.43)
+1.0V_CLK2: length 6.5
  TOP w0.254: UH1.R17 126.66,109.29 v2(126.35,108.97) ; UH1.V17 v2(126.71,111.16)
  IN3 w0.508: v2(126.35,108.97) 126.63,108.97 127.49,109.83 127.49,110.7 127.02,111.16 v2(126.71,111.16)
  BOTTOM w0.508: RH259.2 136.19,111.92 135.42,111.92 134.88,111.38
  vias: v1(134.32,111.02)
+1.0V_CLK3: length 13.1
  TOP w0.254: UH1.R19 125.15,109.29 v2(125.14,109.3)
  BOTTOM w0.254: v2(125.14,109.3) 125.14,109.37 125.24,109.47 127.97,109.47 128.44,109.94 132.83,109.94 v1(133.44,109.33) 133.64,109.13 134.36,109.13 135.63,110.4 RH257.2
+1.0V_CLK4: length 12.6
  TOP w0.254: UH1.U20 v2(125.16,110.39)
  BOTTOM w0.254: 134.37,110.34 127.75,110.34 127.31,109.91 v1(127.03,109.91) 125.58,109.91 125.16,110.33 v2(125.16,110.39)
  BOTTOM w0.508: RH258.2 135.67,111.29 134.72,110.34 134.37,110.34
+1.0V_CLK5: length 24.6
  TOP w0.152: UH1.K2 134.15,106.67 134.06,106.76 UH1.K3
  TOP w0.305: UH1.K2 134.43,106.78 134.55,106.91 135.05,106.91 135.58,107.44 v2(135.74,107.44)
  TOP w0.381: RH171.1 139.2,102.59 v2(139.68,102.59)
  TOP w0.508: RH241.2 132.98,97.54 133.32,97.19 CH29.1 CH46.1 136.49,97.19 136.81,96.87 CH32.1 137.34,96.59 138.6,96.59 138.89,96.88 v2(138.89,97.24)
  IN3 w0.508: v2(139.68,102.59) 139.68,103.65 138.98,104.35 138.98,107.27 v2(138.57,107.68)
  IN4 w0.508: v2(135.74,107.44) 135.99,107.68 v2(138.57,107.68)
  BOTTOM w0.508: v2(139.68,102.59) 139.28,102.19 139.28,97.62 v2(138.89,97.24)
+1.0V_DSW: length 26.9
  TOP w0.254: UH1.BA29 120.46,121.94 v2(120.38,122.02)
  IN2 w0.508: v2(120.38,122.02) 121.15,122.02 121.44,122.31 123.4,122.31 124.91,123.82 125.23,123.82 125.79,124.38 125.79,125.24 126.15,125.61 126.38,125.61 126.85,126.08 126.85,127.59 127.93,128.67 v2(128.06,128.67)
  IN3 w0.508: v2(138.95,128.45) 138.35,129.05 137.77,129.05 136.97,128.25 136.28,128.25 135.85,128.67 v2(128.06,128.67)
  BOTTOM w0.508: RH255.2 140.37,127.27 CH35.1 139.74,127.52 139.74,128.06 139.32,128.48 138.98,128.48 v2(138.95,128.45)
+1.0V_DTS: length 10
  TOP w0.508: UH1.AD15 127.81,114.05 v2(128.06,114.3)
  BOTTOM w0.508: v2(128.06,114.3) 128.06,114.14 129.49,112.71 v1(132.31,112.71) 134.94,112.71 134.98,112.67 135.6,112.67 135.99,113.07 RH288.2
+1.0V_DUSB: length 27
  TOP w0.254: v2(126.71,113.47) 127.08,113.1 UH1.AC17
  IN1 w0.508: v2(140.74,125.51) 140.44,125.22 140.44,122.89 139.3,121.75 139.3,119.22 138.71,118.64 137.39,118.64 134.6,115.84 134.6,114.51 133.56,113.47 v2(126.71,113.47)
  BOTTOM w0.508: CH38.1 138.95,125.73 139.59,125.09 v1(139.83,125.09) 140.32,125.09 v2(140.74,125.51) 140.38,125.87 RH286.2
+1.0V_F24: length 18.8
  TOP w0.508: RH241.1 131.74,98.93 v2(131.44,99.23)
  IN1 w0.508: v2(140.33,109.45) 139.91,109.45 139.26,108.8 139.26,105.52 137.32,103.58 137.32,100.93 135.61,99.23 v2(131.44,99.23)
  BOTTOM w0.508: RH260.2 140.27,109.51 v2(140.33,109.45)
+1.0V_MPHY: length 2.7
  TOP w0.305: UH1.U21 v2(124.39,110.39)
  TOP w0.381: UH1.V26 v2(122.06,111.16) ; UH1.U25 v2(122.84,110.39) ; UH1.U23 v2(123.61,110.39) ; UH1.U26 v2(122.06,110.39)
  vias: v1(116.51,107.44)
+1.0V_PRIM: length 246.9
  TOP w0.305: UH1.AJ25 v2(123.61,115.81) UH1.AJ23 v2(124.39,115.81) UH1.AJ21 v2(125.16,115.81) 125.55,116.2 UH1.AJ20 ; UH1.Y23 v2(123.61,111.94) UH1.AA23 ; UH1.AE23 v2(123.61,113.49) UH1.AC23 ; UH1.Y25 v2(122.84,111.94) UH1.AA26 v2(122.84,112.71) ; UH1.AC28 v2(122.06,112.71) UH1.AA28 ; UH1.AE26 v2(122.84,113.49) ; UH1.AC26 v2(122.06,113.49)
  TOP w0.508: 200.89,95.65 200.89,95.1 201.97,94.03 201.97,92.84 202.66,92.15 204.67,92.15 205.18,91.63 205.18,90.06 v2(204.46,89.34) ; v2(152.71,20.26) 153.5,19.47 RC216.1
  IN1 w0.508: v2(101.18,108.58) 100.78,108.58 100.21,108.01 100.21,107.23 98.21,105.24 v2(98.21,104.99)
  IN2 w0.508: 141.79,74.76 151.11,74.76 156.06,79.71 176.13,79.71 176.51,80.09 183.68,80.09 184.38,80.79 190.48,80.79 192.01,82.32 v2(200.9,82.32) ; 141.79,74.76 141.79,61.79 152.71,50.87 v2(152.71,20.26) ; 141.79,74.76 136.65,79.89 120.71,79.89 116.65,75.84 107.08,75.84 105.02,73.78 103.83,73.78 v2(103.12,73.07)
  IN3 w0.508: v2(103.12,73.07) 103.84,73.79 103.84,77.79 103.22,78.42 101.48,78.42 v2(100.97,78.93) ; v2(200.9,82.32) 200.65,82.07 200.65,81.61 200.65,81.61 200.65,81.03 201.06,80.62 203.94,80.62 204.26,80.94 204.26,89.14 v2(204.46,89.34)
  BOTTOM w0.508: v2(100.97,78.93) 100.02,79.88 100.02,81.55 97.77,83.8 97.77,87.65 95.97,89.45 95.97,91.47 102.09,97.59 v3(102.09,99.72) 101.71,100.1 101.71,100.11 99.93,101.88 99.93,103.91 98.85,104.99 v2(98.21,104.99)
  vias: v2(99.39,112.3) v2(99.42,111.21) v2(99.72,111.77) v2(99.75,112.78) v2(100.11,112.3) v2(100.05,111.21) v2(100.41,112.81) v2(100.36,111.74) v2(100.74,112.3) v2(100.72,111.23) v2(110.66,110.07) v2(110.66,109.43) v2(110.66,108.8) v2(111.23,110.32) v2(111.23,109.68) v2(111.23,109.05) v2(111.68,108.61) v2(111.8,110) v2(111.8,109.37)
+1.0V_PRIM_XDP: length 32.1
  TOP w0.102: v2(147.72,15.42) v1(147.72,16.06)
  TOP w0.279: JXDP1.43 154.86,6.7 154.73,6.83 v2(154.73,8.66) 154.86,8.79 JXDP1.44
  TOP w0.508: v2(154.33,15.77) 154.2,15.9 RC216.2 153.3,15.69 CC33.1 CC37.1 v2(153.3,12.21) ; v2(147.72,15.42) 147.8,15.34 RC138.2 ; v2(159.59,12.97) RC6.2
  IN3 w0.508: v2(159.59,12.97) 159.43,12.97 158.79,13.61 154.6,13.61 153.84,14.37 ; v2(147.72,15.42) 147.72,14.55 148.03,14.24 153.71,14.24 153.84,14.37 ; 153.84,14.37 154.33,14.86 v2(154.33,15.77)
  BOTTOM w0.508: v2(153.3,12.21) 153.3,11.11 154.32,10.09 154.32,9.06 v2(154.73,8.66)
+1.0V_PRIMP: length 19.8
  TOP w0.508: v2(103.26,126.18) 103.74,126.66 103.74,129.76 103.5,130 103.5,132.08 102.29,133.29 100.33,133.29 99.44,132.4 PR807.2
  BOTTOM w0.508: PC806.1 102.19,120.14 102.82,120.77 102.82,123.69 103.26,124.12 v2(103.26,126.18)
  vias: v1(99.04,116.96)
+1.0V_RUN: length 396
  TOP w0.508: v2(181.31,89.35) 181.31,91.5 181.94,92.13 181.94,93.89 180.71,95.12 179.38,95.12 178.52,95.97 178.52,97.2 178.88,97.56 178.88,97.9
  IN2 w0.508: v2(221.48,117.16) 221.77,117.16 223.75,115.18 223.75,113.81 225.49,112.08 226.18,112.08 230.29,107.97 230.29,103.34 227.4,100.45 227.4,98.35 226.28,97.23 226.28,95.3 226.01,95.02 226.01,93.77 228.52,91.26 228.52,86.51 227.45,85.44 223.22,85.44 222.86,85.8 v2(222.86,86.48) ; v2(181.31,89.35) 181.31,87.73 181.67,87.37 181.67,84.87 180.57,83.78 178.03,83.78 177.78,84.03 174.67,84.03 174.2,84.5 169.42,84.5 168.28,83.36 167.05,83.36 166.42,83.98 166.41,83.97 161.21,83.97 159.65,85.52 158.32,85.52 157.61,86.23 156.31,86.23 152.32,82.24 145.93,82.24 144.88,81.19 139.76,81.19 137.63,83.32 134.83,83.32 134.16,83.99 131.78,83.99 130.76,85.02 126.91,85.02 124.91,83.01 123.38,83.01 122.64,83.76 117.15,83.76 115.78,85.14 113.01,85.14 111.92,84.04 109.11,84.04 107.58,82.51 106.26,82.51 106.07,82.32 103.4,82.32 100,78.92 99.5,78.92 98.23,77.66 98.23,76.94 97.1,75.81 96.42,75.81 95.58,74.98 95.58,73.38 94.48,72.27 94.48,60.97 87.4,53.89 85.88,53.89 78.39,46.4 v2(75.54,46.4)
  IN3 w0.508: v2(222.86,86.48) 222.28,85.9 222.28,82.91 215.94,76.56 210.01,76.56 207.88,78.7 205.66,78.7 203.64,76.68 195.91,76.68 195.64,76.96 195.62,76.96 195.6,76.98 195.49,77.09 195.25,77.09 193.94,78.4 193.94,78.8 192.07,80.67 192.07,81.53 189.36,84.23 189.36,87.4 187.41,89.35 v2(181.31,89.35)
  IN4 w0.508: v2(75.54,46.4) 75.54,46.2 71.81,42.46 71.81,36.96 70.1,35.25 69.04,35.25 66.96,37.33 62.13,37.33 61.5,36.7 61.5,35.48 61.14,35.12 61.14,30.12 60.84,29.81 55.05,29.81 50.83,34.03 48.7,34.03 48.04,34.69 47.17,34.69 46.61,34.13 43.59,34.13 41.45,31.99 41.45,31.49 39.3,29.34 39.3,28.51 37.88,27.1 37.24,27.1 36.09,25.94 34.26,25.94 33.91,25.6 29.65,25.6 29.21,25.17 24.44,25.17 22.46,27.15 22.46,29.05 17.45,34.06 16.77,34.06 11.97,38.86 11.97,49.25 9.88,51.33 v2(7.12,51.33) ; v2(196.28,120.33) 196.79,120.83 197.15,120.83 198.02,121.71 198.67,121.71 199.95,122.99 202.8,122.99 203.2,122.59 208.1,122.59 208.55,123.04 210.64,123.04 211.5,122.18 214.11,122.18 215.43,120.85 215.43,118.85 216.64,117.65 221,117.65 v2(221.48,117.16)
  BOTTOM w0.102: v2(75.54,46.4) v3(75.54,45.74)
  BOTTOM w0.508: v2(196.28,120.33) 196.2,120.24 196.2,119.87 R866.2
+1.0V_RUN_PWR:
  vias: v1(182.73,97.63)
+1.0V_VCCSFR: length 61.5
  TOP w0.305: CPU1.H28 CPU1.J28 191.75,59.45 191.19,58.86 191.19,58.84 v2(191.09,58.75)
  TOP w0.508: v2(192.38,96.29) 192.7,96.6 RC304.2
  IN3 w0.508: v2(195.69,80.92) 195.69,83.14 193.44,85.38 193.44,90.57 194.03,91.17 194.03,92.86 194.61,93.43 194.61,94.95 193.27,96.29 v2(192.38,96.29)
  IN4 w0.508: v2(191.09,58.75) 191.41,59.06 192.88,59.06 193.21,59.39 196.89,59.39 199.31,61.81 199.31,66.63 198.73,67.2 198.73,69.36 199.88,70.5 199.88,73.74 200.77,74.63 200.77,75.84 199.69,76.92 199.69,78.7 199.11,79.27 197.34,79.27 v2(195.69,80.92)
  BOTTOM w0.508: v2(195.69,80.92) 196.64,80.92 196.96,80.6 196.96,77.43 197.4,76.98 CC192.2 ; v2(192.38,96.29) 192.71,96.29 v3(193.18,95.81)
+1.0V_VCCST: length 397.2
  TOP w0.203: CPU1.H30 193.4,60.16 v2(193.72,60.49)
  TOP w0.508: RC166.2 163.25,16.48 v2(162.73,15.96) ; RC172.2 198,14.8 v2(198.18,14.63) ; v2(267.23,37.77) 267.23,38.68 PC1101.2 265.23,39.82 PR1103.1 PR1105.2 PR1199.1 PR1104.1 ; RC317.2 RC155.1 RC157.1 195.62,6.43 194.66,6.43 194.09,7.01 v2(194.09,7.44) ; v2(161.06,18.62) 161.06,20.23 147.53,33.76 147.53,57.32 156.39,66.17 157.27,66.17 157.75,66.65 RC164.2 ; RC326.2 217.27,73.49 217.66,73.87 v2(217.66,74.76)
  IN2 w0.508: 212.84,72.5 212.07,72.5 211.85,72.28 209.21,72.28 208,73.49 208,77.53 205.25,80.28 200.19,80.28 198.98,81.5 v2(198.71,81.5) ; 212.84,72.5 214.59,74.25 216.01,74.25 216.61,74.86 217.56,74.86 v2(217.66,74.76) 218.11,75.21 219.78,75.21 220.15,74.85 221.74,74.85 222.74,75.84 232.55,75.84 235.36,73.03 235.36,71.85 237.72,69.49 243.6,69.49 244.19,68.9 244.19,67.34 244.9,66.63 244.9,60.01 248.6,56.31 248.6,55.5 249.1,55 253.45,55 254.52,53.93 254.52,49.08 255.13,48.47 255.13,47.3 254.5,46.67 254.5,43.3 255.94,41.86 255.94,39.05 253.99,37.1 v2(253.99,35.26) ; 212.84,72.5 212.84,72.04 209.64,68.83 209,68.83 206.86,66.7 202.86,66.7 200.58,68.98 197.78,68.98 197.02,69.74 195.56,69.74 194.8,68.98 194.8,68.54 194.86,68.47 ; 192.64,8.97 193.46,9.8 197.91,9.8 199.31,11.2 ; 192.64,8.97 191.35,10.26 188.37,10.26 185,13.64 183.62,13.64 181.77,11.79 177.41,11.79 176.77,12.43 172.53,12.43 171.82,11.72 166.97,11.72 v2(162.73,15.96) ; 192.64,8.97 193.32,8.29 193.32,8.2 v2(194.09,7.44) ; v2(218.81,7.14) 218.42,6.76 202.48,6.76 201.08,8.15 201.08,9.42 199.31,11.2 ; 194.86,68.47 194.1,68.47 192.92,67.3 v2(192.92,66.64) ; 194.86,68.47 195.3,68.03 195.3,61.74 194.05,60.49 v2(193.72,60.49) ; 199.31,11.2 199.31,12.85 198.18,13.97 v2(198.18,14.63)
  IN3 w0.508: v2(218.81,7.14) 241.05,7.14 241.93,8.02 253.66,8.02 262.3,16.66 262.3,18 265.02,20.72 265.02,21.95 268.08,25.01 268.08,30.16 268.75,30.83 268.75,32.63 268.39,32.99 267.5,32.99 267.07,33.42 267.07,35.48 267.23,35.65 v2(267.23,37.77) ; v2(198.59,93.03) 198.59,93 198.61,92.98 198.61,89.05 197.72,88.16 197.72,85.11 198.69,84.13 198.69,81.52 v2(198.71,81.5)
  BOTTOM w0.508: v2(267.23,37.77) 265.58,37.77 264.38,36.56 263.41,36.56 261.99,35.14 255.67,35.14 254.97,34.44 254.39,34.44 253.99,34.84 v2(253.99,35.26) ; v2(198.59,93.03) 198.31,93.03 196.55,94.79 196.55,95.77 v3(195.43,96.89) 194.9,96.89 194.23,97.56 194.23,98.89 v2(194.61,99.27) ; v2(161.06,18.62) 161.06,17.62 v2(162.73,15.96) ; CC193.2 CC194.2 193.14,69.42 193.14,69.07 193.65,68.56 193.65,68.03 193.31,67.68 193.31,67.02 v2(192.92,66.64) 192.54,67.02 192.54,67.6 192.06,68.09 CC191.2
+1.0V_VCCST_UZ18:
  vias: v1(192.63,101.28)
+1.0V_VCCSTG: length 369.6
  TOP w0.203: v2(193.72,61.14) 193.49,60.91 193.42,60.91 CPU1.G30 ; v2(191.06,58.14) 191.29,58.14 191.82,58.66 191.82,58.97 192.23,59.38 192.23,59.85 CPU1.H29
  TOP w0.508: v2(218.55,74.57) 218.55,73.91 218.23,73.59 218.23,73.2 CC195.2 CC186.2 ; 195.81,100.73 195.81,101.18 ; 193.34,8.15 193.34,9.48 194.42,10.57 RC180.1 194.64,10.84 195.88,12.09 v2(195.88,12.21) ; 193.34,8.15 193.34,6.05 RC317.1 ; 193.34,8.15 193.32,8.13 185.04,8.13 184.34,7.43 184.34,6.1 183.72,5.48 172.29,5.48 171.09,6.69 RC135.1
  IN2 w0.381: v2(191.06,58.14) 191.29,58.14 192.1,58.95 193.34,58.95 193.84,59.46 196.22,59.46 197.94,61.18 202.15,61.18 208.74,67.77 209.49,67.77 v2(209.55,67.84)
  IN2 w0.508: v2(141.15,123.43) 141.41,123.7 144.08,123.7 144.44,123.34 150.28,123.34 150.73,123.78 152.22,123.78 154.28,121.72 162.21,121.72 162.57,122.08 164.95,122.08 165.21,121.82 167.22,121.82 167.64,122.25 168.98,122.25 169.38,121.84 169.87,121.84 171.03,123.01 175.05,123.01 175.77,123.72 181.28,123.72 182.12,124.56 186.9,124.56 188.21,125.87 189.24,125.87 189.97,126.6 195.24,126.6 196.42,127.78 201.43,127.78 202.16,128.52 205.11,128.52 205.44,128.19 206.9,128.19 207.66,127.43 208.6,127.43 210.48,129.31 214.77,129.31 v2(215.69,128.4) ; v2(209.55,67.84) 209.86,67.84 215.64,73.62 218.25,73.62 218.55,73.91 v2(218.55,74.57)
  IN3 w0.254: 200.68,62.31 200.67,62.3 199.64,62.3 199.53,62.19 196.97,62.19 196.96,62.18 196.59,62.18 196.59,62.19 195.69,62.19 194.64,61.14 v2(193.72,61.14)
  IN3 w0.508: v2(191.06,58.14) 191.06,55.67 191.55,55.19 192.16,55.19 192.54,54.8 192.54,48.07 192.21,47.73 191.73,47.73 191.31,48.15 190.54,48.15 189.78,47.39 187.88,47.39 186.99,48.28 183.49,48.28 181.27,46.06 181.27,42.37 182.07,41.58 182.07,39.93 182.1,39.9 182.1,34.69 182.48,34.31 185.34,34.31 185.78,33.87 186.31,33.87 187.79,32.39 187.79,28.81 189.02,27.57 189.31,27.57 189.32,27.58 189.79,27.58 189.8,27.57 190.59,27.57 190.92,27.24 190.92,24.59 192.27,23.25 193.33,23.25 193.67,22.91 193.67,22.36 194.42,21.61 194.77,21.61 195.3,21.08 195.3,18.18 196.51,16.97 196.51,12.85 v2(195.88,12.21) ; v2(228.32,127.21) 227.02,125.9 227.02,118.36 227.61,117.76 227.61,116.59 227.37,116.35 227.37,114.82 227.79,114.4 227.79,113.85 227.37,113.43 227.37,112.12 227.56,111.93 227.56,110.75 228.06,110.25 228.06,108.44 227.71,108.09 227.71,107.29 226.81,106.39 v2(226.81,105.04) ; v2(221.58,83.45) 212.41,83.45 208.95,79.99 200.79,79.99 200.01,80.77 200.01,81.87 200.02,81.88 200.02,86.33 200.21,86.52 200.21,89.94 201.76,91.49 201.76,93.52 199.16,96.11 199.16,96.12 198.9,96.12 198.54,96.48 198.54,97.15 196.44,99.25 195.58,99.25 195.56,99.27 195.56,99.25 195.56,99.25 195.56,99.27 v2(195.55,99.27) ; v2(209.55,67.84) 208.08,67.84 202.54,62.3 201.59,62.3 201.58,62.31 200.68,62.31
  IN4 w0.508: v2(215.69,128.4) 218.44,128.4 218.8,128.76 219.87,128.76 221.42,127.2 228.31,127.2 v2(228.32,127.21)
  BOTTOM w0.508: RH315.1 RH314.1 140.56,120.67 140.83,120.95 RH312.1 140.83,123.12 v2(141.15,123.43) ; v2(218.55,74.57) 218.36,74.76 218.36,76.36 220.55,78.56 v3(220.55,81.65) 220.55,82.41 v2(221.58,83.45) 221.58,84.97 222.04,85.43 222.04,91.14 224.33,93.43 225.2,93.43 226.9,95.14 228.2,95.14 228.8,95.73 228.8,96.47 228.79,96.51 227.94,97.36 227.94,99.33 226.98,100.3 226.41,100.3 224.92,101.79 224.87,101.84 224.87,103.11 v2(226.81,105.04)
+1.0V_VCCSTG_C:
  vias: v1(197.18,102.86)
+1.2V_MEM: length 572.3
  TOP w0.102: 106.43,45.69 CD116.1 ; 106.43,46.55 CD60.1
  TOP w0.203: v2(174.6,46.13) 174.29,46.44 CPU1.AF5 ; v2(174.6,46.13) 174.29,45.81 CPU1.AG5 ; v2(174.6,46.13) 174.94,46.47 CPU1.AF6 ; v2(174.61,38.58) 174.94,38.89 CPU1.AR6
  TOP w0.254: CD93.1 135.67,32.98 134.41,32.98 133.71,33.68 JDIMM1.75 ; v2(134.56,53.31) 134.56,54.35 133.73,55.17 JDIMM1.153 ; JDIMM1.130 123.53,47.43 123.12,47.84 v2(123.12,47.85) ; v2(175.33,55.25) 175.25,55.25 CPU1.R6 CPU1.T6 ; CPU1.AL11 v2(178.56,43.31) CPU1.AJ12 ; CPU1.AW6 174.92,36.5 v2(174.47,36.05) 174.87,35.66 CPU1.AY6 ; JDIMM1.159 133.97,56.68 v2(134.88,57.59) 134.79,57.68 JDIMM1.163 ; CPU1.AG9 v2(177.29,46.05) ; CPU1.AE12 v2(179.17,47.86) ; v2(121.45,33.46) 120.97,32.98 120.53,32.98 119.83,33.68 JDIMM3.75 ; CPU1.J5 174.29,59.78 CPU1.K6 CPU1.J6 174.94,60.03 v2(174.6,60.37) 174.29,60.05 CPU1.J5
  TOP w0.305: JDIMM3.136 107.98,48.92 CD52.1 ; JDIMM3.148 109.7,53.92 109.35,53.58 v2(109.35,53.41) ; 123.25,48.92 123.32,49 123.32,50.25 123.5,50.43 JDIMM1.142 ; 123.25,48.92 122.96,48.64 122.55,48.64 v2(121.73,47.82) ; 123.25,48.92 JDIMM1.136 ; JDIMM1.220 123.22,71.92 123.11,72.03 122.05,72.03 121.74,71.72 v2(121.74,71.55) ; CD39.1 106.86,72.17 107.79,72.17 108.03,71.92 JDIMM3.220 ; JDIMM3.118 109.6,44.42 109.2,44.83 v2(109.2,45.44) ; JDIMM1.178 125.46,61.43 126.04,62.01 v2(126.04,62.17) ; JDIMM3.123 119.83,45.68 v2(120.29,45.22) ; JDIMM3.160 109.23,56.92 v2(109.21,56.9) ; v2(123.08,55.44) 123.11,55.4 124.58,55.4 JDIMM1.154 ; JDIMM3.12 108.33,17.93 107.94,18.32 107.44,18.82 107.23,18.82 ; JDIMM1.135 133.94,48.68 v2(134.81,47.8) 134.19,47.17 JDIMM1.129 ; JDIMM3.154 109.07,55.43 v2(108.92,55.28) ; JDIMM3.163 119.62,57.68 119.85,57.44 120.54,57.44 v2(121.03,56.95) 120.75,56.68 JDIMM3.159 ; v2(134.76,50.72) 134.74,50.74 134.39,50.74 133.82,50.17 JDIMM1.141 ; CPU1.AA6 174.61,51.07 v2(174.61,51.14) 174.94,51.47 CPU1.W6 ; JDIMM1.111 133.96,42.68 134.38,43.1 134.38,43.55 v2(134.4,43.56) ; JDIMM1.148 123.67,53.92 122.48,55.11 v2(122.48,55.44) 122.48,55.68 123.72,56.92 JDIMM1.160 ; JDIMM1.112 123.57,42.92 123.11,43.38 v2(123.11,43.7) 123.11,44.16 123.38,44.42 JDIMM1.118 ; v2(122.79,45.23) 122.79,45.54 123.17,45.92 JDIMM1.124 ; JDIMM3.178 107.76,61.43 106.68,62.5 ; v2(121.65,45.17) 121.65,45.73 120.21,47.17 JDIMM3.129 ; JDIMM1.12 122.69,17.93 122.24,17.47 122.24,17.39 v2(122.15,17.3) ; JDIMM1.117 134.7,44.17 135.09,43.78 v2(135.09,43.56) ; JDIMM3.117 120.52,44.17 v2(121.01,43.69) 120,42.68 JDIMM3.111 ; v2(134.56,53.31) 134.38,53.5 133.96,53.5 133.88,53.54 133.73,53.54 133.45,53.68 JDIMM1.147 ; CPU1.L6 174.94,58.29 175.24,58.59 175.24,58.85 174.96,59.13 CPU1.K6 ; JDIMM1.123 134.77,45.68 v2(134.82,45.63) ; JDIMM3.124 109.57,45.92 v2(109.17,46.32) ; v2(122.39,76.64) 122.39,76.8 122.02,77.17 JDIMM3.241 ; JDIMM3.135 120.04,48.68 120.37,48.35 v2(120.37,48.28) ; JDIMM3.96 109.23,38.92 v2(109.2,38.96) ; CPU1.AR6 CPU1.AP6 175.2,40.11 CPU1.AP7 ; JDIMM1.96 122.88,38.92 122.49,39.32 122.49,39.53 v2(122.48,39.53) ; JDIMM1.33 134.11,23.17 134.65,23.71 135.13,23.71 135.48,23.36 135.48,23.25 v2(135.56,23.16) ; v2(121.18,55.45) 120.37,55.45 120.09,55.17 JDIMM3.153 ; CPU1.L12 179.02,58.57 179.02,59.06 CPU1.K12 ; JDIMM3.33 120.73,23.17 120.76,23.15 121.18,23.15 121.2,23.17 121.22,23.17 v2(121.7,23.66) ; v2(108.92,42.89) 108.96,42.92 JDIMM3.112 ; JDIMM3.199 121.44,66.67 121.7,66.41 v2(121.7,66.03) ; v2(135.5,66.7) 135.5,66.48 135.14,66.12 134.71,66.12 134.16,66.67 JDIMM1.199 ; JDIMM3.141 119.68,50.17 121.19,51.68 121.52,51.68 v2(121.76,51.45) ; JDIMM3.147 120.5,53.68 121.83,55 v2(121.83,55.44) ; v2(109.01,47.94) 109.52,47.43 JDIMM3.130 ; v2(108.94,51.11) 109.62,50.43 JDIMM3.142 ; JDIMM3.54 107.07,28.42 CD109.1 ; CPU1.AR12 179.11,38.93 179.11,38.54 CPU1.AT12 178.85,38.11 v2(178.56,37.82) ; v2(135.74,76.89) 135.2,77.43 134.33,77.43 134.08,77.17 JDIMM1.241
  TOP w0.33: CPU1.K12 v2(178.54,59.64)
  TOP w0.356: v2(122.47,27.75) 123.14,28.42 JDIMM1.54
  TOP w0.381: CD93.1 135.61,33.35 v2(135.29,33.67)
  TOP w0.508: CD10.1 135.59,52.41 135.2,52.8 v2(135.2,53.31) ; v2(138.1,41.59) 138.1,41.26 137.65,40.8 CD32.1 ; v2(108.21,49.74) 108.02,49.55 CD52.1 ; CD31.1 140.19,41.09 v2(139.7,41.57) 140.21,42.08 141.8,42.08 142.31,42.59 142.31,44.23 141.88,44.66 CD13.1 CD99.1 ; RD46.1 105.25,53.24 104.89,53.6 104.89,53.83 v2(104.91,53.84) ; 106.43,46.55 CD142.1 107.85,46.55 v2(108.03,46.38) ; CD58.1 106.87,65.55 v2(107.21,65.21) ; CD91.1 138.66,65.27 138.05,65.88 CD102.1 CD103.1 136.63,66.45 136.39,66.7 v2(136.2,66.7) ; v2(136,53.32) 136,53.32 136.01,53.31 137.14,53.31 CD95.1 137.19,52.61 CD90.1 ; CD116.1 105.31,45.69 CD64.1 CD45.1 ; v2(136.22,23.16) 136.36,23.02 CD12.1 136.42,22.44 CD89.1 138.26,22.44 138.92,23.1 CD27.1 138.9,24.07 CD100.1 CD24.1 ; RD9.1 136.12,60.24 v2(136.44,60.56) ; v2(141.12,19.51) 141.12,15.81 138.41,13.1 132.63,13.1 130.33,10.8 CD139.1 131.19,7.08 RD43.1 ; v2(135.5,66.7) 135.5,66.98 135.95,67.43 CD9.1 136.68,67.43 136.88,67.63 CD97.1 ; v2(108.25,42.93) 108.18,43 CD108.1 CD59.1 105.34,43 CD57.1 CD46.1 ; v2(103.4,50.59) 104.07,51.26 CD68.1 104.26,51.25 CD117.1 ; CD18.1 137.53,33.48 CD20.1 136.98,33.47 v2(136.79,33.66) ; CD28.1 138.92,41.6 v2(138.9,41.61) ; v2(107.57,66.67) 107.55,66.7 CD63.1 ; v2(134.82,45.63) 135.5,45.63 v2(135.51,45.64) 136.32,45.64 CD11.1 ; v2(106.54,29.03) 106.77,29.03 CD106.1 CD67.1 107.23,31.71 v2(107.44,31.93) ; v2(135.74,32) 136.08,32.34 CD15.1 CD34.1 ; CD40.1 106.61,60.97 CD49.1 107.75,60.47 v2(108.03,60.75) ; v2(108.11,45.47) 107.74,45.47 107.52,45.69 CD42.1 106.43,45.69 ; CD23.1 135.79,39.47 v2(135.73,39.53) ; v2(106.42,63.65) CD114.1 ; v2(106.52,19.54) 106.52,19.53 107.23,18.82 ; CD70.1 107.1,69.62 v2(107.32,69.4) ; CD39.1 106.63,71.9 107.03,71.51 v2(107.33,71.51) ; v2(107.8,38.06) 107.74,37.99 CD50.1 107.12,37.98 CD112.1 107.14,36.82 v2(107.14,36.16) ; v2(107.33,70.24) 106.81,70.76 CD118.1 ; CD41.1 CD111.1 108.06,51.25 v2(108.12,51.19) ; CD104.1 CD94.1 CD96.1 ; CD104.1 CD101.1 ; CD104.1 136.47,45.79 CD11.1 ; CD11.1 136.36,44.93 CD6.1 ; v2(135.67,62.19) 135.91,62.43 CD5.1 CD129.1 ; CD115.1 106.9,26.83 CD120.1 107.05,26.97 v2(107.05,27.67) 106.99,27.73 CD109.1 ; CD4.1 135.81,76.97 v2(135.74,76.89) ; v2(107.43,22.46) 107.4,22.5 CD110.1 106.66,22.51 CD107.1
  IN1 w0.508: v2(123.14,13.48) 124.25,14.59 124.25,47.79 123.44,48.6 122.15,48.6 121.73,48.18 v2(121.73,47.82)
  IN2 w0.508: v2(123.14,13.48) 126,13.48 128.06,15.55 128.82,15.55 129.15,15.87 132.03,15.87 132.64,15.26 145.67,15.26 146.74,16.33 152.52,16.33 153.78,15.07 157.78,15.07 158.6,15.9 158.6,28.79 164.89,35.07 173.84,35.07 174.47,35.7 v2(174.47,36.05)
  IN4 w0.508: v2(48.02,14.64) 48.02,16.75 50.73,19.46 53.46,19.46 55.31,21.32 61.07,21.32 62.14,22.39 62.14,25.96 63.72,27.54 63.72,31.58 65.22,33.08 71.27,33.08 72.24,34.06 74.57,34.06 v2(75.72,32.91)
  BOTTOM w0.254: v2(134.76,50.72) 134.76,50.73 134.79,50.71 134.79,50.4 134.26,49.88 134.26,49.33 133.86,48.92 JDIMM2.136
  BOTTOM w0.305: v2(135.73,28.69) 135.73,28.71 135.04,28.05 134.61,28.05 134.23,28.42 JDIMM2.54 ; v2(135.2,53.31) 135.2,53.3 135.21,53.31 135.21,55.95 134.24,56.92 JDIMM2.160 ; v2(134.76,50.72) 134.74,50.74 134.29,50.74 133.98,50.43 JDIMM2.142 ; v2(121.76,51.45) 121.23,51.45 120.21,50.43 JDIMM4.142 ; v2(109.35,53.41) 109.61,53.66 109.61,53.68 JDIMM4.147 ; JDIMM2.241 123.31,77.17 123.31,77.18 122.7,77.18 122.39,76.87 v2(122.39,76.64) ; v2(134.82,45.63) 134.52,45.92 JDIMM2.124 ; JDIMM2.12 134.05,17.93 134.53,18.4 135.18,18.4 v2(135.72,17.86) ; JDIMM2.154 133.85,55.43 134.6,54.68 134.6,53.35 v2(134.56,53.31) 133.95,53.92 JDIMM2.148 ; v2(122.79,45.23) 122.79,45.54 122.92,45.68 JDIMM2.123 ; JDIMM4.111 109.13,42.68 v2(108.92,42.89) ; JDIMM4.163 110.53,57.61 109.7,57.61 109.44,57.35 109.44,57.35 109.21,57.13 v2(109.21,56.9) 109.44,56.68 JDIMM4.159 ; JDIMM2.75 123.24,33.68 v2(123.08,33.51) ; v2(109.01,47.94) 109.05,47.9 109.05,47.4 109.28,47.17 JDIMM4.129 ; v2(108.94,51.11) 108.94,50.56 109.33,50.17 JDIMM4.141 ; JDIMM2.220 134.39,71.92 134.91,72.44 v2(134.91,73.14) ; JDIMM2.159 123.78,56.68 123.17,56.07 123.17,55.53 v2(123.08,55.44) 123.38,55.14 124.56,55.14 JDIMM2.153 ; JDIMM2.141 123.44,50.17 122.97,49.71 122.97,49.06 v2(121.73,47.82) ; v2(121.7,23.66) 122.21,23.15 122.75,23.15 122.78,23.17 JDIMM2.33 ; JDIMM2.130 134.44,47.43 v2(134.81,47.8) ; v2(120.62,38.04) 120.62,38.15 119.85,38.92 JDIMM4.96 ; v2(135.67,62.19) 135.67,62.1 135.22,61.64 134.72,61.64 134.5,61.43 JDIMM2.178 ; JDIMM4.153 109.03,55.17 v2(108.92,55.28) ; v2(109.2,45.44) 109.2,44.44 109.47,44.17 JDIMM4.117 ; JDIMM2.112 134.69,42.92 135.09,43.33 v2(135.09,43.56) ; v2(121.65,45.17) 121.65,45.74 119.96,47.43 JDIMM4.130 ; JDIMM4.123 109.75,45.68 109.17,46.25 v2(109.17,46.32) ; JDIMM2.96 135.18,38.92 v2(135.73,39.53) ; JDIMM2.147 123.08,53.68 122.45,54.31 122.45,55.38 122.48,55.42 v2(122.48,55.44) ; JDIMM4.148 121.17,53.92 121.83,54.58 v2(121.83,55.44) 121.83,55.59 123.08,56.84 123.08,57.02 123.74,57.68 JDIMM2.163 ; v2(121.78,27.72) 121.78,28.03 121.38,28.42 JDIMM4.54 ; v2(120.37,48.28) 119.73,48.92 JDIMM4.136 ; v2(107.57,66.67) 107.82,66.92 109.29,66.92 109.54,66.67 JDIMM4.199 ; JDIMM2.117 123.59,44.17 123.11,43.7 v2(123.11,43.7) 123.11,42.97 123.41,42.68 JDIMM2.111 ; v2(121.01,43.69) 120.96,43.63 120.67,43.63 119.96,42.92 JDIMM4.112 ; v2(121.03,56.95) 121,56.92 JDIMM4.160 ; v2(108.92,49.69) 108.92,49.01 109.26,48.68 JDIMM4.135 ; JDIMM4.154 121.15,55.43 v2(121.18,55.45) ; JDIMM2.118 133.74,44.42 134.4,43.77 v2(134.4,43.56) ; v2(120.86,62.33) 120.78,62.26 120.78,61.69 120.52,61.43 JDIMM4.178 ; JDIMM4.118 119.95,44.42 120.29,44.76 v2(120.29,45.22) 120.29,45.42 119.78,45.92 JDIMM4.124 ; v2(107.43,22.46) 108.07,23.11 108.61,23.11 108.68,23.17 JDIMM4.33 ; JDIMM2.199 122.16,66.67 121.7,66.22 v2(121.7,66.03) ; v2(121.74,71.55) 121.36,71.93 120.88,71.93 120.88,71.92 JDIMM4.220 ; JDIMM4.75 108.87,33.68 107.44,32.25 v2(107.44,31.93) ; JDIMM4.12 120.61,17.93 120.87,17.66 v2(120.87,17.38) ; JDIMM4.241 109.11,77.17 108.18,76.25 108.18,74.81 v2(108.13,74.76) ; JDIMM2.135 123.31,48.68 123.11,48.47 123.11,47.86 v2(123.12,47.85) 123.11,47.85 123.11,47.55 123.49,47.17 JDIMM2.129
  vias: v2(75.72,32.28) v2(75.72,31.64) v2(75.72,31.01) v2(76.35,32.91) v2(76.35,32.28) v2(76.35,31.64) v2(76.35,31.01) v2(76.37,30.37) v2(76.99,32.91) v2(76.99,32.28) v2(76.99,31.64) v2(76.99,31.01) v2(77,30.37) v2(77.62,32.91) v2(77.62,32.28) v2(77.62,31.64) v2(77.62,31.01) v2(77.64,30.37) v2(78.26,32.91) v2(78.26,32.28) v2(78.26,31.64) v2(78.26,31.01) v2(78.27,30.37) v2(93.45,33.61) v2(94.09,33.61) v2(94.08,32.99) v2(94.08,32.35) v2(94.07,31.71) v2(94.07,31.07) v2(94.07,30.44) v2(94.07,29.8) v2(94.72,33.61) v2(94.71,32.99) v2(94.71,32.35) v2(94.7,31.71) v2(94.7,31.07) v2(94.7,30.44) v2(94.7,29.8) v2(95.35,32.99) v2(95.35,32.35) v2(95.34,31.71) v2(95.34,31.07) v2(95.34,30.44) v2(95.34,29.8) v2(95.36,33.61) v2(107.82,62.29) v2(141.76,19.5) v2(142.39,19.5) v2(143.09,19.5) v2(143.73,19.5) v2(144.36,19.5) v2(150.66,56.96) v2(151.17,56.48) v2(151.65,56) v2(152.11,55.51) v3(77.5,35.28)
+1.2V_MEN_P: length 33.2
  TOP w0.508: v2(57.95,15.18) PC211.2 PR204.2
  IN1 w0.508: v2(57.95,15.18) 57.65,15.18 57.08,15.76 57.08,16.71 59.44,19.08 59.44,20.73 60.52,21.8 60.52,26.4 v2(62.34,28.23)
  IN2 w1.016: 65.89,27.86 64.76,27.86 63.29,26.39 63.29,22.65 64.14,21.8 64.14,17.92 64.63,17.43
  BOTTOM w0.203: PC214.1 58.48,14.93 58.61,14.93 58.98,15.29 PU200.5
  BOTTOM w0.508: PC214.1 57.89,15.12 v2(57.95,15.18)
  vias: v1(69.98,29.92) v2(65.09,16.38) v2(65.19,15.79) v2(65.94,31.52) v2(65.94,30.88) v2(65.94,30.25) v2(65.94,29.61) v2(65.94,28.98) v2(66.57,31.52) v2(66.57,30.88) v2(66.57,30.25) v2(66.57,29.61) v2(66.57,28.98) v2(67.21,31.52) v2(67.21,30.88) v2(67.21,30.25) v2(67.21,29.61) v2(67.21,28.98) v2(67.84,31.52) v2(67.84,30.88) v2(67.84,30.25) v2(67.84,29.61) v2(67.84,28.98)
+1.8V_ALW: length 172.8
  TOP w0.508: v2(239.59,81.26) 239.37,81.47 239.37,85.06 242.68,88.36 243.45,88.36 243.45,88.36 243.81,88.36 245.01,89.57 247.01,89.57 247.36,89.57 248.85,91.06 v2(249.03,91.06)
  IN2 w0.254: 157.18,130.04 158.13,130.04 158.16,130 160.32,130 161.11,130.8 160.89,131.02 158.03,131.02 157.18,130.17 157.18,130.04 ; 157.18,130.04 157.05,129.9
  IN2 w0.508: v2(188.29,128.19) 188.01,128.19 187.97,128.23 173.48,128.23 173.06,128.65 167.8,128.65 165.46,130.98 164.34,130.98 163.48,131.85 162.16,131.85 161.11,130.8 ; v2(137.9,128.32) 138.07,128.32 138.44,127.94 138.44,127.5 138.73,127.21 139.34,127.21 139.69,127.55 143.32,127.55 146.69,130.92 153,130.92 154.01,129.9 157.05,129.9 ; v2(238.8,103.84) 238.8,101.96 241.62,99.14 243,99.14 246.68,95.47 246.68,92.9 248.52,91.06 v2(249.03,91.06)
  IN3 w0.508: v2(237.52,123.79) 237.52,120.77 238.54,119.76 238.54,116.44 239.6,115.37 239.6,111.18 238.4,109.98 238.4,107.06 237.39,106.05 237.39,104.79 238.34,103.84 v2(238.8,103.84)
  IN4 w0.508: v2(188.29,128.19) 188.29,128.07 188.51,127.86 189.35,127.86 189.66,128.16 193.7,128.16 194.21,127.66 194.21,126.95 194.58,126.59 195.76,126.59 196.6,127.43 201.49,127.43 202.22,126.7 203.95,126.7 204.58,127.32 208.81,127.32 209.29,126.85 211.6,126.85 211.74,126.99 214.14,126.99 214.6,126.52 217.46,126.52 218.91,127.97 219.69,127.97 221.1,126.56 230.36,126.56 231.66,125.26 235.15,125.26 235.74,124.67 237.01,124.67 237.52,124.16 v2(237.52,123.79)
  BOTTOM w0.508: v2(137.9,128.32) 137.96,128.38 RH247.2
  vias: v3(238.62,80.59)
