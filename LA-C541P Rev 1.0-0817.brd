# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_ACE_DET#_R: length 2.7
  TOP w0.102: R388.2 50.68,31.19 v1(50.87,31) 51.51,30.35 JIO2.34
PECI_EC_R: length 4.9
  BOTTOM w0.102: C292.1 R953.1 194.49,117.58 v1(194.51,117.57) 194.51,117.4 195.05,116.85 U51.A48
PEDET: length 29.8
  TOP w0.102: v2(17.38,27.45) 17.49,27.45 17.5,27.47 QN5.2 18.38,28.45 R372.2
  IN3 w0.127: v2(20.01,6.75) 19.98,6.78 19.98,13.29 22.52,15.83 22.52,22.54 21.85,23.21 20.25,23.21 17.38,26.08 v2(17.38,27.45)
  BOTTOM w0.102: JNGFF3.61 19.75,5.72 20.01,5.98 v2(20.01,6.75)
PEG_COMP: length 5.2
  TOP w0.254: 169.98,62.37 170.92,61.43 170.92,61.34 171.49,60.77 171.52,60.77 171.53,60.76 172.33,60.76 CPU1.G2
  TOP w0.381: 169.98,62.37 169.72,62.63 168.2,62.63 RC2.2
PEG_CRX_C_GTX_N0: length 2.8
  TOP w0.102: CC1.2 176.68,90.17 176.68,89.73 176.85,89.56 176.85,88.97 177,88.83 JMXM1.177
PEG_CRX_C_GTX_N1: length 2.8
  TOP w0.102: CC2.2 178.45,90.17 178.45,89.71 178.35,89.6 178.35,88.97 178.5,88.83 JMXM1.171
PEG_CRX_C_GTX_N2: length 2.9
  TOP w0.102: CC3.2 180.23,90.17 180.23,89.77 179.85,89.39 179.85,88.97 180,88.83 JMXM1.165
PEG_CRX_C_GTX_N3: length 2.8
  TOP w0.102: CC4.2 183.34,90.17 183.34,88.98 183.5,88.83 JMXM1.157
PEG_CRX_C_GTX_N4: length 4.5
  TOP w0.102: JMXM1.151 185,88.83 184.83,88.99 v4(184.83,89.87) 184.83,91.97 CC5.2
PEG_CRX_C_GTX_N5: length 2.7
  TOP w0.102: CC6.2 186.35,90.19 186.35,88.98 186.5,88.83 JMXM1.145
PEG_CRX_C_GTX_N6: length 4.5
  TOP w0.102: CC7.2 187.82,91.98 v4(187.82,89.8) 187.82,89 188,88.83 JMXM1.139
PEG_CRX_C_GTX_N7: length 2.8
  TOP w0.102: JMXM1.133 189.5,88.83 189.33,88.99 189.33,90.19 CC8.2
PEG_CRX_C_GTX_N8: length 4.5
  TOP w0.102: CC9.2 190.84,91.95 v4(190.84,89.81) 190.84,88.99 191,88.83 JMXM1.127
PEG_CRX_C_GTX_N9: length 2.8
  TOP w0.102: CC10.2 192.35,90.16 192.35,88.97 192.5,88.83 JMXM1.121
PEG_CRX_C_GTX_N10: length 4.5
  TOP w0.102: CC11.2 193.84,91.97 v4(193.84,89.87) 193.84,88.98 194,88.83 JMXM1.115
PEG_CRX_C_GTX_N11: length 2.8
  TOP w0.102: JMXM1.109 195.5,88.83 195.31,89.01 195.31,90.2 CC12.2
PEG_CRX_C_GTX_N12: length 4.6
  TOP w0.102: CC13.2 196.74,91.95 196.74,91.77 196.85,91.66 v4(196.85,89.82) 196.85,88.97 197,88.83 JMXM1.103
PEG_CRX_C_GTX_N13: length 2.8
  TOP w0.102: JMXM1.97 198.5,88.83 198.35,88.97 198.35,89.72 198.27,89.8 198.27,90.17 CC14.2
PEG_CRX_C_GTX_N14: length 2.8
  TOP w0.102: CC15.2 200.04,90.17 200.04,89.56 199.85,89.37 199.85,88.97 200,88.83 JMXM1.91
PEG_CRX_C_GTX_N15: length 3
  TOP w0.102: JMXM1.85 201.5,88.83 201.35,88.97 201.35,89.23 201.82,89.71 201.82,90.17 CC16.2
PEG_CRX_C_GTX_P0: length 2.8
  TOP w0.102: CC17.2 176.46,90.17 176.46,89.64 176.63,89.47 176.63,88.97 176.5,88.84 JMXM1.179
PEG_CRX_C_GTX_P1: length 2.8
  TOP w0.102: CC18.2 178.24,90.17 178.24,89.8 178.13,89.69 178.13,88.97 178,88.84 JMXM1.173
PEG_CRX_C_GTX_P2: length 2.9
  TOP w0.102: CC19.2 180.02,90.17 180.02,89.86 179.63,89.48 179.63,88.97 179.5,88.84 JMXM1.167
PEG_CRX_C_GTX_P3: length 2.7
  TOP w0.102: JMXM1.159 183,88.84 183.13,88.97 183.13,90.17 CC20.2
PEG_CRX_C_GTX_P4: length 4.5
  TOP w0.102: JMXM1.153 184.5,88.84 184.61,88.96 v4(184.61,91.19) 184.61,91.92 CC21.2
PEG_CRX_C_GTX_P5: length 2.8
  TOP w0.102: JMXM1.147 186,88.84 186.13,88.97 186.13,90.15 CC22.2
PEG_CRX_C_GTX_P6: length 4.5
  TOP w0.102: JMXM1.141 187.5,88.84 187.6,88.95 v4(187.6,91.17) 187.6,91.91 CC23.2
PEG_CRX_C_GTX_P7: length 2.8
  TOP w0.102: CC24.2 189.12,90.15 189.12,88.96 189,88.84 JMXM1.135
PEG_CRX_C_GTX_P8: length 4.5
  TOP w0.102: CC25.2 190.62,91.95 v4(190.62,91.09) 190.62,88.96 190.5,88.84 JMXM1.129
PEG_CRX_C_GTX_P9: length 2.8
  TOP w0.102: JMXM1.123 192,88.84 192.14,88.98 192.14,90.17 CC26.2
PEG_CRX_C_GTX_P10: length 4.5
  TOP w0.102: CC27.2 193.63,91.92 v4(193.63,91.2) 193.63,88.97 193.5,88.84 JMXM1.117
PEG_CRX_C_GTX_P11: length 2.7
  TOP w0.102: JMXM1.111 195,88.98 195.1,89.08 195.1,90.14 CC28.2
PEG_CRX_C_GTX_P12: length 4.6
  TOP w0.102: JMXM1.105 196.5,88.84 196.63,88.97 v4(196.63,91.14) 196.63,91.57 196.53,91.68 196.53,91.95 CC29.2
PEG_CRX_C_GTX_P13: length 2.8
  TOP w0.102: JMXM1.99 198,88.84 198.13,88.97 198.13,89.63 198.05,89.71 198.05,90.17 CC30.2
PEG_CRX_C_GTX_P14: length 2.8
  TOP w0.102: JMXM1.93 199.5,88.83 199.63,88.96 199.63,89.46 199.83,89.65 199.83,90.17 CC31.2
PEG_CRX_C_GTX_P15: length 2.9
  TOP w0.102: JMXM1.87 201,88.84 201.13,88.97 201.13,89.32 201.61,89.8 201.61,90.17 CC32.2
PEG_CRX_GTX_N0: length 36.8
  TOP w0.089: CPU1.E10 177.51,62.11 v2(177.19,62.44)
  TOP w0.102: v2(177.78,92.1) 177.61,92.26 176.75,92.26 176.58,92.09 176.58,91.52 176.69,91.42 CC1.1
  IN1 w0.089: 176.34,70.91 176.34,70.88 176.33,70.87 176.33,65.32 176.96,64.69 176.96,62.88 177.03,62.81 177.26,62.81 177.37,62.69 177.37,62.62 v2(177.19,62.44)
  IN1 w0.109: v2(177.78,92.1) 177.78,92.03 177.64,91.89 177.47,91.89 177.36,92.01 177.36,92.36 177.25,92.47 176.96,92.47 176.61,92.12 176.61,89.66 174.92,87.96 174.92,85.92 174.43,85.43 174.43,77.5 175.64,76.29 175.64,73.3 175.65,73.3 175.65,73.21 176.34,72.51 176.34,70.91
PEG_CRX_GTX_N1: length 36.8
  TOP w0.089: CPU1.E11 178.04,62.44 v2(177.97,62.44)
  TOP w0.102: CC2.1 178.44,91.42 178.36,91.5 178.36,91.77 178.45,91.87 178.54,91.87 178.65,91.98 178.85,91.98 179.17,92.3 179.3,92.3 v2(179.53,92.07)
  IN1 w0.089: v2(177.97,62.44) 177.97,62.65 177.89,62.73 177.6,62.73 177.41,62.92 177.41,64.83 176.97,65.27 176.97,66.01 176.83,66.16 176.83,70.81 176.81,70.83 176.81,70.91
  IN1 w0.109: v2(179.53,92.07) 179.89,92.07 179.98,91.99 179.98,91.75 179.68,91.46 179,91.46 176.36,88.82 176.36,85.01 174.84,83.49 174.84,77.7 176.06,76.48 176.06,73.43 176.81,72.68 176.81,70.91
PEG_CRX_GTX_N2: length 37.3
  TOP w0.089: CPU1.E12 179.09,62.11 v2(178.76,62.44)
  TOP w0.102: CC3.1 180.27,91.42 180.14,91.55 180.14,91.89 180.81,92.55 181.01,92.55 v2(181.26,92.31)
  IN1 w0.089: v2(178.76,62.44) 178.7,62.38 178.63,62.38 178.54,62.46 178.54,64.02 178.19,64.36 178.19,65.78 177.63,66.34 177.63,70.81 177.64,70.82 177.64,70.88 177.65,70.89 177.65,70.91
  IN1 w0.109: v2(181.26,92.31) 181.26,92.31 181.46,92.51 181.46,92.76 181.37,92.84 181.24,92.84 181.17,92.78 181.04,92.78 180.83,92.56 180.83,91.4 178.5,89.07 178.5,86.53 177.8,85.83 177.8,84.25 176.39,82.84 176.39,77.79 176.9,77.27 176.9,73.82 177.65,73.07 177.65,70.91
PEG_CRX_GTX_N3: length 37
  TOP w0.089: CPU1.E13 179.81,62.11 v2(179.54,62.39)
  TOP w0.102: CC4.1 183.43,91.67 183.43,92.09 183.05,92.48 182.86,92.48 v2(182.67,92.67)
  IN1 w0.089: v2(179.54,62.39) 179.38,62.54 179.21,62.54 178.93,62.82 178.93,63.97 178.54,64.37 178.54,65.6 178.86,65.92 178.86,70.19 178.61,70.44 178.61,70.91
  IN1 w0.109: v2(182.67,92.67) 182.66,92.65 182.07,92.65 181.88,92.46 181.88,92.08 181.4,91.6 181.4,91.32 179.4,89.33 179.4,86.56 178.89,86.04 178.67,86.04 178.22,85.59 178.22,85.38 178.22,85.37 178.22,84.08 176.8,82.66 176.8,77.96 177.88,76.88 177.88,73.65 178.61,72.93 178.61,70.91
PEG_CRX_GTX_N4: length 40.5
  TOP w0.089: CPU1.E14 180.66,62.11 v2(180.34,61.79)
  TOP w0.102: v2(184.12,94.62) 184.23,94.51 184.57,94.51 184.9,94.18 184.9,93.44 CC5.1
  IN1 w0.089: 179.49,70.25 179.49,70.24 179.5,70.23 179.5,70.16 179.51,70.15 179.51,69.82 179.42,69.74 179.42,65.59 179.52,65.5 179.52,65.2 179.42,65.11 179.42,64.4 180,63.82 180,62.76 180.76,62 180.76,61.69 180.71,61.65 180.48,61.65 v2(180.34,61.79)
  IN1 w0.109: 179.49,70.25 179.49,70.65 179.28,70.86 179.28,74.21 179.19,74.3 179.19,76.53 178.01,77.72 178.01,82.98 180.06,85.04 180.06,89.1 181.25,90.28 182.39,90.28 183.28,91.17 183.28,92.57 183.59,92.87 183.59,94.08 184.12,94.61 v2(184.12,94.62)
PEG_CRX_GTX_N5: length 37.3
  TOP w0.089: v2(181.12,62.44) CPU1.E15
  TOP w0.102: CC6.1 186.54,91.54 186.54,92.29 186.22,92.6 186.05,92.6 185.79,92.86 v2(185.79,92.91)
  IN1 w0.089: v2(181.12,62.44) 180.97,62.59 180.8,62.59 180.52,62.87 180.52,63.9 180.24,64.18 180.23,64.18 180.13,64.28 180.02,64.4 180.02,70.04 180.1,70.13 180.1,70.91
  IN1 w0.109: v2(185.79,92.91) 185.59,92.7 184.48,92.7 183.91,92.13 183.91,90.91 181.21,88.21 181.21,86.65 180.76,86.2 180.76,84.73 179.15,83.11 179.15,77.52 179.82,76.84 179.82,74.56 179.91,74.47 179.91,71.27 180.1,71.08 180.1,70.91
PEG_CRX_GTX_N6: length 40.8
  TOP w0.089: CPU1.E16 182.24,62.11 v2(181.91,62.44)
  TOP w0.102: CC7.1 187.8,93.2 187.7,93.29 187.7,93.79 188.18,94.27 188.31,94.27 188.57,94 v2(188.57,93.94)
  IN1 w0.089: v2(181.91,62.44) 181.73,62.62 181.73,64.02 181.38,64.36 181.38,70.8 181.4,70.82 181.4,70.91
  IN1 w0.109: v2(188.57,93.94) 188.86,93.94 188.98,94.06 188.98,94.23 188.86,94.35 188.08,94.35 187.01,93.29 187.01,92.07 186.31,91.37 185.57,91.37 182.05,87.86 182.05,86.22 181.61,85.78 181.61,84.38 179.99,82.76 179.99,77.97 181.35,76.61 181.35,71.61 181.4,71.56 181.4,70.91
PEG_CRX_GTX_N7: length 38.2
  TOP w0.089: CPU1.E17 v2(182.7,62.44)
  TOP w0.102: v2(188.85,92.8) 188.85,92.64 188.95,92.54 189.22,92.54 189.4,92.36 189.4,91.66 CC8.1
  IN1 w0.089: v2(182.7,62.44) 182.54,62.59 182.29,62.59 182.05,62.83 182.05,64.11 181.71,64.45 181.71,65.7 181.89,65.88 181.89,70.9 181.88,70.91
  IN1 w0.109: 181.88,70.91 181.88,71.67 181.76,71.78 181.76,76.86 180.83,77.8 180.83,82.27 183.38,84.82 183.38,88.6 185.74,90.96 186.49,90.96 187.5,91.97 187.5,92.49 187.8,92.8 v2(188.85,92.8)
PEG_CRX_GTX_N8: length 41.4
  TOP w0.089: v2(183.49,61.79) CPU1.F18
  TOP w0.102: v2(189.83,94.52) 189.84,94.51 190.16,94.51 190.23,94.57 190.73,94.57 190.93,94.37 190.93,93.44 CC9.1
  IN1 w0.089: v2(183.49,61.79) 183.07,62.4 183.07,63.94 182.73,64.27 182.73,65.49 182.52,65.7 182.52,70.81 182.51,70.82 182.51,70.91
  IN1 w0.109: 182.51,70.91 182.51,71.98 182.39,72.1 182.39,74.11 182.4,74.11 182.4,77.14 181.46,78.07 181.46,81.99 184.45,84.97 184.45,88.77 185.99,90.32 188.32,90.32 189.65,91.65 189.65,94.06 189.83,94.24 v2(189.83,94.52)
PEG_CRX_GTX_N9: length 40.1
  TOP w0.089: CPU1.D19 184.6,62.76 v2(184.27,63.09)
  TOP w0.102: CC10.1 192.63,91.42 192.28,91.77 192.28,91.86 192.14,92 192.14,92.31 192.35,92.51 192.5,92.51 192.63,92.38 v2(192.63,92.09)
  IN1 w0.089: v2(184.27,63.09) 184.27,62.88 184.19,62.79 184,62.79 183.82,62.97 183.82,64.73 183.5,65.05 183.5,65.52 183.81,65.82 183.81,70.62 183.53,70.91
  IN1 w0.109: v2(192.63,92.09) 192.83,92.29 192.83,92.43 192.74,92.51 192.22,92.51 188.6,88.89 186.7,88.89 185.81,88 185.81,85.02 182.33,81.55 182.33,78.46 183.25,77.54 183.25,72.64 183.49,72.4 183.49,72.27 183.49,72.22 183.49,72.22 183.49,70.94 183.53,70.91
PEG_CRX_GTX_N10: length 39.8
  TOP w0.089: v2(185.88,61.79) 185.78,61.79 CPU1.F20
  TOP w0.102: v2(193.94,93.82) 193.76,93.63 193.76,93.54 194.1,93.2 CC11.1
  IN1 w0.089: 184.4,70.91 184.46,70.85 184.46,70.59 184.46,70.31 184.62,70.14 184.62,64.43 184.85,64.21 184.85,63.17 185.46,62.55 185.46,61.92 185.59,61.79 v2(185.88,61.79)
  IN1 w0.109: v2(193.94,93.82) 194.02,93.74 194.02,92.15 192.85,90.99 191.59,90.99 188.15,87.55 188.15,86.41 183.46,81.72 183.46,78.53 184.34,77.64 184.34,70.96 184.4,70.91
PEG_CRX_GTX_N11: length 39.6
  TOP w0.089: v2(185.85,63.09) 186.17,62.76 CPU1.D21
  TOP w0.102: v2(194.8,92.66) 194.94,92.51 195.22,92.51 195.47,92.26 195.47,91.88 195.37,91.78 195.37,91.67 CC12.1
  IN1 w0.089: v2(185.85,63.09) 185.7,62.94 185.63,62.94 185.39,63.17 185.39,64.5 185.18,64.71 185.18,70.8 185.2,70.82 185.2,70.91
  IN1 w0.109: 185.2,70.91 185.2,71.07 185.18,71.09 185.18,71.1 184.98,71.31 184.98,77.86 184.97,77.86 184.97,77.91 184.66,78.22 184.66,82.03 189.18,86.56 189.18,87.7 191.81,90.32 193.11,90.32 193.79,91 195.41,91 195.71,91.31 195.71,92.01 195.2,92.51 194.94,92.51 v2(194.8,92.66)
PEG_CRX_GTX_N12: length 43.3
  TOP w0.089: v2(186.64,61.79) CPU1.F22
  TOP w0.102: CC13.1 196.83,93.44 196.83,93.7 196.51,94.03 195.41,94.03 v2(195.22,94.22)
  IN1 w0.089: v2(186.64,61.79) 187,62.31 187,62.59 186.41,63.18 186.41,64.64 186.19,64.86 186.19,65.88 186.36,66.04 186.36,67.4 186.19,67.56 186.19,70.91
  IN1 w0.109: v2(195.22,94.22) 195.22,94.22 195.43,94.01 195.69,94.01 196.47,93.23 196.47,91.18 195.56,90.27 193.98,90.27 193.41,89.69 192.07,89.69 189.81,87.44 189.81,86.29 185.3,81.78 185.3,78.47 185.61,78.16 185.61,71.63 186.19,71.04 186.19,70.91
PEG_CRX_GTX_N13: length 40.5
  TOP w0.089: v2(187.42,63.09) 187.75,62.76 CPU1.D23
  TOP w0.102: v2(197.72,92.62) 197.72,92.6 197.85,92.48 198.15,92.48 198.36,92.26 198.36,91.66 CC14.1
  IN1 w0.089: v2(187.42,63.09) 187.26,62.92 187.22,62.92 186.97,63.18 186.97,64.86 186.66,65.17 186.66,65.53 186.99,65.86 186.99,70.87 187,70.88 187,70.91
  IN1 w0.109: 187,70.91 187,71.25 186.38,71.87 186.38,73.52 186.73,73.87 186.73,76.22 186.41,76.54 186.41,82 190.91,86.5 190.91,87.64 192.33,89.06 193.7,89.06 194.24,89.59 195.78,89.59 197.18,90.99 197.88,90.99 198.35,91.46 198.35,92.07 198.15,92.27 198.07,92.27 v2(197.72,92.62)
PEG_CRX_GTX_N14: length 40.9
  TOP w0.089: v2(188.21,61.79) CPU1.F24
  TOP w0.102: CC15.1 200.13,91.67 200.13,91.91 200.08,91.97 200.08,92.25 199.73,92.59 v2(199.73,92.85)
  IN1 w0.089: v2(188.21,61.79) 187.81,62.38 187.79,62.41 187.79,63.91 187.49,64.2 187.49,70.6 187.44,70.65 187.44,70.81 187.43,70.82 187.43,70.88 187.41,70.89 187.41,70.91
  IN1 w0.109: 187.41,70.91 187.41,82.13 191.33,86.04 191.33,87.11 192.86,88.64 193.91,88.64 194.3,89.03 195.81,89.03 197.22,90.44 197.92,90.44 198.77,91.29 198.77,92.43 199.02,92.68 199.56,92.68 v2(199.73,92.85)
PEG_CRX_GTX_N15: length 40.5
  TOP w0.089: CPU1.D25 189.32,62.76 v2(189,63.09)
  TOP w0.102: v2(200.5,92.67) 200.6,92.58 201.26,92.58 201.92,91.92 201.92,91.66 CC16.1
  IN1 w0.089: 188.26,70.91 188.26,70.88 188.27,70.86 188.27,70.61 188.75,70.14 188.75,66.08 188.2,65.54 188.2,64.85 188.52,64.53 188.52,63.31 188.74,63.09 v2(189,63.09)
  IN1 w0.109: v2(200.5,92.67) 201.01,92.16 201.01,91.7 199.5,90.19 198.87,90.19 198.21,89.53 197.5,89.53 196.13,88.16 194.64,88.16 188.26,81.78 188.26,70.91
PEG_CRX_GTX_P0: length 36.8
  TOP w0.089: v2(177.19,61.79) CPU1.F10
  TOP w0.102: CC17.1 176.37,91.66 176.37,92.18 176.66,92.48 177.43,92.48 177.63,92.68 v2(177.62,92.69)
  IN1 w0.089: 176.13,70.91 176.13,70.88 176.14,70.87 176.14,65.23 176.76,64.61 176.76,62.42 176.97,62.12 v2(177.19,61.79)
  IN1 w0.109: 176.13,70.91 176.13,72.42 175.43,73.12 175.43,73.21 175.43,73.21 175.43,76.2 174.21,77.41 174.21,85.52 174.71,86.01 174.71,88.05 176.39,89.75 176.39,92.21 176.87,92.69 v2(177.62,92.69)
PEG_CRX_GTX_P1: length 36.8
  TOP w0.089: v2(177.97,63.09) 178.3,62.76 CPU1.D11
  TOP w0.102: CC18.1 178.14,91.66 178.14,91.86 178.36,92.08 178.45,92.08 178.56,92.19 178.76,92.19 179.08,92.51 179.38,92.51 v2(179.53,92.66)
  IN1 w0.089: v2(177.97,63.09) 177.82,62.93 177.68,62.93 177.61,63 177.61,64.91 177.17,65.35 177.17,66.1 177.02,66.24 177.02,70.91
  IN1 w0.109: 177.02,70.91 177.02,72.77 176.27,73.52 176.27,76.57 175.06,77.79 175.06,83.4 176.57,84.92 176.57,88.73 179.09,91.24 179.77,91.24 180.19,91.66 180.19,92.08 179.96,92.31 179.87,92.31 v2(179.53,92.66)
PEG_CRX_GTX_P2: length 37.3
  TOP w0.089: v2(178.76,61.79) 179.09,61.46 CPU1.F12
  TOP w0.102: CC19.1 179.93,91.66 179.93,91.97 180.75,92.8 181,93.05 v2(181,93.19)
  IN1 w0.089: 177.44,70.91 177.44,66.26 178,65.7 178,64.28 178.34,63.94 178.34,62.31 178.76,61.89 v2(178.76,61.79)
  IN1 w0.109: v2(181,93.19) 181,93.05 180.61,92.65 180.61,91.49 178.28,89.16 178.28,86.62 177.59,85.92 177.59,84.34 176.17,82.93 176.17,77.7 176.69,77.18 176.69,73.73 177.44,72.98 177.44,70.91
PEG_CRX_GTX_P3: length 37
  TOP w0.089: CPU1.D13 179.87,62.76 179.55,63.09 179.55,63.13 v2(179.54,63.14)
  TOP w0.102: v2(182.65,92.05) 182.65,92.15 182.76,92.26 182.96,92.26 183.22,92 183.22,91.53 183.11,91.42 CC20.1
  IN1 w0.089: 178.82,70.91 178.8,70.89 178.8,70.52 179.05,70.27 179.05,65.84 178.73,65.52 178.73,64.45 179.12,64.06 179.12,62.9 179.27,62.76 179.63,62.76 179.7,62.82 179.7,62.99 v2(179.54,63.14)
  IN1 w0.109: 178.82,70.91 178.82,73.02 178.1,73.74 178.1,76.97 177.02,78.05 177.02,82.58 178.43,83.99 178.43,85.28 178.44,85.29 178.44,85.5 178.76,85.83 178.98,85.83 179.62,86.47 179.62,89.24 181.61,91.23 181.61,91.51 182.1,91.99 182.1,92.37 182.16,92.44 182.26,92.44 v2(182.65,92.05)
PEG_CRX_GTX_P4: length 40.4
  TOP w0.089: v2(180.34,61.14) 180.66,61.46 CPU1.F14
  TOP w0.102: CC21.1 184.56,93.2 184.68,93.32 184.68,94.09 184.48,94.29 184.38,94.29 v2(184.12,94.03)
  IN1 w0.089: 179.71,70.25 179.71,69.74 179.62,69.65 179.62,65.67 179.71,65.58 179.71,65.12 179.62,65.03 179.62,64.48 180.19,63.9 180.19,62.84 180.95,62.08 180.95,61.61 180.8,61.45 180.47,61.45 180.34,61.31 v2(180.34,61.14)
  IN1 w0.109: v2(184.12,94.03) 183.89,94.03 183.8,93.94 183.8,92.78 183.49,92.48 183.49,91.08 182.48,90.07 181.34,90.07 180.28,89.01 180.28,84.95 178.22,82.89 178.22,77.81 179.41,76.62 179.41,74.39 179.5,74.3 179.5,70.95 179.71,70.74 179.71,70.25
PEG_CRX_GTX_P5: length 37.3
  TOP w0.089: v2(181.12,63.09) 181.45,62.76 CPU1.D15
  TOP w0.102: v2(185.78,92.06) 185.78,92.23 185.95,92.39 186.13,92.39 186.33,92.2 186.33,91.89 185.85,91.42 CC22.1
  IN1 w0.089: 180.32,70.91 180.32,70.89 180.31,70.88 180.31,70.82 180.3,70.81 180.3,70.05 180.21,69.96 180.21,64.56 180.21,64.48 180.32,64.37 180.71,63.98 180.71,62.95 180.88,62.78 181.01,62.78 181.12,62.9 v2(181.12,63.09)
  IN1 w0.109: 180.32,70.91 180.32,71.17 180.13,71.36 180.13,74.56 180.04,74.65 180.04,76.93 179.36,77.61 179.36,83.02 180.98,84.64 180.98,86.11 181.42,86.56 181.42,88.12 184.12,90.82 184.12,92.04 184.57,92.49 185.81,92.49 185.93,92.36 185.93,92.19 185.81,92.06 v2(185.78,92.06)
PEG_CRX_GTX_P6: length 40.8
  TOP w0.089: v2(181.91,61.79) CPU1.F16
  TOP w0.102: CC23.1 187.49,93.45 187.49,93.88 188.09,94.48 188.27,94.48 v2(188.55,94.76)
  IN1 w0.089: v2(181.91,61.79) 181.53,62.34 181.53,63.94 181.19,64.28 181.19,70.91
  IN1 w0.109: v2(188.55,94.76) 188.35,94.57 187.99,94.57 186.8,93.38 186.8,92.16 186.22,91.59 185.48,91.59 181.84,87.95 181.84,86.31 181.4,85.87 181.4,84.47 179.78,82.85 179.78,77.88 181.13,76.52 181.13,71.52 181.19,71.47 181.19,70.91
PEG_CRX_GTX_P7: length 38.2
  TOP w0.089: CPU1.D17 183.02,62.76 182.7,63.09 v2(182.7,63.15)
  TOP w0.102: CC24.1 189.1,91.42 189.19,91.5 189.19,92.27 189.13,92.32 188.85,92.32 188.78,92.25 v2(188.78,92.03)
  IN1 w0.089: 182.09,70.91 182.08,70.9 182.08,65.8 181.9,65.62 181.9,64.53 182.24,64.19 182.24,62.91 182.37,62.79 182.52,62.79 182.53,62.8 182.66,62.8 182.78,62.92 182.78,63.07 v2(182.7,63.15)
  IN1 w0.109: 182.09,70.91 182.09,71.76 181.98,71.87 181.98,76.95 181.04,77.89 181.04,82.18 183.6,84.73 183.6,88.51 185.83,90.74 186.58,90.74 187.71,91.88 187.71,92.4 187.89,92.58 188.41,92.58 188.78,92.21 v2(188.78,92.03)
PEG_CRX_GTX_P8: length 41.4
  TOP w0.089: v2(183.49,62.47) 183.85,62.11 CPU1.E18
  TOP w0.102: CC25.1 190.64,93.2 190.72,93.27 190.72,94.28 190.64,94.36 190.34,94.36 190.24,94.25 190.24,93.87 v2(190.31,93.81)
  IN1 w0.089: v2(183.49,62.47) 183.31,62.47 183.26,62.52 183.26,64.02 182.93,64.35 182.93,65.57 182.72,65.78 182.72,70.81 182.73,70.82 182.73,70.91
  IN1 w0.109: v2(190.31,93.81) 190.48,93.98 190.48,94.16 190.36,94.29 190.18,94.29 189.87,93.97 189.87,91.56 188.41,90.1 186.08,90.1 184.66,88.68 184.66,84.88 181.68,81.9 181.68,78.16 182.61,77.23 182.61,74.02 182.61,74.02 182.61,72.19 182.73,72.07 182.73,70.91
PEG_CRX_GTX_P9: length 40.1
  TOP w0.089: v2(184.27,62.44) CPU1.E19
  TOP w0.102: CC26.1 192.06,91.67 192.06,91.77 191.93,91.91 191.93,92.4 192.26,92.73 192.38,92.73 v2(192.63,92.97)
  IN1 w0.089: 183.27,70.91 183.27,70.88 183.61,70.54 183.61,65.91 183.31,65.6 183.31,64.97 183.62,64.65 183.62,62.89 183.91,62.59 184.12,62.59 v2(184.27,62.44)
  IN1 w0.109: v2(192.63,92.97) 192.63,92.86 192.49,92.73 192.13,92.73 188.51,89.11 186.61,89.11 185.59,88.09 185.59,85.11 182.11,81.64 182.11,78.37 183.03,77.45 183.03,72.55 183.27,72.31 183.27,70.91
PEG_CRX_GTX_P10: length 39.8
  TOP w0.089: v2(185.06,61.81) 185.07,61.82 185.2,61.82 185.45,62.08 CPU1.E20
  TOP w0.102: CC27.1 193.54,93.47 193.54,93.67 193.39,93.82 v2(193.25,93.82)
  IN1 w0.089: v2(185.06,61.81) 185.06,61.81 185.27,62.02 185.27,62.47 184.65,63.09 184.65,64.13 184.43,64.35 184.43,70.06 184.26,70.23 184.26,70.74 184.13,70.87 184.13,70.91
  IN1 w0.109: 184.13,70.91 184.13,77.55 183.24,78.44 183.24,81.81 187.93,86.5 187.93,87.64 191.5,91.21 192.76,91.21 193.8,92.24 193.8,93.27 v2(193.25,93.82)
PEG_CRX_GTX_P11: length 39.6
  TOP w0.089: v2(185.85,62.44) 186.17,62.11 CPU1.E21
  TOP w0.102: v2(194.8,92.07) 195.02,92.3 195.13,92.3 195.25,92.17 195.25,91.97 195.15,91.87 195.15,91.52 195.03,91.4 194.75,91.4 CC28.1
  IN1 w0.089: 184.99,70.91 184.99,64.63 185.2,64.42 185.2,63.09 185.46,62.82 v2(185.85,62.44)
  IN1 w0.109: v2(194.8,92.07) 194.8,92.1 195,92.3 195.11,92.3 195.5,91.92 195.5,91.4 195.32,91.22 193.7,91.22 193.02,90.53 191.72,90.53 188.97,87.79 188.97,86.65 184.45,82.12 184.45,78.13 184.76,77.82 184.76,77.77 184.76,77.77 184.76,71.2 184.99,70.98 184.99,70.91
PEG_CRX_GTX_P12: length 43.3
  TOP w0.089: v2(186.64,62.44) 186.96,62.11 CPU1.E22
  TOP w0.102: v2(195.28,93.37) 195.28,93.4 195.69,93.81 196.42,93.81 196.62,93.61 196.62,93.27 196.54,93.2 CC29.1
  IN1 w0.089: 185.98,70.91 185.98,70.89 185.99,70.88 185.99,70.82 186,70.81 186,67.48 186.16,67.32 186.16,66.12 186,65.96 186,64.78 186.22,64.56 186.22,63.1 186.64,62.68 v2(186.64,62.44)
  IN1 w0.109: v2(195.28,93.37) 194.9,93.37 194.77,93.49 194.77,93.67 194.9,93.8 195.6,93.8 196.26,93.14 196.26,91.27 195.47,90.48 193.9,90.48 193.32,89.9 191.98,89.9 189.6,87.52 189.6,86.38 185.08,81.87 185.08,78.38 185.39,78.07 185.39,71.54 185.98,70.95 185.98,70.91
PEG_CRX_GTX_P13: length 40.5
  TOP w0.089: v2(187.42,62.44) 187.75,62.11 CPU1.E23
  TOP w0.102: CC30.1 198.08,91.42 198.15,91.48 198.15,92.17 198.06,92.26 197.92,92.26 197.72,92.06 v2(197.72,92.04)
  IN1 w0.089: 186.78,70.91 186.78,70.89 186.79,70.88 186.79,65.94 186.46,65.61 186.46,65.09 186.77,64.78 186.77,63.1 187.14,62.73 187.35,62.73 187.42,62.66 v2(187.42,62.44)
  IN1 w0.109: 186.78,70.91 186.78,71.16 186.16,71.78 186.16,73.61 186.52,73.96 186.52,76.13 186.2,76.45 186.2,82.09 190.7,86.59 190.7,87.73 192.24,89.27 193.61,89.27 194.15,89.81 195.69,89.81 197.09,91.21 197.79,91.21 198.14,91.55 198.14,91.98 198.08,92.04 197.72,92.04 v2(197.72,92.04)
PEG_CRX_GTX_P14: length 40.9
  TOP w0.089: CPU1.E24 188.54,62.11 v2(188.21,62.44)
  TOP w0.102: v2(199.41,92.03) 199.64,92.26 199.76,92.26 199.86,92.16 199.86,91.88 199.91,91.82 199.91,91.51 199.82,91.42 CC31.1
  IN1 w0.089: 187.63,70.91 187.63,70.73 187.68,70.68 187.68,64.28 187.98,63.99 187.98,62.49 188.03,62.44 v2(188.21,62.44)
  IN1 w0.109: v2(199.41,92.03) 199.81,92.03 199.93,92.15 199.93,92.32 199.81,92.44 199.56,92.44 199.54,92.46 199.11,92.46 198.98,92.34 198.98,91.2 198.01,90.23 197.31,90.23 195.9,88.82 194.39,88.82 194,88.43 192.95,88.43 191.54,87.02 191.54,85.95 187.63,82.04 187.63,70.91
PEG_CRX_GTX_P15: length 40.5
  TOP w0.089: v2(189,62.44) 189.32,62.11 CPU1.E25
  TOP w0.102: CC32.1 201.61,91.42 201.7,91.51 201.7,91.83 201.17,92.36 200.78,92.36 v2(200.5,92.09)
  IN1 w0.089: 188.04,70.91 188.04,70.82 188.08,70.78 188.08,70.53 188.55,70.06 188.55,66.16 188,65.62 188,64.77 188.32,64.45 188.32,63.23 189,62.56 v2(189,62.44)
  IN1 w0.109: 188.04,70.91 188.04,81.87 194.55,88.37 196.04,88.37 197.41,89.75 198.12,89.75 198.78,90.41 199.41,90.41 200.8,91.79 200.8,91.98 200.69,92.09 v2(200.5,92.09)
PEG_CTX_C_GRX_N0: length 3.2
  TOP w0.102: CC44.1 176.42,77.33 176.42,77.66 176.86,78.1 176.86,78.43 176.6,78.69 176.6,78.83 176.75,78.97 JMXM1.176
PEG_CTX_C_GRX_N1: length 3.3
  TOP w0.102: JMXM1.170 178.25,78.97 178.1,78.83 178.1,78.67 178.54,78.23 178.54,77.97 178.2,77.63 178.2,77.33 CC45.1
PEG_CTX_C_GRX_N2: length 3.1
  TOP w0.102: JMXM1.164 179.75,78.85 179.6,78.71 179.6,78.18 v4(179.82,77.96) 179.98,77.81 179.98,77.33 CC53.1
PEG_CTX_C_GRX_N3: length 3.2
  TOP w0.102: JMXM1.156 183.75,78.95 183.6,78.81 183.6,78.59 183.25,78.24 183.25,78.14 v4(183.43,77.96) 183.54,77.85 183.54,77.38 CC73.1
PEG_CTX_C_GRX_N4: length 4.8
  TOP w0.102: JMXM1.150 185.24,78.85 185.1,78.71 185.1,76.85 185.06,76.8 v4(185.06,76.37) 185.06,75.55 CC46.1
PEG_CTX_C_GRX_N5: length 3.2
  TOP w0.102: JMXM1.144 186.75,79.03 186.6,78.89 186.6,78.59 186.24,78.23 186.24,78.1 v4(186.37,77.96) 186.52,77.82 186.52,77.39 CC74.1
PEG_CTX_C_GRX_N6: length 4.8
  TOP w0.102: CC47.1 188.3,75.55 v4(188.3,76.42) 188.3,77.08 188.1,77.28 188.1,78.71 188.24,78.85 JMXM1.138
PEG_CTX_C_GRX_N7: length 3.1
  TOP w0.102: CC56.1 189.69,77.39 189.69,77.82 v4(189.54,77.97) 189.35,78.16 189.35,78.26 189.6,78.52 189.6,78.85 189.75,78.99 JMXM1.132
PEG_CTX_C_GRX_N8: length 4.7
  TOP w0.102: CC75.1 191.01,75.57 191.01,76.16 191.09,76.24 v4(191.09,77.87) 191.09,78.79 191.24,78.95 JMXM1.126
PEG_CTX_C_GRX_N9: length 3.1
  TOP w0.102: JMXM1.120 192.75,79.01 192.6,78.87 192.6,78.62 192.87,78.35 192.87,78.05 192.54,77.72 192.54,77.39 CC48.1
PEG_CTX_C_GRX_N10: length 5
  TOP w0.102: CC59.1 193.88,75.55 193.88,77.8 v4(194.06,77.98) 194.26,78.18 194.26,78.56 194.1,78.72 194.1,78.82 194.25,78.97 JMXM1.114
PEG_CTX_C_GRX_N11: length 3.1
  TOP w0.102: CC76.1 195.18,77.37 195.18,77.85 v4(195.35,78.02) 195.56,78.23 195.56,78.87 195.75,79.05 JMXM1.108
PEG_CTX_C_GRX_N12: length 3.1
  TOP w0.102: JMXM1.102 197.25,78.97 197.1,78.83 197.1,78.69 197.31,78.48 197.31,78.15 v4(197.14,77.98) 196.93,77.77 196.93,77.4 CC49.1
PEG_CTX_C_GRX_N13: length 3.1
  TOP w0.102: JMXM1.96 198.75,78.97 198.57,78.8 198.57,78.62 198.34,78.39 198.34,78.21 v4(198.55,78) 198.71,77.84 198.71,77.4 CC62.1
PEG_CTX_C_GRX_N14: length 3
  TOP w0.102: CC77.1 200.49,77.4 200.49,77.87 200.1,78.26 200.1,78.95 200.25,79.1 JMXM1.90
PEG_CTX_C_GRX_N15: length 3.2
  TOP w0.102: CC50.1 202.26,77.41 202.26,77.8 201.6,78.46 201.6,78.7 201.75,78.84 JMXM1.84
PEG_CTX_C_GRX_P0: length 3.2
  TOP w0.102: JMXM1.178 176.25,79 176.39,78.86 176.39,78.6 176.65,78.34 176.65,78.19 v4(176.41,77.95) 176.21,77.75 176.21,77.33 CC67.1
PEG_CTX_C_GRX_P1: length 3.3
  TOP w0.102: CC68.1 177.98,77.33 177.98,77.72 v4(178.17,77.91) 178.33,78.06 178.33,78.14 177.89,78.58 177.89,78.8 177.75,78.95 JMXM1.172
PEG_CTX_C_GRX_P2: length 3.1
  TOP w0.102: JMXM1.166 179.25,78.85 179.39,78.71 179.39,78.09 179.76,77.72 179.76,77.33 CC51.1
PEG_CTX_C_GRX_P3: length 3.2
  TOP w0.102: CC52.1 183.33,77.4 183.33,77.76 183.04,78.05 183.04,78.33 183.39,78.68 183.39,78.81 183.24,78.96 JMXM1.158
PEG_CTX_C_GRX_P4: length 4.8
  TOP w0.102: JMXM1.152 184.75,78.85 184.89,78.71 v4(184.89,77.9) 184.89,76.94 184.84,76.89 184.84,75.55 CC69.1
PEG_CTX_C_GRX_P5: length 3.2
  TOP w0.102: JMXM1.146 186.24,79.05 186.39,78.91 186.39,78.68 186.02,78.32 186.02,78.01 186.3,77.73 186.3,77.39 CC54.1
PEG_CTX_C_GRX_P6: length 4.8
  TOP w0.102: JMXM1.140 187.75,78.85 187.89,78.71 v4(187.89,77.69) 187.89,77.19 188.08,76.99 188.08,75.55 CC55.1
PEG_CTX_C_GRX_P7: length 3.1
  TOP w0.102: JMXM1.134 189.24,79 189.39,78.86 189.39,78.61 189.13,78.35 189.13,78.07 189.48,77.73 189.48,77.39 CC70.1
PEG_CTX_C_GRX_P8: length 4.7
  TOP w0.102: CC57.1 190.8,75.66 190.8,76.25 190.87,76.32 190.87,78.85 190.75,78.98 JMXM1.128
PEG_CTX_C_GRX_P9: length 3.1
  TOP w0.102: JMXM1.122 192.25,79.05 192.38,78.91 192.38,78.53 192.65,78.26 192.65,78.14 v4(192.48,77.97) 192.33,77.81 192.33,77.39 CC58.1
PEG_CTX_C_GRX_P10: length 5
  TOP w0.102: JMXM1.116 193.75,78.97 193.88,78.84 193.88,78.63 194.05,78.47 194.05,78.27 193.67,77.89 193.67,75.55 CC71.1
PEG_CTX_C_GRX_P11: length 3
  TOP w0.102: CC60.1 194.96,77.41 194.96,77.94 195.34,78.32 195.34,78.91 195.25,79.01 JMXM1.110
PEG_CTX_C_GRX_P12: length 3.1
  TOP w0.102: JMXM1.104 196.75,78.95 196.88,78.81 196.88,78.6 197.1,78.39 197.1,78.24 196.72,77.86 196.72,77.4 CC61.1
PEG_CTX_C_GRX_P13: length 3.1
  TOP w0.102: CC72.1 198.49,77.4 198.49,77.75 198.12,78.13 198.12,78.48 198.35,78.71 198.35,78.86 198.25,78.97 JMXM1.98
PEG_CTX_C_GRX_P14: length 3
  TOP w0.102: CC63.1 200.27,77.4 200.27,77.78 v4(200.07,77.98) 199.88,78.17 199.88,78.93 199.75,79.07 JMXM1.92
PEG_CTX_C_GRX_P15: length 3.2
  TOP w0.102: JMXM1.86 201.25,78.83 201.38,78.7 201.38,78.37 v4(201.75,78.01) 202.05,77.71 202.05,77.4 CC64.1
PEG_CTX_GRX_N0: length 18.4
  TOP w0.089: CPU1.B10 177.43,63.91 177.35,63.91 177.28,63.98 177.28,65.09 176.95,65.42 176.95,68.49 v4(176.21,69.23) 175.96,69.48 175.19,69.48 175.01,69.3 175.01,68.79 v2(175.02,68.78)
  TOP w0.102: v2(177.37,75.42) 177,75.05 176.75,75.05 176.33,75.48 176.33,75.9 176.51,76.08 CC44.2
  BOTTOM w0.089: 174.98,70.91 174.98,70.89 174.98,70.88 174.98,70.82 174.99,70.81 174.99,70.73 175.02,70.7 v2(175.02,68.78)
  BOTTOM w0.102: v2(177.37,75.42) 177.34,75.45 176.57,75.45 174.98,73.85 174.98,70.91
PEG_CTX_GRX_N1: length 18.5
  TOP w0.089: CPU1.B11 178.24,64.19 178.05,64.19 177.87,64.37 177.87,65.22 177.93,65.27 177.93,65.76 177.35,66.34 v4(177.35,66.54) 177.35,69.43 176.21,70.57 175.95,70.82 175.7,70.82 175.6,70.73 175.6,70.6 v2(175.76,70.44)
  TOP w0.102: v2(178.56,75.47) 178.33,75.24 178.2,75.24 178.11,75.34 178.11,76 178.18,76.08 CC45.2
  BOTTOM w0.102: v2(175.76,70.44) 175.8,70.44 176.03,70.67 176.03,70.67 176.4,71.04 176.4,72.2 176.4,72.58 177.44,73.62 179.06,73.62 179.41,73.96 179.41,74.8 179.29,74.91 179.29,75.28 179.1,75.47 v2(178.56,75.47)
PEG_CTX_GRX_N2: length 28.8
  TOP w0.089: v2(178.2,67.55) 178.4,67.34 178.68,67.34 178.93,67.1 178.93,65.94 178.75,65.77 178.75,65.1 178.87,64.99 178.87,63.87 178.96,63.78 179.05,63.78 179.15,63.88 CPU1.B12
  TOP w0.102: v2(180.48,75.44) 180.18,75.13 180.04,75.13 179.88,75.28 179.88,75.96 180,76.08 CC53.2
  BOTTOM w0.089: 174.31,70.91 174.31,70.89 174.31,70.88 174.31,70.21 173.38,69.28 173.38,67.46 173.69,67.15 178.67,67.15 178.79,67.27 178.79,67.43 178.68,67.55 v2(178.2,67.55)
  BOTTOM w0.102: 174.31,70.91 174.31,74.05 176.34,76.07 180.67,76.07 180.95,75.79 180.95,75.39 180.79,75.23 180.69,75.23 v2(180.48,75.44)
PEG_CTX_GRX_N3: length 21
  TOP w0.089: v2(178.2,68.82) 178.2,68.88 178.44,69.12 178.53,69.12 178.78,68.88 178.78,67.64 179.27,67.15 v4(179.27,66.75) 179.27,65.83 179.55,65.55 179.55,65.17 179.44,65.05 179.44,64.37 179.64,64.17 179.84,64.17 CPU1.B13
  TOP w0.102: CC73.2 183.85,76.14 183.2,75.49 183.2,75.3 183.34,75.15 183.44,75.15 v2(183.7,75.42)
  BOTTOM w0.089: 176.81,70.91 176.81,69.34 177.11,69.04 177.97,69.04 v2(178.2,68.82)
  BOTTOM w0.102: v2(183.7,75.42) 182.63,75.42 180.87,73.65 179.68,73.65 179.23,73.21 177.63,73.21 176.81,72.39 176.81,70.91
PEG_CTX_GRX_N4: length 20.6
  TOP w0.089: 178.89,70.91 179.98,69.81 v4(179.98,67.84) 179.98,67.38 180.16,67.21 180.16,65.96 180.31,65.8 180.31,65.16 180.44,65.03 180.44,63.91 180.53,63.82 180.65,63.82 180.73,63.89 CPU1.B14
  TOP w0.102: CC46.2 185.15,74.06 185.15,73.55 184.72,73.11 183.75,73.11 v2(183.7,73.05) ; v2(178.2,71.36) 178.2,71.24 178.36,71.08 178.72,71.08 178.89,70.91
  BOTTOM w0.102: v2(183.7,73.05) 183.33,73.42 181.82,73.42 181.21,72.82 180.03,72.82 179.58,72.37 177.98,72.37 177.65,72.04 177.65,71.13 177.86,70.92 178.3,70.92 178.38,71 178.38,71.18 v2(178.2,71.36)
PEG_CTX_GRX_N5: length 21.1
  TOP w0.089: CPU1.B15 181.35,64.23 181.23,64.23 181.01,64.45 181.01,65.07 181.14,65.2 181.14,66.12 181.03,66.24 180.8,66.24 180.72,66.16 v2(180.72,65.97)
  TOP w0.102: v2(186.05,74.91) 186.19,75.05 186.43,75.05 186.72,75.34 186.72,75.69 186.61,75.79 186.61,75.9 CC74.2
  BOTTOM w0.089: 179.24,70.91 179.24,70.88 179.25,70.88 179.25,67.02 180.09,66.17 180.52,66.17 v2(180.72,65.97)
  BOTTOM w0.102: 179.24,70.91 179.24,71.45 180.19,72.41 183.75,72.41 185.16,73.82 186.17,73.82 186.55,74.19 186.55,75.02 186.45,75.12 186.26,75.12 v2(186.05,74.91)
PEG_CTX_GRX_N6: length 20.1
  TOP w0.089: CPU1.B16 182.3,63.82 182.21,63.72 182.09,63.72 182,63.81 182,65 181.91,65.09 181.91,66.46 181.43,66.94 181.43,68.01 181.15,68.29 181,68.29 v2(180.73,68.56)
  TOP w0.102: CC47.2 188.39,74.06 188.39,73.57 v4(187.96,73.13) 187.63,72.8 186.99,72.8 v2(186.94,72.75)
  BOTTOM w0.089: 180.32,70.91 180.32,70.89 180.32,70.88 180.32,70.82 180.31,70.81 180.31,68.27 180.4,68.18 180.81,68.18 180.88,68.24 180.88,68.42 v2(180.73,68.56)
  BOTTOM w0.102: 180.32,70.91 180.32,71.25 180.32,71.25 180.32,71.35 180.54,71.57 184.23,71.57 185.59,72.93 186.44,72.93 186.52,73.01 186.64,73.01 186.9,72.75 v2(186.94,72.75)
PEG_CTX_GRX_N7: length 21.2
  TOP w0.089: v2(180.73,69.83) 180.73,70.04 180.81,70.12 181.21,70.12 181.75,69.57 v4(181.75,68.9) 181.75,67.96 182.24,67.46 182.24,66.02 182.81,65.44 182.81,65.24 182.6,65.02 182.6,64.38 182.77,64.21 182.95,64.21 CPU1.B17
  TOP w0.102: CC56.2 190.03,75.91 189.91,75.79 189.91,75.33 189.65,75.08 189.65,74.86 v2(189.66,74.85)
  BOTTOM w0.089: 180.95,70.05 v2(180.73,69.83)
  BOTTOM w0.102: 180.95,70.05 181.4,70.05 182.15,70.8 184.68,70.8 185.37,71.49 187.04,71.49 187.88,72.32 187.88,73.86 188.86,74.85 v2(189.66,74.85)
PEG_CTX_GRX_N8: length 19
  TOP w0.089: v2(183.12,66.05) 183.12,66.22 183.21,66.31 183.47,66.31 183.56,66.22 183.56,65.83 183.27,65.54 183.27,65.03 183.37,64.93 183.37,63.76 183.59,63.54 183.75,63.54 CPU1.C18
  TOP w0.102: v2(189.47,73.09) 190.19,73.09 190.57,73.46 190.83,73.73 190.83,73.77 190.98,73.92 190.98,74.05 CC75.2
  IN4 w0.089: v2(183.12,66.05) 183.33,66.25 183.64,66.25 184.13,66.74 184.13,69.34 184.51,69.73 184.51,70.9 184.53,70.91
  IN4 w0.109: 184.53,70.91 184.53,71.85 186.41,73.74 188.21,73.74 188.64,73.31 189.25,73.31 v2(189.47,73.09)
PEG_CTX_GRX_N9: length 26
  TOP w0.089: v2(183.2,68.6) 183.42,68.38 183.65,68.38 184.48,67.56 v4(184.48,66.8) 184.48,65.1 184.36,64.99 184.36,64.53 184.47,64.42 184.6,64.42 184.67,64.48 CPU1.A19
  TOP w0.102: CC48.2 192.64,75.9 192.64,75.36 v2(192.16,74.88)
  IN4 w0.089: v2(183.2,68.6) 183.34,68.46 183.34,68.31 183.27,68.23 182.56,68.23 182.56,70.88 182.57,70.89 182.57,70.91
  IN4 w0.109: 182.57,70.91 182.57,75.29 183.87,76.6 189.91,76.6 191.23,75.28 191.76,75.28 v2(192.16,74.88)
PEG_CTX_GRX_N10: length 28.6
  TOP w0.089: v2(183.17,69.78) 183.61,70.21 183.91,70.21 184.82,69.3 184.82,65 184.95,64.88 184.95,63.73 185.15,63.53 185.33,63.53 CPU1.C20
  TOP w0.102: CC59.2 194.2,74.28 194.2,73.43 193.88,73.11 192.44,73.11 191.92,72.6 v4(191.62,72.6) 190.92,72.6 v2(190.87,72.55)
  IN4 w0.089: 183.84,70.91 183.84,70.89 183.83,70.88 183.83,70.23 183.59,69.99 183.39,69.99 v2(183.17,69.78)
  IN4 w0.109: 183.84,70.91 183.84,72.22 184.54,72.92 184.54,75.11 185.39,75.97 189.59,75.97 190.1,75.46 190.1,72.98 190.31,72.77 190.65,72.77 v2(190.87,72.55)
PEG_CTX_GRX_N11: length 23.2
  TOP w0.089: CPU1.A21 186.24,64.51 186.15,64.42 186.03,64.42 185.95,64.5 185.95,64.93 186.22,65.2 186.22,66.21 185.9,66.53 185.75,66.53 185.68,66.61 v2(185.68,66.76)
  TOP w0.102: CC76.2 195.25,75.9 195.25,75.63 195.52,75.36 195.52,74.83 195.3,74.61 195,74.61 v2(194.88,74.48)
  IN4 w0.089: 185.16,70.91 185.16,70.89 185.14,70.88 185.14,70.82 185.13,70.81 185.13,69.67 184.85,69.39 184.85,66.49 184.95,66.39 185.69,66.39 185.78,66.48 185.78,66.66 v2(185.68,66.76)
  IN4 w0.109: v2(194.88,74.48) 194.51,74.85 194.19,74.85 191.24,71.9 187.42,71.9 186.96,71.44 185.3,71.44 185.16,71.3 185.16,70.91
PEG_CTX_GRX_N12: length 23
  TOP w0.089: v2(185.58,67.98) 185.58,68.1 185.75,68.27 186.11,68.27 186.26,68.13 186.26,66.86 186.42,66.7 186.42,65 186.52,64.9 186.52,63.75 186.7,63.57 186.87,63.57 CPU1.C22
  TOP w0.102: v2(196.62,74.81) 197.03,75.22 197.03,75.91 CC49.2
  IN4 w0.089: 192.79,70.75 192.78,70.74 192.77,70.74 192.75,70.72 192.67,70.64 187.89,70.64 186.22,68.98 186.22,68.43 185.98,68.19 185.8,68.19 v2(185.58,67.98)
  IN4 w0.109: 192.79,70.75 193.41,71.37 193.78,71.37 194.61,72.19 194.7,72.28 195.17,72.28 196.16,73.27 196.16,74.92 196.26,75.03 196.4,75.03 v2(196.62,74.81)
PEG_CTX_GRX_N13: length 27
  TOP w0.089: v2(185.58,70.52) 185.58,70.37 185.72,70.24 186.63,70.24 187.02,69.85 187.02,67.45 187.11,67.35 187.11,66.15 187.6,65.66 187.6,64.95 187.52,64.86 187.52,64.68 187.56,64.64 187.74,64.64 CPU1.A23
  TOP w0.102: v2(199.63,75.19) 199.22,75.6 199.16,75.6 198.98,75.78 198.98,76.08 CC62.2
  IN4 w0.089: v2(185.58,70.52) 185.69,70.42 186.54,70.42 187.03,70.91
  IN4 w0.109: 187.03,70.91 187.61,71.48 191.47,71.48 193.31,73.32 194.9,73.32 195.31,73.74 195.31,75.32 196.1,76.12 199.37,76.12 199.63,75.86 v2(199.63,75.19)
PEG_CTX_GRX_N14: length 26.1
  TOP w0.089: CPU1.C24 188.53,63.48 188.26,63.48 188.1,63.64 188.1,64.89 188.02,64.96 188.02,65.56 187.38,66.2 187.38,69.35 187.6,69.57 188.08,69.57 v2(188.12,69.6)
  TOP w0.102: CC77.2 200.59,75.92 200.59,75.09 198.84,73.34 198.73,73.34 v2(198.48,73.09)
  IN4 w0.089: v2(188.12,69.6) 188.12,69.3 188.06,69.24 187.78,69.24 187.59,69.43 187.59,69.69 188.02,70.12 192.39,70.12 193.02,69.48 193.61,69.48 194.82,70.7 194.87,70.74 194.88,70.74 194.89,70.75
  IN4 w0.109: 194.89,70.75 197.6,73.46 198.43,73.46 198.53,73.36 198.53,73.14 v2(198.48,73.09)
PEG_CTX_GRX_N15: length 25.7
  TOP w0.089: CPU1.A25 189.39,64.5 189.31,64.42 189.15,64.42 189.1,64.47 189.1,65.02 189.33,65.24 189.33,67.23 188.88,67.67 v2(188.12,67.67)
  TOP w0.102: CC50.2 202.24,75.79 202.24,75.66 201.9,75.32 201.72,75.32 199.8,73.4 199.8,71.96 199.55,71.71 198.44,71.71 198.26,71.53 198.26,71.39 v2(198.44,71.22)
  IN4 w0.089: 193.27,67.9 193.26,67.9 193.24,67.89 193.18,67.89 193.16,67.87 193.12,67.83 193.11,67.83 193.1,67.84 192.79,67.84 192.56,68.07 191.62,68.07 190.5,66.94 189.66,66.94 188.93,67.67 v2(188.12,67.67)
  IN4 w0.109: 193.27,67.9 193.46,67.9 196.09,70.54 197.4,71.84 198.16,71.84 198.34,71.66 198.34,71.32 v2(198.44,71.22)
PEG_CTX_GRX_P0: length 18.4
  TOP w0.089: CPU1.C10 177.58,63.59 177.46,63.71 177.26,63.71 177.07,63.9 177.07,65.01 176.74,65.34 v4(176.74,68.07) 176.74,68.41 175.88,69.27 175.27,69.27 175.21,69.21 175.21,69.11 175.54,68.78 v2(175.61,68.78)
  TOP w0.102: CC67.2 176.11,75.84 176.11,75.39 176.66,74.83 v2(177.37,74.83)
  BOTTOM w0.089: v2(175.61,68.78) 175.56,68.78 175.23,69.11 175.23,70.78 175.19,70.82 175.19,70.91
  BOTTOM w0.102: v2(177.37,74.83) 176.97,75.23 176.66,75.23 175.19,73.76 175.19,70.91
PEG_CTX_GRX_P1: length 18.5
  TOP w0.089: CPU1.A11 178.37,64.49 178.27,64.4 178.13,64.4 178.08,64.45 178.08,65.14 178.13,65.19 178.13,65.86 177.56,66.43 v4(177.56,69.18) 177.56,69.51 176.16,70.91
  TOP w0.102: CC68.2 177.89,75.84 177.89,75.25 178.11,75.03 178.41,75.03 v2(178.56,74.88) ; 176.16,70.91 176.05,71.01 175.8,71.01 175.71,71.1 v2(175.71,71.33)
  BOTTOM w0.102: v2(178.56,74.88) 178.66,74.99 178.66,74.99 178.93,75.25 179.01,75.25 179.07,75.19 179.07,74.82 179.19,74.71 179.19,74.05 178.97,73.83 177.35,73.83 176.18,72.67 176.18,72.11 176.18,72.11 176.18,71.13 175.89,70.84 175.72,70.84 175.62,70.94 175.62,71.24 v2(175.71,71.33)
PEG_CTX_GRX_P2: length 28.8
  TOP w0.089: CPU1.C12 178.99,63.58 178.87,63.58 178.66,63.79 178.66,64.91 178.55,65.02 178.55,65.85 178.73,66.03 178.73,67.01 178.6,67.14 178.34,67.14 178.21,67.01 v2(178.21,66.78)
  TOP w0.102: CC51.2 179.67,75.84 179.67,75.19 179.95,74.91 180.43,74.91 180.49,74.86 v2(180.49,74.85)
  BOTTOM w0.089: v2(178.21,66.78) 178.05,66.94 173.61,66.94 173.18,67.38 173.18,69.36 174.1,70.29 174.1,70.88 174.1,70.89 174.1,70.91
  BOTTOM w0.102: v2(180.49,74.85) 180.65,75.01 180.88,75.01 181.17,75.3 181.17,75.88 180.76,76.29 176.25,76.29 174.1,74.14 174.1,70.91
PEG_CTX_GRX_P3: length 20.9
  TOP w0.089: CPU1.A13 179.94,64.43 179.88,64.37 179.73,64.37 179.64,64.46 179.64,64.97 179.76,65.09 179.76,65.63 179.47,65.91 179.47,67.23 178.98,67.73 v4(178.98,68.7) 178.98,68.96 v2(178.41,69.53)
  TOP w0.102: CC52.2 182.98,75.21 183.25,74.94 183.6,74.94 v2(183.7,74.83)
  BOTTOM w0.089: v2(178.41,69.53) 178.49,69.45 178.49,69.26 178.41,69.18 178.12,69.18 178.05,69.25 177.19,69.25 177.01,69.43 177.01,70.81 177.02,70.82 177.02,70.88 177.02,70.89 177.02,70.91
  BOTTOM w0.102: v2(183.7,74.83) 183.33,75.2 182.72,75.2 180.95,73.44 179.77,73.44 179.32,72.99 177.72,72.99 177.02,72.3 177.02,70.91
PEG_CTX_GRX_P4: length 20.6
  TOP w0.089: CPU1.C14 180.73,63.53 180.64,63.61 180.44,63.61 180.24,63.82 180.24,64.94 180.11,65.07 180.11,65.72 179.96,65.87 179.96,67.12 179.78,67.3 179.78,69.72 v4(179.43,70.07) 178.81,70.7 178.8,70.7 178.75,70.74 178.75,70.74 178.73,70.75
  TOP w0.102: v2(178.21,70.53) 178.21,70.76 178.31,70.86 178.63,70.86 178.73,70.75 ; v2(183.7,73.64) 184.01,73.32 184.63,73.32 184.94,73.64 184.94,74.17 184.81,74.3 CC69.2
  BOTTOM w0.102: v2(178.21,70.53) 178.03,70.71 177.77,70.71 177.43,71.04 177.43,72.13 177.89,72.59 179.49,72.59 179.94,73.03 181.12,73.03 181.73,73.64 v2(183.7,73.64)
PEG_CTX_GRX_P5: length 21.1
  TOP w0.089: CPU1.A15 181.52,64.51 181.44,64.43 181.31,64.43 181.21,64.53 181.21,64.99 181.34,65.11 181.34,66.21 181.11,66.44 180.89,66.44 v2(180.72,66.61)
  TOP w0.102: CC54.2 186.36,76.14 186.4,76.1 186.4,75.7 186.5,75.6 186.5,75.43 186.34,75.27 186.25,75.27 186.05,75.47 v2(186.05,75.49)
  BOTTOM w0.089: 179.46,70.91 179.46,70.88 179.45,70.88 179.45,67.1 180.12,66.43 180.54,66.43 v2(180.72,66.61)
  BOTTOM w0.102: v2(186.05,75.49) 186.21,75.33 186.54,75.33 186.76,75.11 186.76,74.1 186.26,73.6 185.25,73.6 183.84,72.19 180.28,72.19 179.46,71.36 179.46,70.91
PEG_CTX_GRX_P6: length 20.1
  TOP w0.089: CPU1.C16 182.2,63.52 182.01,63.52 181.8,63.73 181.8,64.91 181.71,65.01 181.71,66.38 181.23,66.85 v4(181.23,67.36) 181.23,67.92 181.07,68.09 180.75,68.09 180.59,67.93 v2(180.59,67.8)
  TOP w0.102: v2(186.94,73.33) 187.08,73.19 187.25,73.02 187.54,73.02 188.18,73.66 188.18,74.22 188.1,74.3 CC55.2
  BOTTOM w0.089: 180.11,70.91 180.11,68.19 180.32,67.98 180.41,67.98 v2(180.59,67.8)
  BOTTOM w0.102: 180.11,70.91 180.11,71.16 180.1,71.16 180.1,71.44 180.45,71.78 184.14,71.78 185.5,73.15 186.35,73.15 186.43,73.22 186.83,73.22 v2(186.94,73.33)
PEG_CTX_GRX_P7: length 21.2
  TOP w0.089: v2(180.73,70.48) 180.89,70.32 181.29,70.32 181.95,69.66 181.95,68.04 182.45,67.55 v4(182.45,66.97) 182.45,66.1 183.02,65.53 183.02,65.16 182.8,64.94 182.8,64.46 182.85,64.41 183.02,64.41 183.09,64.48 CPU1.A17
  TOP w0.102: CC70.2 189.48,76.14 189.57,76.05 189.57,75.81 189.69,75.69 189.69,75.46 189.64,75.41 v2(189.39,75.41)
  BOTTOM w0.102: v2(180.73,70.48) 180.94,70.27 181.31,70.27 182.06,71.01 184.59,71.01 185.28,71.7 186.95,71.7 187.66,72.41 187.66,73.95 188.77,75.06 189.3,75.06 189.39,75.15 v2(189.39,75.41)
PEG_CTX_GRX_P8: length 19
  TOP w0.089: v2(183.12,66.69) 183.29,66.52 183.55,66.52 183.76,66.31 183.76,65.75 183.48,65.46 183.48,65.11 183.58,65.01 183.58,63.84 183.68,63.74 183.74,63.74 183.88,63.88 CPU1.B18
  TOP w0.102: CC57.2 190.49,74.37 190.77,74.09 190.77,74.01 190.62,73.86 190.62,73.82 190.35,73.55 190.1,73.31 189.83,73.31 189.64,73.5 189.52,73.5 189.47,73.55 v2(189.47,73.67)
  IN4 w0.089: 184.31,70.91 184.31,70.89 184.32,70.88 184.32,69.81 183.94,69.43 183.94,66.82 183.56,66.45 183.36,66.45 v2(183.12,66.69)
  IN4 w0.109: 184.31,70.91 184.31,71.94 186.32,73.96 188.3,73.96 188.73,73.53 189.32,73.53 v2(189.47,73.67)
PEG_CTX_GRX_P9: length 26
  TOP w0.089: v2(183.14,67.87) 183.14,68.04 183.28,68.18 183.57,68.18 v4(183.82,67.93) 184.28,67.48 184.28,65.19 184.16,65.07 184.16,64.44 184.39,64.21 184.52,64.21 CPU1.B19
  TOP w0.102: CC58.2 192.2,76.35 192.35,76.35 192.42,76.27 192.42,75.55 192.37,75.49 v2(192.18,75.49)
  IN4 w0.089: 182.35,70.91 182.35,70.89 182.36,70.88 182.36,68.15 182.47,68.04 182.97,68.04 v2(183.14,67.87)
  IN4 w0.109: v2(192.18,75.49) 191.32,75.49 190,76.82 183.79,76.82 182.35,75.38 182.35,70.91
PEG_CTX_GRX_P10: length 28.7
  TOP w0.089: v2(183.17,70.42) 183.99,70.42 185.02,69.39 185.02,65.09 185.15,64.96 185.15,63.82 185.23,63.74 185.36,63.74 185.45,63.83 CPU1.B20
  TOP w0.102: v2(190.87,73.13) 191.18,72.81 191.84,72.81 192.35,73.32 v4(192.82,73.32) 193.79,73.32 193.98,73.52 193.98,73.65 193.74,73.89 CC71.2
  IN4 w0.089: v2(183.17,70.42) 183.4,70.19 183.5,70.19 183.63,70.31 183.63,70.87 183.62,70.88 183.62,70.91
  IN4 w0.109: v2(190.87,73.13) 190.72,72.98 190.4,72.98 190.31,73.07 190.31,75.55 189.68,76.18 185.3,76.18 184.32,75.2 184.32,73.01 183.62,72.31 183.62,70.91
PEG_CTX_GRX_P11: length 23.2
  TOP w0.089: CPU1.B21 186.09,64.22 185.95,64.22 185.75,64.42 185.75,65.01 186.02,65.28 186.02,66.12 185.82,66.33 185.65,66.33 185.58,66.26 v2(185.58,66.02)
  TOP w0.102: CC60.2 194.94,76.14 195.03,76.05 195.03,75.54 195.31,75.27 195.31,74.92 195.22,74.82 195.12,74.82 v2(194.88,75.06)
  IN4 w0.089: v2(185.58,66.02) 185.41,66.19 184.87,66.19 184.66,66.41 184.66,69.47 184.94,69.75 184.94,70.91
  IN4 w0.109: 184.94,70.91 184.94,71.39 185.21,71.66 186.87,71.66 187.33,72.12 191.15,72.12 194.1,75.06 v2(194.88,75.06)
PEG_CTX_GRX_P12: length 23
  TOP w0.089: CPU1.B22 187.03,63.85 186.95,63.77 186.78,63.77 186.73,63.83 186.73,64.99 186.62,65.09 186.62,66.78 186.46,66.94 186.46,68.21 186.2,68.47 185.73,68.47 v2(185.58,68.61)
  TOP w0.102: v2(196.62,75.39) 196.72,75.39 196.81,75.48 196.81,76.29 196.71,76.39 196.61,76.39 CC61.2
  IN4 w0.089: v2(185.58,68.61) 185.81,68.39 185.9,68.39 186.03,68.52 186.03,69.06 187.8,70.84 192.59,70.84 192.63,70.88 192.63,70.9 192.64,70.91
  IN4 w0.109: 192.64,70.91 193.32,71.58 193.69,71.58 194.52,72.41 194.52,72.41 194.61,72.5 195.08,72.5 195.94,73.36 195.94,75.01 196.17,75.24 196.47,75.24 v2(196.62,75.39)
PEG_CTX_GRX_P13: length 27.1
  TOP w0.089: v2(185.58,69.88) 185.74,70.04 186.54,70.04 186.81,69.76 186.81,67.36 186.91,67.27 186.91,66.06 187.4,65.57 187.4,65.03 187.32,64.95 187.32,64.59 187.5,64.41 187.5,64.38 CPU1.B23
  TOP w0.102: v2(198.97,75.19) 198.99,75.21 198.99,75.46 198.75,75.7 198.59,75.7 198.16,76.13 CC72.2
  IN4 w0.089: 187.34,70.91 186.65,70.22 185.92,70.22 185.76,70.06 185.76,70.06 v2(185.58,69.88)
  IN4 w0.109: 187.34,70.91 187.7,71.27 191.56,71.27 193.4,73.11 194.99,73.11 195.53,73.65 195.53,75.23 196.19,75.9 199.28,75.9 199.41,75.77 199.41,75.63 v2(198.97,75.19)
PEG_CTX_GRX_P14: length 26.1
  TOP w0.089: v2(188.14,68.85) 188.12,68.87 188.12,69.09 187.85,69.36 187.68,69.36 187.58,69.27 187.58,66.29 188.22,65.65 188.22,65.05 188.3,64.97 188.3,63.72 188.34,63.69 188.52,63.69 188.64,63.8 188.64,64.03 CPU1.B24
  TOP w0.102: v2(198.3,73.88) 198.3,73.83 198.58,73.55 198.75,73.55 200.37,75.18 200.37,75.79 200.01,76.15 CC63.2
  IN4 w0.089: v2(188.14,68.85) 188.14,68.93 188.03,69.04 187.7,69.04 187.39,69.35 187.39,69.77 187.94,70.31 192.47,70.31 193.11,69.68 193.53,69.68 194.73,70.88 194.73,70.9 194.74,70.91
  IN4 w0.109: v2(198.3,73.88) 198.1,73.68 197.51,73.68 194.74,70.91
PEG_CTX_GRX_P15: length 25.6
  TOP w0.089: CPU1.B25 189.23,64.22 189.07,64.22 188.9,64.39 188.9,65.1 189.12,65.33 189.12,67.14 188.79,67.47 188.58,67.47 188.34,67.23 v2(188.12,67.01)
  TOP w0.102: v2(197.81,71.19) 198.05,71.43 198.05,71.62 198.35,71.93 199.46,71.93 199.58,72.05 199.58,73.49 201.63,75.53 201.81,75.53 202.02,75.75 202.02,75.84 CC64.2
  IN4 w0.089: 193.27,67.69 193.26,67.68 193.24,67.68 193.2,67.63 193.03,67.63 193.02,67.64 192.71,67.64 192.48,67.87 191.71,67.87 190.58,66.75 189.58,66.75 188.84,67.48 188.59,67.48 v2(188.12,67.01)
  IN4 w0.109: v2(197.81,71.19) 198.12,71.51 198.12,71.57 198.07,71.62 197.49,71.62 196.25,70.38 193.55,67.69 193.27,67.69
PGOOD_3V_5V: length 7.7
  TOP w0.102: PU101.7 350.27,29.13 349.69,28.55 v2(349.07,28.55)
  BOTTOM w0.102: v2(349.07,28.55) 348.96,28.66 347.43,28.66 346.68,29.41 PR107.1 PR108.2 v1(346.68,32.41)
PLTRST_CPU#: length 176.6
  TOP w0.089: 137.21,117.25 136.94,116.97 134.99,116.97 134.62,116.61 134.62,116.61 134.43,116.42 UH1.AK2 ; v2(196.43,22.04) 196.05,22.42 196.05,23.77 195.87,23.95 195.87,24.22 195.93,24.28 195.93,25.07 CPU1.BP35
  TOP w0.102: 137.21,117.25 137.42,117.46 v1(137.75,117.46) 138.82,117.46 v2(138.98,117.3)
  IN3 w0.127: v2(197.79,77.85) 197.12,78.51 197.12,83.62 195.09,85.66 195.09,89.4 196.59,90.9 196.59,94.58 196.59,95.07 191.66,100 191.66,102.22 190.81,103.07 v2(190.2,103.07)
  IN4 w0.089: v2(196.43,22.04) 196.19,22.28 196.19,23.13 191.18,28.15 190.31,28.15 190.05,28.42 190.05,29.47 190.06,29.48 190.06,29.78 189.62,30.22 188.7,30.22 187.89,31.03 186.3,31.03 185.79,31.54 185.79,42.08 184.26,43.62 184.26,45.15 184.12,45.29 184.12,45.6 184.45,45.93 184.45,58.87 183.9,59.42 183.9,63.3 182.49,64.71 182.43,64.71 181.74,65.4 181.74,70.91 ; 141.76,115.19 141.29,115.19 139.17,117.3 v2(138.98,117.3)
  IN4 w0.109: v2(197.79,77.85) 196.8,77.85 196.24,77.29 183.25,77.29 181.74,75.77 181.74,70.91 ; v2(190.2,103.07) 189.74,103.53 185.11,103.53 184.61,104.03 182.82,104.03 182.57,104.27 182.57,104.88 182.04,105.42 180.59,105.42 179.59,106.42 175.33,106.42 175.02,106.74 175.02,108.17 173.53,109.66 173.53,110.35 173.25,110.63 172.58,110.63 172.19,111.02 171.68,111.02 169.96,112.74 166.8,112.74 166.5,113.04 164.48,113.04 164.21,113.32 162.17,113.32 161.89,113.6 152.81,113.6 152.21,114.19 149.63,114.19 148.72,115.1 145.59,115.1 145.51,115.19 141.76,115.19
PLTRST_GPU#: length 196.3
  TOP w0.102: v2(236.17,71.9) 236.17,72.51 236.83,73.17 240.83,73.17 242.13,74.47 v2(242.13,76.38) ; 174.22,73.15 174.22,74.92 v2(174.2,74.95)
  IN4 w0.109: v2(174.2,74.95) 174.22,74.95 174.4,75.13 175.48,75.13 176.45,76.09 176.45,78.37 177.52,79.45 179.82,79.45 180.77,80.4 190.74,80.4 191.82,81.48 196.69,81.48 198.46,79.71 203.2,79.71 204.21,78.71 206.98,78.71 210.74,74.95 214.21,74.95 214.69,75.43 220.29,75.43 220.79,75.93 233.09,75.93 236.17,72.85 v2(236.17,71.9) ; v2(188,134.42) 188.67,133.75 198.32,133.75 198.65,133.43 212.18,133.43 213.16,132.45 215.74,132.45 215.94,132.25 217.16,132.25 217.75,131.67 218.55,131.67 218.93,132.04 225.03,132.04 225.78,132.8 231.01,132.8 239.27,124.54 239.27,122.18 238.65,121.56 238.65,118.75 239.15,118.24 239.73,118.24 240.1,117.87 240.1,117.04 239.62,116.57 239.62,115.01 239.98,114.65 239.98,112.14 238.74,110.89 238.74,107.78 v2(240.07,106.45)
  BOTTOM w0.102: v2(240.07,106.45) 239.46,105.84 239.46,103.25 241.02,101.69 241.02,100.85 242.33,99.55 242.33,99.52 244.85,97 244.85,96.74 245.05,96.55 245.05,96.12 243.07,94.15 243.07,91.73 242.33,90.99 242.33,89.75 240.92,88.33 240.92,78.56 v1(241.79,77.69) 242.13,77.35 v2(242.13,76.38) ; v2(188,134.42) 187.51,134.42 186.54,133.46 RH195.2
PLTRST_HDD#: length 177.4
  IN2 w0.127: v2(36.05,20.15) 35.44,19.54 34.98,19.54 34.59,19.94 34.59,21.19 30.28,25.49 30.28,31 27.84,33.45 24.69,33.45 24.39,33.75 24.39,36.47 24.13,36.72 24.13,46.01 22.9,47.24 22.9,51.6 25.71,54.4 25.71,61.99 28.47,64.75 54.89,64.75 56.86,62.78 75.74,62.78 83.76,70.8 83.76,79.1 91.2,86.54 91.2,97.49 97.4,103.69 97.4,109.4 97.9,109.9 97.9,112.17 101.78,116.05 104.3,116.05 104.95,116.7 v2(104.95,119.19)
  BOTTOM w0.102: v2(36.05,20.15) JSATA2.17 ; RH212.2 104.83,120.54 104.83,119.31 v2(104.95,119.19)
