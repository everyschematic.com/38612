# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_ALW_PCHRES: length 45.5
  TOP w0.508: RH296.1 108.38,124.26 v2(108.75,123.89)
  IN1 w0.508: v2(117.41,131.11) 113.1,131.11 111.83,129.85 v2(111.83,129.02)
  IN2 w0.508: v2(132.5,137.59) 132.5,136.89 131.78,136.16 126.28,136.16 125.86,135.74 122.04,135.74 v2(117.41,131.11) ; v2(108.75,123.89) 108.98,124.11 108.98,125.27 110.91,127.21 111.02,127.21 111.83,128.03 v2(111.83,129.02)
  BOTTOM w0.508: RH247.1 137.46,131.34 136.82,130.7 RH295.1 136.4,131.67 134.66,133.41 134.66,135.31 134.28,135.69 134.28,137.06 134.22,137.13 133.75,137.59 v2(132.5,137.59) ; RH250.1 112.08,128.78 v2(111.83,129.02) ; RH294.1 117.79,130.73 v2(117.41,131.11)
+1.8V_RUN: length 185.2
  IN2 w0.508: v2(196.02,7.19) 197.72,5.49 227.27,5.49 228.92,7.13 246.53,7.13 246.82,7.42 254.83,7.42 256.37,8.97 261.73,8.97 265.92,13.16 265.92,20.34 264.72,21.53 264.72,24.51 263.44,25.79 263.44,26.47 262.82,27.1 262.82,28.8 261.7,29.92 261.7,34.78 257.65,38.83 257.65,41.6 259.68,43.62 259.68,44.96 263.19,48.47 v2(263.86,48.47)
  IN3 w0.508: v2(263.86,48.47) 263.86,49 262.36,50.5 262.36,52.68 260.84,54.21 260.84,55.56 258.91,57.49 252.27,57.49 247.44,62.32 247.44,72.11 244.15,75.4 v2(244.15,76.51)
  BOTTOM w0.508: v2(196.02,7.19) 196.02,8.77 194.98,9.81 192.04,9.81 191.45,9.22 187.82,9.22 186.27,10.77 182.18,10.77 181.51,10.1 175.48,10.1 174.48,11.11 v1(174.48,12.85) 175.01,13.38 RH252.1 RH253.1
+1.8V_RUN_EDRAM: length 23.1
  TOP w0.203: CPU1.BM14 180.43,26.69 v2(180.1,26.36)
  TOP w0.508: CC190.1 180.76,11.6 179.87,11.6 179.42,12.05 179.42,12.66 179.82,13.05 179.82,13.35 v2(179.81,13.36)
  IN4 w0.508: v2(179.81,13.36) 180.09,13.63 180.09,15.83 180.78,16.52 180.78,23.79 180.1,24.47 v2(180.1,26.36)
  BOTTOM w0.508: RH252.2 177.18,13.01 176.89,12.72 176.89,12.31 177.56,11.64 178.41,11.64 v1(179.37,12.59) 179.81,13.04 v2(179.81,13.36)
+1.8V_RUN_EDRAM_ED2: length 12.3
  TOP w0.254: CPU1.BJ35 196.68,27.93 v2(196.68,27.86)
  TOP w0.508: RC226.2 198.04,20.58 v1(198.12,20.67) 198.37,20.91 v2(199.48,20.91)
  IN3 w0.508: v2(196.68,27.86) 197.65,26.89 197.77,26.89 199.88,24.79 199.88,21.31 v2(199.48,20.91)
+1.8V_RUN_PWR:
  vias: v1(243.79,82.24)
+1.8VSP:
  vias: v1(231,83.44)
+1.8VSP_ON:
  vias: v1(237.76,89.77)
+1.8VSP_VIN:
  vias: v1(231.19,86.52)
+1VSP_B+:
  vias: v1(100.89,117.37)
+2.5V_MEM: length 131.8
  TOP w0.254: 134.96,81.67 v2(134.97,81.68) ; 134.96,81.67 JDIMM1.259 ; 134.96,81.67 134.46,81.18 JDIMM1.257
  TOP w0.508: v2(134.97,81.68) 134.97,82.6 135.53,83.16 CD3.1 CD2.1 ; v2(137.22,87.23) 137.08,87.37 CD8.1 CD7.1
  IN1 w0.508: v2(118.15,87.97) 119.35,89.17 135.27,89.17 v2(137.22,87.23)
  IN4 w1.524: 100.18,83.65 99.23,83.65 74.91,59.33 74.91,50.88 64.37,40.34 61.57,40.34 ; 23.09,62.76 26.46,62.76 27.54,63.84 50.74,63.84 52.49,62.08 52.49,59.39 52.37,59.27
  BOTTOM w0.508: v2(134.97,81.68) 134.97,82.18 136.59,83.81 136.59,86.6 v2(137.22,87.23)
  vias: v2(102.91,88.25) v2(103.39,87.76) v2(103.67,88.3) v2(104,87.76) v2(104.63,87.78) v3(119.83,89.38) v4(21.82,64.03) v4(21.82,63.39) v4(21.82,62.76) v4(22.46,64.03)
+2.5V_MEMP: length 4.1
  TOP w0.254: 18.46,61.17 18.24,61.39 16.58,61.39 15.96,60.77 PR404.1 PC402.1
  vias: v1(24.14,58.86)
+2.5VSP_ON: length 5.8
  TOP w0.102: v1(17.57,60.72) 18.21,60.08 PR401.1
  TOP w0.254: PU400.7 18.53,56.23 18.77,56.47 18.77,57.13 PC401.1 PR402.1 PR401.1
+2.8V_FHV: length 26
  TOP w0.305: UH1.AL22 v2(125.19,117.06)
  IN2 w0.508: v2(145.77,113.37) 145.57,113.16 137.6,113.16 137.23,113.54 137.23,114.55 137.01,114.76
  BOTTOM w0.508: RH287.2 143.08,126.56 143.81,125.83 143.81,124.04 144.68,123.16 144.68,120.64 144.31,120.28 v1(144.31,119.68) 144.31,118.14 144.94,117.52 144.94,114.21 v2(145.77,113.37)
+3.3V_1.8V_AZIO: length 16.7
  TOP w0.254: UH1.BA15 128.52,121.56 v2(128.56,121.56)
  IN2 w0.508: v2(128.56,121.56) 128.35,121.56 128,121.91 128,122.38 128.38,122.77 128.71,122.77 129.44,123.49 131.4,123.49 132.38,124.47 133.75,124.47 134.54,125.26 134.54,125.29 134.66,125.42 134.66,126.49 136.53,128.36 v2(136.53,128.86)
  BOTTOM w0.508: RH292.2 RH295.2 136.4,128.98 136.53,128.85 v2(136.53,128.86) 136.17,128.5 CH269.1
+3.3V_1.8V_FUSE: length 1.7
  BOTTOM w0.102: v2(136.3,126.23) 136.69,125.84 v1(136.69,125.62)
  BOTTOM w0.508: v2(136.3,126.23) 136.17,126.36 RH300.2
+3.3V_1.8V_GPPA: length 9.5
  TOP w0.254: v2(119.38,122.4) 119.38,122.35 119.79,121.94 UH1.BA31
  BOTTOM w0.508: RH294.2 RH291.2 116.9,128.14 117.71,127.34 v1(117.71,126.87) 117.71,125.12 118.36,124.46 118.36,123.72 119.38,122.7 v2(119.38,122.4)
+3.3V_1.8V_GPPD:
  vias: v1(110.21,125.19)
+3.3V_1.8V_SPI: length 2.5
  TOP w0.102: v3(112.16,127.05) 112.16,126.39 113.16,125.39 v2(113.16,125.01)
  vias: v2(113.8,125.01)
+3.3V_ALW: length 533.2
  TOP w0.254: v2(58,9.63) 57.89,9.52 57.53,9.52 57.35,9.7 PU1800.10 ; PR1025.2 339.81,57.17 v2(339.94,57.04) ; PU300.7 331.73,18.35 332.07,18.69 ; PU500.10 v2(74.47,11.12) 74.13,11.46 73.99,11.46 73.77,11.68 73.77,12.29 PC506.1
  TOP w0.305: JIO2.46 53.29,33.35 v2(53.79,33.86) ; C90.1 175.67,72.71 174.87,71.92 U16.5 174.87,70 R11.1 ; JIO1.62 310.46,33.3 310.25,33.3 308.95,34.59 C723.1
  TOP w0.356: C1421.1 207.58,99.75 UC1.5 ; C787.1 319.83,6.9 320.27,7.34 320.77,7.34 321.02,7.08 U9.5 ; RE71.1 180.1,118.12 180.1,116.46 180.29,116.28 R759.1
  TOP w0.381: UC7.5 86.7,23.68 C1471.1 ; 191.53,105.51 191.53,104.95 191.4,104.83 UC4.5 ; UC6.5 218.32,105.3
  TOP w0.406: 335.88,42.39 335.96,42.31 336.72,42.31 336.96,42.07 PU105.5 ; v2(306.43,8.68) 306.81,9.06 U58.5
  TOP w0.508: PR509.1 v2(68.61,12.04) ; PR1812.1 PR1811.2 v2(53.57,3.77) ; PR757.2 271.81,27.44 v2(271.83,27.41) ; 180.48,113.35 180.48,112.62 181,112.1 181.75,112.1 RE74.1 ; C1471.1 v2(86.03,23.69) ; v2(214.99,75.01) 215.06,74.95 C92.1 215.97,75.85 215.74,76.07 U17.5 ; v2(208.35,100.32) 207.89,99.87 C1421.1 ; 218.32,105.3 218.25,105.3 v2(217.06,106.49) 217.06,106.43 216.33,105.69 216.33,104.71 215.41,103.79 UC5.5 ; RC241.1 157.76,15.41 v2(157.41,15.76) ; JPB1.4 287,42.37 287.63,41.74 288.03,41.74 290.6,39.17 290.6,38.83 289.88,38.11 289.88,37.81 v2(289.87,37.8) ; v2(307.87,9.11) 308,9.24 C778.1 ; v2(191.55,106.95) 191.24,106.65 CH17.1 191.53,105.91 191.53,105.51 ; RE75.1 RE76.1 180.32,115.27 R759.1 ; 11.92,58.63 11.92,59.08 PR400.1 ; R817.1 206.79,104.77 206.79,105.88 206.29,106.38 v2(206.29,106.53) 206.28,106.54 206.28,108.76 205.91,109.13 R3754.1 ; v2(269.44,27.35) 269.46,27.36 PR740.2 269.88,27.99 270.12,28.22 270.12,29.68 v2(270.87,30.44) ; v2(333.65,19.07) PC310.1 333.27,19.9 332.07,18.69 ; PR8.2 11.64,19.98 v2(11.85,19.77) ; PR800.2 102.24,131.8 v2(101.43,132.61) ; v2(59.29,3.77) PR1800.2 ; v2(70.53,3.89) PR511.2 ; v2(110.66,99.72) 110.66,99.58 110.21,99.13 RH276.1 ; v2(174.6,69.3) 174.6,69.73 R11.1 ; PR2.1 v2(250.15,6.81) ; C723.1 308.39,34.81 v2(308.05,35.15) ; JKBTP1.15 290.93,28.35 v2(290.46,28.82) 289.98,29.29 C1414.1 ; v2(270.21,25.98) PR758.1 271.04,25.3 PR760.1 ; v2(329.84,23.26) 329.84,22.77 PR315.1 330.11,21.83 PR306.1 ; PC151.2 335.88,42.96 335.73,43.11 v2(335.73,43.52) ; v2(55.52,13.29) PC1807.1 ; v2(182.1,91.39) 182.1,89.19 181.59,88.68 181.59,73.37 180.93,72.71 C90.1 ; v2(174.73,104.74) 174.73,105.55 R805.1 175.17,105.64 175.59,105.23 RE73.1 ; v2(319.07,7.45) 319.07,6.94 319.31,6.7 C787.1 ; R932.1 300.53,7.25 v2(300.98,7.69) ; v2(76.13,3.91) PR500.2 ; v2(72.43,3.96) PR512.1 ; PR1810.1 v2(51.45,13.33) ; v2(179.41,118.36) 179.57,118.19 RE71.1 180.18,118.74 RE72.1 ; v2(179.11,107.86) 179.11,107.86 179.7,108.45 179.7,109 179.3,109.39 RE69.1 178.24,110.66 177.52,111.37 177.51,111.37 176.43,112.45 RE77.1 175.58,112.68 175.1,113.17 175.1,116.14 v2(174.78,116.45)
  TOP w1.016: 114.79,138.01 117.01,138.01 117.33,137.69 119.8,137.69
  IN1 w0.508: v2(179.41,118.36) 179.41,118.78 179.05,119.13 176.85,119.13 176.32,118.6 176.32,116.86 175.81,116.35 174.89,116.35 v2(174.78,116.45) ; v2(270.21,25.98) 269.92,25.98 269.44,26.45 v2(269.44,27.35) 269.44,27.35 269.51,27.41 v2(271.83,27.41) 271.83,23.41 272.33,22.91 v2(272.57,22.91)
  IN2 w0.508: v2(58,9.63) 58.53,9.1 58.53,4.66 58.46,4.59 ; 213.3,93.26 213.3,95.36 208.8,99.86 208.8,99.88 208.35,100.32 v2(208.35,100.32) ; 213.28,92.6 213.67,92.6 216.21,90.06 216.21,88.7 216.75,88.16 217.73,88.16 218.15,88.16 v2(220.58,85.72) ; 58.46,4.59 54.4,4.59 v2(53.57,3.77) ; 58.46,4.59 v2(59.29,3.77) ; v2(169.52,111.35) 169.52,111.87 v2(169.89,112.24) ; v2(157.41,15.76) 157.41,50.1 174.41,67.1 174.41,68.98 174.6,69.17 v2(174.6,69.3) ; v2(153.01,120.61) 153.01,120.83 152.38,121.47 150.89,121.47 149.86,120.44 144.42,120.44 143.6,119.62 142.18,119.62 139.68,122.12 137.75,122.12 137.21,122.65 136.99,122.65 v2(136.62,123.01)
  IN3 w0.508: 75.06,4.97 73.45,4.97 v2(72.43,3.96) 71.54,4.85 70.97,4.85 70.53,4.4 v2(70.53,3.89) ; 75.06,4.97 75.35,5.27 75.35,10.24 v2(74.47,11.12) ; 75.06,4.97 v2(76.13,3.91) ; v2(114.28,136.93) 114.19,136.84 114.19,136.61 113.13,135.55 109.66,135.55 108.97,134.87 107.14,134.87 106.32,135.69 103.06,135.69 101.43,134.06 v2(101.43,132.61) ; v2(169.52,111.35) 169.01,110.84 169.01,109.57 v2(170.04,108.54) ; v2(186.03,101.87) 186.03,97.72 187.94,95.82 187.94,93.35 185.98,91.39 v2(182.1,91.39) ; v2(333.65,19.07) 332.83,18.24 329.97,18.24 329.04,19.17 329.04,22.42 329.84,23.23 v2(329.84,23.26) ; v2(196.38,123.86) 196.38,125.14 196.34,125.18 196.34,127.62 196.35,127.62 196.35,128.57 197.38,129.6 197.38,130.49 197.15,130.72 197.15,135.11 194.06,138.2 192.83,138.2 192,139.02 192,141.12 190.4,142.72 190.4,144.47 190.45,144.52 v2(190.45,144.55)
  IN4 w0.508: v2(51.45,13.33) 51.45,13 51.92,12.53 55.22,12.53 55.52,12.82 v2(55.52,13.29) ; v2(250.15,6.81) 250.77,7.44 254.71,7.44 256.25,8.97 261.63,8.97 272.57,19.91 v2(272.57,22.91) ; v2(74.47,11.12) 79.3,11.12 80.37,10.05 83.93,10.05 90.28,16.4 90.28,19.45 v2(86.03,23.69)
  BOTTOM w0.203: v2(54.74,19.01) 54.93,19.2 PR209.1
  BOTTOM w0.305: JAPS1.7 223.48,97.02 v2(223.32,97.18) ; v2(225.15,97.18) 225.48,96.85 JAPS1.3
  BOTTOM w0.457: v2(200.36,96.79) 200.64,97.08 R396.1
  BOTTOM w0.508: R847.1 181.63,93.29 181.96,92.95 181.96,91.54 v2(182.1,91.39) ; R847.1 R850.1 R848.1 R849.1 ; R847.1 R861.1 ; v2(204.84,123.49) 204.7,123.63 R872.1 ; v2(11.85,19.77) 11.85,20.02 13.69,21.86 13.69,26.63 16.51,29.45 16.51,39.29 v2(16.63,39.4) ; PR107.2 344.06,30.56 v2(343.75,30.25) ; R763.1 170.21,106.45 170.21,105.12 v2(170.05,104.96) ; v2(169.52,111.35) 170.59,111.35 R800.1 ; R2158.1 187.84,106.24 v2(187.84,105.52) ; 190.61,111.72 191.06,111.27 R814.1 ; v2(209.58,114.16) R838.1 R841.1 ; RH301.1 119.36,130.69 117.89,132.16 116.76,132.16 116.25,132.67 ; v2(169.89,112.24) 170.65,112.24 R3740.2 ; v2(153.5,124.04) 153.59,123.95 153.59,121.18 v2(153.01,120.61) ; v2(289.87,37.8) 289.87,34.98 290.46,34.39 v2(290.46,28.82) ; v2(170.04,108.54) 170.53,108.54 RE14.1 ; v2(335.73,43.52) 335.2,42.98 R415.1 ; v2(220.58,85.72) 217.51,85.72 213.08,81.3 213.08,79.84 213.59,79.33 213.59,77.49 214.99,76.09 v2(214.99,75.01) ; R755.1 190.99,144.01 v2(190.45,144.55) ; 231.44,91.9 231.63,91.9 232.77,93.05 232.77,94.06 232.01,94.83 230.8,94.83 229.98,95.65 229.98,96.22 228.58,97.62 228.58,100.41 v3(227.75,101.24) 226.94,102.05 v2(225.55,102.05) ; R837.1 R875.1 209.33,111.42 v2(209.53,111.61) ; v2(186.03,101.87) 186.03,101.3 187.05,100.29 187.94,100.29 v1(188.83,99.39) 188.83,96.6 190.99,94.44 190.99,91.9 v3(190.74,91.66) 190.52,91.66 190.28,91.42 188.23,91.42 187.91,91.74 R864.1 R858.1 186.31,91.65 186.23,91.65 186.04,91.45 185.41,91.45 185.02,91.84 185.02,92.27 R859.1 R860.1 ; RE68.1 216.57,106.5 217.05,106.5 v2(217.06,106.49)
  vias: v2(16.62,40.03) v2(17.23,39.96) v2(17.55,39.45) v2(17.87,39.96) v2(49.67,32.38) v2(49.99,31.87) v2(50.3,32.39) v2(50.62,31.88) v2(69.21,40.02) v2(69.85,40.02) v2(114.91,136.93) v2(117.33,122.13) v2(118.28,121.88) v2(120.69,138.51) v2(120.69,137.88) v2(189.53,110.13) v2(189.52,109.55) v2(192.51,102.45) v2(197.37,123.71) v2(197.97,123.71) v2(198.57,123.71) v2(212.58,93.56) v2(212.58,92.92) v2(218.29,123.91) v2(218.59,123.4) v2(218.75,120.69) v2(219.1,123.72) v2(219.14,123.12) v2(219.1,121.18) v2(219.15,120.27) v2(305.54,31.95) v2(306.18,31.85) v2(306.29,31.26) v2(306.81,31.85) v2(306.92,31.26) v2(307.45,31.85) v2(307.56,31.26) v2(322.15,36.58) v2(322.15,35.95) v2(322.52,37.03) v2(322.8,36.52) v2(322.8,35.88) v2(340.4,5.29) v2(340.4,4.66) v2(340.4,4.02) v2(341.04,4.02) v2(341.72,4.02) v2(342.35,4.02) v2(342.99,4.02) v2(343.75,4.02) v2(344.51,4.66) v2(344.51,4.02) v2(345.15,4.66) v2(345.15,4.02) v2(345.78,4.66) v2(345.78,4.02) v2(346.42,4.02) v2(347.05,4.02) v2(347.69,4.02) v2(348.32,4.02) v2(348.96,4.02) v4(11.22,57.68) v4(11.22,57.04) v4(11.22,56.41) v4(11.22,55.77) v4(11.92,57.68) v4(11.92,57.04) v4(11.92,56.41) v4(11.92,55.77)
+3.3V_ALW2: length 560.1
  TOP w0.305: v2(54.44,33.93) 53.97,34.4 53.62,34.4 53.07,33.85 JIO2.48
  TOP w0.508: RZ70.1 65.42,34.51 v2(66.02,35.11) ; v2(247.59,77.98) 237.97,68.35 231.56,68.35 230.62,67.4 228.57,67.4 227.14,68.83 225.38,68.83 224.77,68.22 v2(222.61,68.22) ; v2(347.77,56.9) 347.77,57.37 PR1099.1 ; PQ1072.3 v2(345.96,55.95) ; PR1013.1 333.15,46.38 v2(333.59,46.82) 334.57,46.82 334.89,46.51 336.99,46.51 337.73,47.25 v2(337.73,47.44) 337.73,47.81 337.33,48.2 PR1022.1
  IN1 w0.508: v2(54.44,33.93) 55.05,33.93 57.63,36.51 59.21,36.51 59.87,37.18 63.84,37.18 65.9,35.11 v2(66.02,35.11) 70.78,35.11 72.88,37.21 v2(72.88,46.57)
  IN2 w0.508: v2(200.11,123.63) 200.91,123.63 202.02,124.74 205.21,124.74 205.8,124.15 215.65,124.15 216.8,125.3 219.46,125.3 220.49,124.26 222.33,124.26 224.93,121.67 224.93,117.64 228.41,114.16 229.03,114.16 230.03,113.16 230.03,110.2 231.68,108.55 231.68,108.04 232.77,106.95 v2(232.83,106.95) ; v2(247.59,77.98) 247.67,78.05 247.67,78.7 247.31,79.05 246.98,79.05 242.45,83.59 242.45,84.6 235.09,91.96 v2(235.09,92.2) ; v2(333.59,46.82) 332.38,46.82 331.94,47.25 329.85,47.25 328.75,46.15 328.37,46.15 327.96,45.74 326.24,45.74 325.69,45.19 324.41,45.19 323.26,44.04 322.38,44.04 321.41,43.07 317.83,43.07 316.91,43.99 315.45,43.99 313.64,45.8 312.14,45.8 311.14,44.8 295.79,44.8 294.09,46.5 286.38,46.5 283.32,49.56 278.38,49.56 261.94,66 261.94,66.91 259.95,68.9 259.95,71.24 256.72,74.47 256.72,75.74 253.64,78.82 253.64,83.53 250.96,86.2 250.96,87.23 246.53,91.66 v2(245.56,91.66) ; v2(347.77,56.9) 347.77,56.99 346.74,55.95 v2(345.96,55.95) 344.35,54.34 344.35,51.36 341.64,48.65 338.49,48.65 337.73,47.89 v2(337.73,47.44) 337.73,47.12 338.93,45.92 338.93,34.13 340.63,32.43 342.37,32.43 343.9,30.9 347.13,30.9 v2(347.56,31.33) ; v2(177.64,19.11) 177.85,19.32 178.22,19.32 179.11,20.21 179.11,20.59 182.99,24.47 187.68,24.47 188.26,23.9 188.26,19.64 189.08,18.82 195.5,18.82 201.15,24.47 211.81,24.47 213.34,25.99 213.34,51.52 212.58,52.28 212.58,57.5 222.61,67.53 v2(222.61,68.22)
  IN3 w0.508: v2(177.64,19.11) 177.64,19.27 177.33,19.58 175.43,19.58 174.98,19.13 172.76,19.13 172,19.9 168.51,19.9 168.06,20.34 158.41,20.34 157.65,19.58 145.95,19.58 142.96,16.59 139.49,16.59 138.85,15.96 138.19,15.96 136.94,14.71 136.94,14.37 134.79,12.21 110.62,12.21 107.06,15.77 105.2,15.77 104.72,15.29 97.25,15.29 92.99,19.55 92.18,19.55 91.32,20.41 91.32,29.17 75.29,45.21 74.36,45.21 73,46.57 v2(72.88,46.57) ; v2(235.09,92.2) 236.57,90.72 238.75,90.72 238.8,90.67 239.31,90.67 239.36,90.72 239.42,90.72 240.67,91.97 245.25,91.97 v2(245.56,91.66)
  BOTTOM w0.508: v2(245.56,91.66) 245.63,91.66 246.64,92.67 246.64,93.05 248.96,95.38 248.96,97.81 v1(247.42,99.35) 246.78,99.99 246.14,99.99 243.73,102.4 243.73,103.04 243.32,103.45 243.32,105.45 241.09,107.69 237.42,107.69 236.81,107.08 232.96,107.08 v2(232.83,106.95) ; R874.2 v2(200.11,123.63)
+3.3V_ALW2_R: length 4.2
  TOP w0.102: RZ70.2 64.98,33.11 65.43,32.65 v3(65.75,32.65) 65.86,32.65 67.01,33.8 JUSH1.25
+3.3V_ALW_PCH: length 339.1
  TOP w0.508: v2(166.79,119.35) 166.79,120.56 164.74,122.61 160.67,122.61 159.68,123.6 RC133.2 159.23,124.21 157.61,125.83 v2(157.61,127.11) ; RH310.2 106.61,115.65 106.14,115.18 ; v2(161.76,18.68) RC316.2 ; RH309.1 106.58,117.42 v2(106.55,117.45) ; v2(96.73,103.97) 97.42,104.66 97.42,105.14 97.93,105.66 99.14,105.66 100.5,107.02 101.77,107.02 104.8,110.05 104.8,111.65 103.92,112.54 103.92,113.18 104.35,113.61 ; RH341.1 107.36,110.51 107.1,110.76 107.1,111.84 106.46,112.49 105.35,112.49 104.82,113.02 ; RH65.1 105.65,128.78 108.08,131.21 RH329.2
  IN2 w0.508: v2(235.18,105.49) 235.18,107.62 232.2,110.6 232.2,115.1 229.23,118.07 228.21,118.07 227.14,119.13 227.14,123.33 223.68,126.79 221.24,126.79 219.64,128.4 217.42,128.4 215.88,129.94 209.79,129.94 209.24,129.39 206.37,129.39 206.35,129.41 201.79,129.41 v2(201.15,128.76) 197.98,128.76 v2(196.73,130.02) 196.12,129.41 194.64,129.41 193.43,128.19 190.13,128.19 189.82,127.88 189.82,127.71 188.87,126.76 186.34,126.76 185.35,125.76 182.86,125.76 182.69,125.93 182.69,126.68 ; v2(101.79,67.05) 101.87,67.05 103.67,68.85 103.67,70.7 104.31,71.33 104.94,71.33 105.96,72.35 116.31,72.35 119.87,75.9 138.47,75.9 140.19,74.19 140.19,61.3 151.39,50.1 151.39,20.56 v2(151.11,20.28)
  IN3 w0.508: v2(202.44,143.92) 202.44,138.11 v2(202.73,137.82)
  BOTTOM w0.254: 226.48,97.3 JAPS1.1
  BOTTOM w0.508: v2(101.79,67.05) 101.79,70.04 95.29,76.54 95.29,86.82 93.96,88.16 93.96,92.36 98.16,96.56 98.16,100.34 96.73,101.77 v3(96.73,103.02) v2(96.73,103.97) ; v2(201.15,128.76) 202.73,130.35 202.73,132.61 203.18,133.05 203.18,136.16 202.42,136.93 202.42,137.5 v2(202.73,137.82) ; RH303.1 114.64,116.09 114.2,115.64 RH352.1 113.48,115.28 113.1,114.89 112.35,114.89 RH351.1 111.66,114.76 111.23,114.76 110.92,114.45 RH305.1 110.81,114.08 110.17,114.72 105.85,114.72 105.31,114.18 v2(104.89,114.18) 104.89,115.22 106.55,116.88 v2(106.55,117.45) ; 226.48,97.3 225.72,98.06 225.72,100.09 224.44,101.37 224.23,101.58 224.23,103.37 226.67,105.81 228.85,105.81 229.07,106.04 230.98,106.04 231.21,105.81 234.87,105.81 v2(235.18,105.49) ; R3728.1 202.23,144.13 202.44,143.92 v2(202.44,143.92) ; RH343.2 166.7,119.43 v2(166.79,119.35) ; v2(138.35,125.62) 138.03,125.31 138.03,123.61 137.47,123.05 137.47,121.92 136.9,121.35 136.67,121.35 135.8,120.48 135.8,120.47 135.52,120.19 RH299.1 ; v2(161.76,18.68) 161.76,19.15 160.95,19.96 154.22,19.96 153.52,19.26 151.74,19.26 151.11,19.9 v2(151.11,20.28) ; RH128.2 RH311.1 ; v2(137.3,126.02) 137.09,126.24 RH300.1
  vias: v2(105.06,126.77) v2(105.06,125.88) v2(109.33,127.53) v2(109.96,127.53) v2(122.28,131.4) v2(122.91,131.4) v2(123.51,131.42) v2(150.39,128.26) v2(150.97,128.26)
+3.3V_ALW_PCH_PWR:
  vias: v1(147.88,125.83)
+3.3V_ALW_PCHRES: length 43.1
  TOP w0.508: v2(107.68,125.4) 107.73,125.45 RH293.1
  IN1 w0.508: v2(112.68,129.12) 113.63,130.06 115.74,130.06 v2(115.99,130.32)
  IN2 w0.508: v2(133.58,136.86) 133.58,136.59 131,134.01 122.86,134.01 118.92,130.06 116.25,130.06 v2(115.99,130.32)
  IN3 w0.508: v2(112.68,129.12) 112.68,128.06 111.76,127.15 110.55,127.15 108.8,125.4 v2(107.68,125.4)
  BOTTOM w0.508: v2(133.58,136.86) 133.58,135.36 133.98,134.96 133.98,133.19 135.51,131.66 RH292.1 ; RH291.1 116.22,130.1 v2(115.99,130.32) ; RH246.1 113.28,128.52 v2(112.68,129.12) 111.98,129.81 RH279.2
+3.3V_ALW_U46: length 43.7
  TOP w0.381: v2(182.48,107.96) 182.48,107.97 183.27,108.76 183.8,108.76 C710.1
  TOP w0.457: v2(185.36,115.33) 184.68,115.33 184.64,115.28 C709.1
  TOP w0.508: C708.1 177.6,115.36 177.6,114.34 v2(177.52,114.26) 177.55,114.23 177.55,113.47 v1(180.29,110.73) 181.96,109.06 181.96,108.48 v2(182.48,107.96) ; v2(178.05,104.59) 178.05,105.23 C717.1 ; v2(173.1,109.61) 173.67,109.61 C718.1
  IN1 w0.254: 178.15,110.73 178.16,110.74
  IN1 w0.508: v2(177.52,114.26) 177.55,114.23 177.55,113.38 178.16,112.77 178.16,110.74 ; 178.05,106.42 178.05,106.42 178.05,105.75 178.05,105.75 v2(178.05,104.59) ; 178.05,106.42 178.05,106.43 ; 178.05,106.42 177.45,106.42 176.69,105.66 175.01,105.66 173.78,106.89 173.78,108.93 v2(173.1,109.61)
  IN4 w0.457: 183.48,115.41 185.27,115.41 185.35,115.33 v2(185.36,115.33)
  IN4 w0.508: v2(177.52,114.26) 177.52,114.29 177.6,114.37 177.6,114.55 178,114.94 178,114.95 178.36,115.31 178.37,115.31 178.47,115.41 183.48,115.41
  BOTTOM w0.254: 185.35,115.33 185.08,115.33 184.75,115.01 U46.A17 ; v2(173.1,109.61) 173.19,109.51 U46.A54 ; U46.B30 183.11,108.76 182.48,108.13 v2(182.48,107.96)
  BOTTOM w0.279: U46.A43 178.05,105.31 v2(178.05,104.59)
  BOTTOM w0.305: v2(177.52,114.26) 177.52,114.83 177.3,115.05 U46.B5
  BOTTOM w0.457: v2(185.36,115.33) 185.35,115.33 185.56,115.54 186.28,115.54 186.41,115.4 186.48,115.46
+3.3V_ALW_U51: length 74
  TOP w0.381: 196.83,104.03 196.83,104.44 196.86,104.47 196.86,105.65 195.71,106.81 195.71,107.09 194.13,108.67 193.46,108.67 192.82,109.32 192.82,110.79 193.17,111.15 v2(193.78,111.15)
  TOP w0.508: v2(194.92,104.8) 195.69,104.03 197.4,104.03 197.72,103.72 198.98,103.72 199.49,104.23 199.49,104.33 199.5,104.34 v2(199.5,104.68) 200.56,105.75 201.46,105.75 202.03,105.19 v1(202.03,103.46) 204.31,103.46 204.58,103.19 206.4,103.19 207.42,104.21 207.42,106.31 207.46,106.34 207.46,106.37 207.81,106.73 207.81,108.99 207.05,109.75
  IN1 w0.508: v2(198.35,120.35) 198.24,120.24 198.24,120.05 197.88,119.69 197.38,119.69 196.91,120.16 196.91,120.57 196.45,121.02 192.35,121.02 v2(190.44,119.11)
  IN3 w0.381: v2(190.44,119.11) 190.44,118.64 192.52,116.56 192.52,112.41 v2(193.78,111.15)
  IN4 w0.457: v2(202.52,102) 202.52,103.04
  IN4 w0.508: v2(199.5,104.68) 200.65,103.53 202.04,103.53 202.52,103.04
  BOTTOM w0.254: C781.1 193.23,110.37 193.78,110.92 v2(193.78,111.15) ; v2(204.45,114.26) 204.59,114.11 U51.B3
  BOTTOM w0.279: R845.1 198.26,118.66 198.26,116.92 198.25,116.92 U51.A52 ; U51.A41 194.72,111.36 194.44,111.08 193.84,111.08 v2(193.78,111.15) ; C777.1 200.13,104.09 200.13,104.86 199.75,105.24 U51.A26 ; U51.A11 207.02,109.86 207.32,109.56 207.96,109.56
  BOTTOM w0.305: 195.18,105.4 195.18,106.23 195.18,106.23 195.5,106.54 195.5,106.87 195.74,107.11 U51.B35
  BOTTOM w0.508: v2(207.42,110.37) 207.45,110.34 207.45,110.21 207.96,109.7 207.96,109.56 C1355.1 ; C1348.1 207.4,115.94 v2(207.2,116.14) ; v2(199.5,104.68) 199.49,104.67 199.49,104.31 199.8,104 C777.1 ; R834.1 203.16,102.3 202.86,102 v2(202.52,102) ; R845.1 C1345.1 198.27,119.99 198.35,120.08 v2(198.35,120.35)
+3.3V_DSW: length 17.7
  TOP w0.254: UH1.BA24 v2(122.81,121.68)
  IN3 w0.508: v2(122.39,129.83) 121.72,129.16 121.72,128.75 123.31,127.16 123.31,125.92 122.66,125.27 122.66,124.1 122.22,123.65 122.22,122.8 122.23,122.79 122.23,122.75 122.57,122.41 122.61,122.41 122.81,122.21 v2(122.81,121.68)
  IN4 w0.508: v2(122.39,129.83) 125.7,129.83 125.97,130.1 v2(127.6,130.1)
  BOTTOM w0.508: RH301.2 121.25,129.3 121.55,129.59 RH306.2 122.15,129.59 v2(122.39,129.83)
  vias: v1(131.11,130.51)
+3.3V_HDD: length 73.4
  TOP w0.254: 40.19,31.17 40.19,30.68 39.96,30.45 UN9.24 ; 35.01,27.65 35.31,27.95 UN9.12 ; UN8.24 29.12,30.38 29.42,30.68 ; UN8.12 24.13,27.88 23.75,27.5
  TOP w0.508: RN121.1 42.8,32.38 RN122.1 43.67,31.87 v2(43.95,31.59) ; v2(23.6,28.21) 23.3,27.91 CN67.1 23.75,27.5 ; v2(40.7,31.64) 40.7,32.2 CN71.1 40.01,31.35 40.19,31.17 ; 29.42,30.68 29.42,32.35 29.82,32.76 CN75.1 v2(29.82,33.88) 29.82,34.46 30.23,34.87 31.04,34.87 RN116.1 RN61.1 33.58,34.11 RN79.1 33.61,33.4 33.89,33.12 RN59.1 ; RN52.1 v2(24.36,23.59) 24.36,22.58 24.92,22.02 24.92,14.96 26.19,13.69 31.83,13.69 ; RN130.1 44.43,28.98 44.2,29.2 v2(43.57,29.2) 43.44,29.2 43.16,29.48 RN123.1 ; RN114.1 22.41,26.16 21.98,25.72 v2(21.59,25.72) 21.59,25.09 RN110.1 ; v2(29.49,23.18) 29.67,23.36 RN104.1 ; 35.01,27.65 34.81,27.45 RN129.1 34.19,27.3 34.73,26.77 34.73,26.39 CN73.1 34.17,25.45 33.68,24.96 RN62.1 v2(32.92,24.68) ; RN78.1 21.19,35.17 20.65,34.64 20.65,33.9 v2(21.16,33.4) RN50.1 RN99.1 ; RN54.1 24.9,33.93 v2(24.9,34.54) ; RN115.1 30.64,27.63 31.12,27.15 RN127.1 31.5,26.89 31.93,26.46 v2(31.93,26.33)
  IN3 w0.508: v2(43.95,31.59) 43.9,31.64 v2(40.7,31.64)
  IN4 w0.508: v2(31.93,26.33) 31.93,26.41 32.74,27.22 35.69,27.22 36.33,27.86 36.33,30.14 36.81,30.63 39.69,30.63 40.7,31.64 v2(40.7,31.64)
  BOTTOM w0.508: v2(43.95,31.59) 43.57,31.21 v2(43.57,29.2)
  vias: v2(31.81,11.86) v2(31.91,29.74) v2(32.77,11.88)
+3.3V_HDD1: length 9
  TOP w0.508: v2(29.95,20.59) 29.95,22.55 30.27,22.87 30.27,22.99 30.64,23.36 31.25,23.36 31.68,23.79 33.66,23.79 34.01,23.44 35.11,23.44 R3753.1
  vias: v2(29.25,20.66) v2(29.25,20.02) v2(29.95,19.96) v2(30.84,19.81)
+3.3V_LAN: length 92.9
  TOP w0.203: v2(236.33,116.35) U32.14
  TOP w0.254: v2(233.73,121.67) 233.79,121.67 233.79,121.56 233.83,121.52 U32.30 ; U32.1 229.83,116.31 230.36,115.78 C473.1 ; U32.21 239.16,119.79 C472.1 ; v2(231.88,116.28) 231.7,116.28 231.33,116.65 U32.4 ; v2(233.33,116.3) U32.8
  TOP w0.508: v2(254.41,119.2) C1418.1 254.41,117.61 R209.2 ; R549.1 256.85,116.35 R559.2 v2(257.53,115.4) ; C478.1 229.49,115.44 229.49,115.89 229.21,116.17 v2(229.21,116.23) ; C478.1 228.97,115.41 228.78,115.61 U15.5 ; C478.1 C473.1 ; R377.1 240.78,120.42 C472.1 239.43,120.42 239.06,120.8 v2(239.06,121.18) ; v2(255.88,121.56) 255.88,120.85 R553.1 ; v2(253.99,103.26) R546.1 R545.1 ; v2(257.66,113.44) R554.1
  IN1 w0.508: 232.9,146.13 230.42,146.13 228.5,144.21 v2(228.03,144.21) ; 232.9,146.13 232.9,149.96 JLOM1.12 ; 232.9,146.13 232.9,145.82 233.98,144.74 234.67,144.74 236.39,143.02 244.14,143.02 245.41,144.29 245.41,146.77 244.52,147.66 JLOM1.9
  IN3 w0.508: v2(253.99,103.26) 254.55,103.83 254.55,105.11 256.33,106.89 256.33,112.92 256.84,113.44 v2(257.66,113.44)
  BOTTOM w0.508: 254.61,121.56 v2(255.88,121.56) ; 254.61,121.56 254.41,121.36 v3(254.41,120.17) v2(254.41,119.2) 255.48,118.13 256.14,118.13 257.53,116.73 v2(257.53,115.4) 256.57,114.43 256.57,113.91 257.05,113.44 v2(257.66,113.44) ; 254.61,121.56 253.79,122.38 249.22,122.38 248.04,123.56 244.3,123.56 243.45,122.7 239.5,122.7 238.8,122
  vias: v2(227.44,144.47) v2(227.44,143.83) v2(227.46,143.2) v2(228.03,143.58) v2(228.26,122.7) v2(228.32,121.75) v2(228.32,120.61) v2(228.52,121.18) v2(228.64,122.26)
+3.3V_LAN_OUT: length 8
  TOP w0.203: 249.91,105.18 250.53,105.79 U31.29 ; U31.4 252.13,112.15 v2(251.88,111.91) 251.73,112.06 U31.5 ; U31.15 v2(249.09,111.34) ; U31.19 249.02,109.74 249.15,109.88 v2(249.15,110)
  TOP w0.508: 249.91,105.18 249.79,105.05 249.03,105.05 248.72,105.36 v2(248.72,105.44)
  vias: v1(251.66,110.55)
+3.3V_LAN_PWR:
  vias: v1(221.35,118.55)
+3.3V_M: length 103
  TOP w0.508: v2(189.2,125.22) 189.2,123.22 RZ75.2
  IN2 w0.508: v2(111.69,125.48) 112.04,125.84 113.86,125.84 114.41,125.29 114.81,125.29 115.17,125.65 115.89,125.65 116.78,124.76 119.87,124.76 120.35,125.24 120.35,126.03 120.68,126.36 120.68,126.72 v2(122.86,128.9) ; v2(189.2,125.22) 188.46,125.22 186.79,123.55 183.85,123.55 183.31,123.01 179.56,123.01 178.92,122.38 177.28,122.38 176.65,121.74 171.56,121.74 169.5,119.68 168.04,119.68 167.1,118.74 165.42,118.74 v2(164.15,120.01) 163.53,120.01 162.95,119.43 162.16,119.43 161.12,118.38 154.59,118.38 153.61,119.36 152.34,119.36 151.92,119.78 v2(151.92,119.84) 150.81,119.84 150.39,119.42 149.29,119.42 148.31,118.44 145.35,118.44 144.91,118.87 136.94,118.87 135.82,119.99 135.82,121.08 v2(136.81,122.07)
  IN3 w0.508: v2(122.86,128.9) 122.86,128.57 124.59,126.84 124.59,126.28 125.48,125.39 125.48,124.45 125.76,124.18 126.98,124.18 127.66,123.49 128.6,123.49 129.07,123.96 130.22,123.96 130.56,123.62 131.5,123.62 132.26,124.38 134.37,124.38 135.03,123.72 135.03,122.85 135.26,122.63 135.26,121.97 135.52,121.71 136.45,121.71 v2(136.81,122.07)
  BOTTOM w0.508: RH344.2 165.79,119.28 165.43,118.92 v3(165.13,118.92) 164.71,118.92 164.15,119.48 v2(164.15,120.01) ; RH348.1 112.04,125.83 v2(111.69,125.48)
+3.3V_M_PWR:
  vias: v1(147.53,117.85)
+3.3V_M_TPM: length 29.2
  TOP w0.508: RZ69.1 190.57,134.62 CZ6.1 CZ7.1 192.38,134.5 v2(192.46,134.58) ; v2(193.12,125.32) 193.73,125.93 QZ2.3 192.36,126.27 191.64,125.55 RZ78.1 191.64,124.41 191.86,124.19 191.86,123.72 191.11,122.97 190.35,122.97 RZ75.1
  IN1 w0.508: v2(199.28,130.01) 194.59,125.32 v2(193.12,125.32) 193.12,125.64 192.46,126.3 v2(192.46,132.16) v2(192.46,134.58)
  BOTTOM w0.254: v2(192.46,132.16) 192.5,132.12 U637.22
  vias: v1(193.22,124.71)
+3.3V_MXM: length 26.5
  TOP w0.305: R2.1 211.37,74.36 211.23,74.51 210.74,74.51 210.21,75.04 Q295.2
  TOP w0.381: Q295.5 210.21,72.32 R1.1
  TOP w0.508: R37.1 213.26,75.95 v2(212.96,75.65) 212.96,74.82 212.5,74.36 R2.1 211.92,72.72 211.36,72.16 R1.1 ; R5.1 R3.1 v2(165.14,76.73) ; 208.25,76.58 R4.1 R1977.1 ; R10.1 161.7,65.88 161.28,66.3 161.28,67.85 162.39,68.96 v2(162.39,68.95)
  BOTTOM w0.508: R1978.1 163.69,76.46 164.06,76.09 164.7,76.09 165.14,76.54 v2(165.14,76.73) ; v2(159.61,74.14) 159.61,71.73 v2(162.39,68.95) 162.92,68.42 R71.1
  vias: v1(152.46,77.72) v1(153.75,77.85) v2(155.74,73.17) v2(159.55,77.55) v2(160.19,77.55) v2(206.09,77.3) v2(206.67,78) v2(206.73,77.36) v2(210.35,77.24) v2(210.99,77.23) v2(214.93,95.08) v2(214.99,93.56) v2(214.99,92.92) v3(210.17,77.86)
+3.3V_MXM_PWR: length 3
  TOP w0.102: v3(216.39,95.73) 214.81,95.73 214.2,95.12 213.64,95.12
+3.3V_PGPPBCH: length 3.2
  TOP w0.254: UH1.BD40 UH1.BC42 114.29,122.9 v2(114.29,122.89)
  BOTTOM w0.508: RH304.2 CH63.1 RH61.1
  vias: v1(113.38,122.97)
+3.3V_PGPPEF: length 2.6
  TOP w0.305: v2(115.42,116.75) 115.06,116.4 UH1.AJ41 ; v2(115.07,117.72) 115.11,117.68 UH1.AL41
  IN4 w0.381: v2(115.42,116.75) 114.94,117.23 114.94,117.6 v2(115.07,117.72)
  vias: v1(115.52,117.95)
+3.3V_PGPPG: length 5.3
  TOP w0.254: v2(115.5,114.3) 115.06,113.86 UH1.AD41
  BOTTOM w0.508: v2(115.5,114.3) 114.6,113.4 113.24,113.4 112.63,114.01 CH64.1 111.95,114.19 RH305.2
+3.3V_PHVC: length 3.4
  TOP w0.254: v2(132.22,118.72) UH1.AN5
  BOTTOM w0.508: RH299.2 133.63,119.42 133.32,119.11 CH66.1 132.61,119.11 v2(132.22,118.72)
+3.3V_PRTC: length 45.1
  TOP w0.203: v2(124.18,121.8) 124.43,121.8 UH1.BA22
  TOP w0.508: CH65.1 CH33.1 144.56,127.07 145.31,126.32 v2(145.58,126.32)
  IN1 w0.508: v2(129.9,135.53) 128.27,133.9 128.27,133.05 128.69,132.63 128.69,131.49 128.02,130.82 125.7,130.82 124.18,129.31 v2(124.18,128.93)
  IN3 w0.381: v2(145.58,126.32) 145.58,126.68 145.36,126.9 145.36,129.47 144,130.83 142.41,130.83 140.96,132.28 135.89,132.28 134.85,133.31 134.85,133.94 132.74,136.05 130.3,136.05 129.9,135.65 v2(129.9,135.53)
  BOTTOM w0.508: RH297.2 124.18,129.61 v2(124.18,128.93) 124.18,128.61 124.78,128.01 v3(124.78,127.55) 124.6,127.37 124.6,126.29 125.58,125.31 125.58,124.4 124.57,123.38 124.57,122.19 v2(124.18,121.8)
+3.3V_PRTCPRIM: length 9.8
  TOP w0.254: v2(126.23,121.68) 126.07,121.68 125.77,121.99 UH1.BA20
  BOTTOM w0.508: RH298.2 126.29,129.58 CH67.1 CH37.1 126.29,126.69 127.49,125.48 v1(127.49,125.31) 127.49,124.77 126.8,124.07 126.8,122.18 126.31,121.68 v2(126.23,121.68)
+3.3V_PUSBDSW: length 28.8
  TOP w0.381: UH1.W15 127.81,111.74 v2(127.96,111.89)
  TOP w0.508: RH276.2 111.61,99.59 v2(111.48,99.72)
  IN4 w0.381: v2(127.96,111.89) 127.96,110.6 127.17,109.81 124.93,109.81 123.19,108.07 119.76,108.07 119.71,108.13 119.29,108.13 119.13,107.97 117.71,107.97
  IN4 w0.508: v2(111.48,99.72) 111.48,99.84 111.04,100.29 111.04,104.35 114.15,107.46 117.2,107.46 117.71,107.97
  BOTTOM w0.102: v3(112.12,99.72) 111.49,99.72 v2(111.48,99.72)
  BOTTOM w0.508: v2(127.96,111.89) 128.28,112.21 CH31.1
+3.3V_RTC_LDO: length 377.4
  TOP w0.508: v2(344.18,32.29) PR103.1 ; v2(129.93,13.44) 129.2,12.71 109.03,12.71 107.3,14.43 106.4,14.43 v2(105.71,15.13)
  IN1 w0.508: v2(247.02,6.76) 247.25,6.99 248.88,6.99 249.74,6.13 252.04,6.13 252.67,6.75 252.67,8.49 256.77,12.6 260.03,12.6 262.82,15.39 271.59,15.39 271.77,15.57 281.93,15.57 282.44,15.06 284.47,15.06 285.91,16.5 297.34,16.5 299.78,14.07 310.24,14.07 314.64,9.67 328.7,9.67 329.59,10.56 333.6,10.56 334.5,9.67 339.21,9.67 340.27,10.72 340.27,12.15 342.23,14.1 342.23,19.74 339.61,22.36 339.61,30.97 340.93,32.29 v2(344.18,32.29) ; v2(181.33,12.72) 181.33,8.41 182.24,7.51 183.25,7.51 v2(183.58,7.18) ; v2(45.98,29.93) 47.39,28.52 51.4,28.52 52.46,29.58 52.46,31.97 52.99,32.5 55.17,32.5 55.66,32.01 60.41,32.01 62.19,33.8 71.72,33.8 73.82,35.9 89.24,35.9 v2(91.02,37.68)
  IN2 w0.508: v2(129.93,13.44) 130.75,14.26 133.61,14.26 134.25,13.61 138.54,13.61 139.36,14.43 160.57,14.43 161.65,15.51 161.65,15.9 162.35,16.59 164.57,16.59 167.17,19.2 171.05,19.2 176.23,14.01 180.04,14.01 v2(181.33,12.72)
  IN4 w0.508: v2(247.02,6.76) 246.68,7.11 242.21,7.11 241.2,6.1 227.23,6.1 226.05,4.92 186.54,4.92 184.28,7.18 v2(183.58,7.18)
  BOTTOM w0.102: PD1.3 44.64,30.26 44.31,29.94 44.31,28.2 v3(43.8,27.68)
  BOTTOM w0.508: v2(45.98,29.93) 45.65,30.26 PD1.3 ; v2(91.02,37.68) 91.67,37.02 91.67,19.58 92.88,18.37 103.93,18.37 105.71,16.59 v2(105.71,15.13)
+3.3V_RUN: length 943.2
  TOP w0.254: JEDP1.10 123.07,143.14 123.36,143.62 123.53,143.78 126.92,143.78 v2(127.53,144.39) ; R501.1 5.06,48.67 U88.3 ; U88.2 5.56,48.86 R502.1 ; CH10.1 144.98,123.72 144.82,123.57 144.3,123.57 144.19,123.68 UC3.5 ; U88.9 5.56,42.31 5.31,42.06 5.31,41.17 R504.1 6.06,41.69 U88.10
  TOP w0.381: R3744.1 170.92,99.26 171.13,99.05 171.13,98.49 171.53,98.09 171.6,98.09 ; R3739.1 244.21,102.43 243.76,102.89 Q366.2 ; v2(244.06,104.34) 243.76,104.64 Q366.5 ; 171.6,98.09 171.41,97.91 Q369.6 ; 171.6,98.09 v2(171.61,98.09) ; CH10.1 145.39,123.72 146.04,123.08 146.04,121.76 145.71,121.43 145.71,118.96 146.16,118.51 146.16,114.51 146.66,114 v2(146.66,112.73) ; Q369.3 172.71,96.49 v2(173.14,96.92)
  TOP w0.406: QH4.2 108.52,129.05 108.94,129.47 v2(108.98,129.47) ; QH4.5 v2(108.52,127.45)
  TOP w0.457: C497.1 150.12,94.1 v2(150.28,93.94) ; PR1114.1 263.56,44.22 264.38,44.22 264.49,44.11 264.71,43.89 265.07,43.53 265.12,43.48 266.37,43.48 266.6,43.71
  TOP w0.508: v2(183.05,140.16) 182.99,140.16 182.19,139.37 C783.1 ; v2(244.9,102.13) R3739.1 ; CV31.1 156.52,112.24 v2(156.49,112.22) ; RH213.2 139.83,123.92 RH199.2 ; R151.2 153.05,107.35 153.55,106.85 R149.2 ; R151.2 152.66,108.77 152.57,108.86 v2(152.54,108.86) ; R151.2 152.01,107.35 151.77,107.11 R152.2 ; R381.2 98.75,93.12 101.53,95.91 102.21,95.91 v2(102.36,95.76) ; RD61.1 44.57,9.8 v2(43.56,10.81) ; v2(111.8,6.43) 112.07,6.17 RD37.1 RD38.1 RD27.1 114.42,5.65 115.04,5.04 119.74,5.04 RD59.1 119.8,4.47 120.44,3.83 124.69,3.83 126.11,5.24 RD8.1 RD13.1 RD17.1 ; v2(119.44,128.9) RH133.2 RH132.2 ; v2(170.58,90.71) 170.85,90.99 C507.1 170.84,91.97 R105.2 ; v2(247.01,100.62) 246.69,100.95 R3738.1 ; C504.1 182.94,134.18 183.3,133.81 183.3,133.37 183.37,133.31 v2(183.37,133.28) ; R405.1 R408.1 237.06,90.41 237.18,90.52 237.18,91.84 236.82,92.2 236.82,92.42 236.82,92.46 v2(236.82,92.46) ; RH126.2 RH131.2 RH127.2 RH124.2 RH125.2 125.42,128.33 v2(125.42,128.88) ; C725.1 49.95,35.34 49.56,34.95 48.01,34.95 47.42,34.36 v2(47.42,34.02) ; v2(146.61,107.26) 146.61,107.94 146.63,107.94 R104.2 ; v2(146.61,107.26) 146.44,107.08 R126.2 ; v2(146.61,107.26) 146.62,107.27 147.11,107.27 147.32,107.06 R125.2 ; v2(105.07,104.99) 105.71,104.99 106.52,105.8 RH317.1 RH91.1 ; CV28.1 162.92,114.54 163.18,114.54 163.44,114.28 163.61,114.28 v2(163.61,114.29) ; C391.1 R504.1 v2(4.7,41.06) ; v2(20.93,29.31) R363.2 ; R413.1 239.29,89.78 v2(239.07,90) ; v2(167.72,118.47) 167.74,118.45 RV30.1 RV31.1 RV32.1 RV33.1 ; JUSH1.8 73.32,42.3 73.94,41.68 74.56,41.68 CZ11.1 v2(75.24,41.66) ; R503.1 9.43,44.15 R513.1 v4(10.44,44.85) ; C495.1 172.89,136.5 172.85,136.45 v2(172.83,136.45) ; R403.1 269.79,40.72 269.09,40.72 268.84,40.98 267.5,40.98 267.06,41.42 267.06,43.2 267.12,43.26 ; RV44.1 164.43,111.02 v2(165.19,111.78) 165.69,112.28 RV42.1 ; C496.1 152.97,95.57 153.84,94.7 153.84,94.03 v2(153.74,93.92) ; v2(171.17,143.53) 170.91,143.26 R2196.1 ; v2(189.34,112.78) 188.84,112.29 R783.2 ; v2(153.14,118.19) 153.19,118.14 CV27.1 ; C784.1 v2(152.27,142.85) 152.06,142.64 152.06,142.2 151.7,141.84 150.9,141.84 150.54,142.2 150.54,142.96 149.9,143.59 147.43,143.59 146.74,142.91 v2(145.06,142.91) R100.2 145.05,142.01 C502.1 ; v2(172.86,134.23) 173.51,134.88 C494.1 ; v2(256.01,87.71) 256.39,87.33 R407.1 ; RZ79.1 191.58,126.81 192,126.81 192.38,127.19 192.38,127.74 192.79,128.15 193.55,128.15 194.2,128.8 v2(195.05,128.8) 195.05,129.84 RZ77.1 ; v2(160.15,112.19) 160.15,111.24 159.19,110.28 RV29.1 ; RH199.2 138.95,123.81 138.47,123.34 v2(138.47,123.11) ; RH199.2 RH202.2 ; RH71.1 106.96,118.41 v2(106.5,118.87) 106.02,118.38 RH350.1 ; RD57.1 133.65,90.63 133.96,90.95 v2(133.96,91.4) ; v2(152.61,104.74) 152.61,104.27 152.3,103.95 C505.1 ; CV29.1 162.54,118.29 v2(162.42,118.4) ; C785.1 146.94,103.3 v2(146.6,103.65) ; R98.2 175.72,138.97 C499.1 175.71,140.26 v2(175.76,140.3) ; C503.1 147.63,97.72 R102.2 147.21,97.75 146.85,97.38 v2(146.85,97.09) 145.63,97.09 145.27,96.73 145.27,95.79 146,95.05 147.98,95.05 148.38,94.66 C497.1 ; R383.1 298.75,6.09 R387.1 298.75,6.8 298.43,7.12 v2(298.43,7.68) ; RH321.1 v2(4.79,52.2) ; v2(166.3,139.2) 166.88,139.78 R2195.1 ; v2(164.66,91.21) 164.47,91.21 163.78,91.89 163.78,93.39 C506.1 163.71,93.85 164.2,94.34 C786.1 164.2,95.89 163.42,96.68 v2(162.92,96.68) ; v2(143.36,140.1) 143.56,139.9 C501.1 143.54,139.34 C500.1 143.54,135.45 v2(142.79,134.7) 142.54,134.45 R426.1 142.14,133.59 R382.1 ; R501.1 R502.1 5.68,49.41 C392.1 7.09,50.12 v2(7.15,50.06) ; v2(7.62,39.78) 8.01,39.4 U639.5 ; v2(152.06,140.04) 152.06,138.77 152.86,137.97 C554.1 RV49.1 153.68,136.64 RV47.1 ; RH347.2 111.41,132.1 110.11,133.4 108.36,133.4 106.71,131.74 105.57,131.74 v2(105.4,131.91) 106.09,132.59 106.09,134.6 105.13,135.55 v2(105.13,137.12) ; v2(258.25,94.91) 258.25,95.86 R410.1 ; R409.1 v2(255.96,92.32)
  IN1 w0.508: v2(106.85,158.26) 107.29,157.82 113.11,157.82 v2(113.94,156.99) 114.02,156.99 114.5,156.52 114.5,152.32 116.12,150.71 122.62,150.71 v2(123.82,149.51) ; v2(108.98,129.47) 106.11,129.47 v2(105.39,130.2) ; v2(255.96,92.32) 257,91.28 257,88.26 256.46,87.71 v2(256.01,87.71) ; v2(146.85,97.09) 146.05,97.88 146.05,103.11 v2(146.6,103.65) 146.1,104.15 146.1,106.54 146.61,107.06 v2(146.61,107.26) ; v2(106.6,89.71) 106.6,90.27 106.78,90.45 112.94,90.45 v2(113.82,91.33)
  IN2 w0.508: v2(243.75,86.22) 243.63,86.22 239.86,90 v2(239.07,90) 236.82,92.25 v2(236.82,92.46) ; v2(162.92,96.68) 162.92,97.24 161.81,98.35 157.81,98.35 154.03,94.57 153.9,94.57 ; v2(164.66,91.21) 164.66,91.6 164.83,91.77 165.9,91.77 166.29,91.38 166.29,90.7 166.81,90.18 170.04,90.18 v2(170.58,90.71) 170.93,91.06 170.93,91.59 171.49,92.16 174.29,92.16 176.13,94 v2(176.13,94.06) ; v2(153.74,93.92) 153.84,94.03 153.84,94.51 153.9,94.57 ; v2(43.56,10.81) 43.56,17.95 40.43,21.08 40.43,22.12 39.96,22.59 39.96,24.02 38.31,25.67 v2(38.31,25.75) ; 153.9,94.57 153.59,94.89 151.24,94.89 v2(150.28,93.94) 150.28,94.2 149.91,94.57 148.89,94.57 148.37,94.05 148.37,91.18 148.73,90.81 148.73,88.69 148.45,88.41 143.74,88.41 142.3,89.86 142.3,92.02 140.9,93.41 136.95,93.41 136.54,93 135.56,93 v2(133.96,91.4) 133.96,91.02 133.51,90.56 131.95,90.56 131.69,90.82 131.16,90.82 130.87,90.53 130.13,90.53 v2(129.2,91.46) ; v2(173.14,96.92) 172.77,96.92 171.6,98.09 v2(171.61,98.09) ; v2(100.35,99.6) 100.63,99.32 100.63,97.49 v2(102.36,95.76) ; v2(211.37,102.84) 215.05,102.84 215.78,102.11 217.76,102.11 218.25,102.6 218.25,102.74 219.47,103.96 220.04,103.96 222.25,106.17 222.69,106.17 222.9,106.38 225.3,106.38 226.49,107.58 226.49,107.8 226.85,108.16 v2(226.87,108.16) ; v2(113.82,91.33) 113.82,91.7 114.09,91.97 123.74,91.97 124.48,91.23 v2(124.48,91.21)
  IN3 w0.381: v2(127.53,144.39) 127.63,144.49 127.63,144.99 123.82,148.79 v2(123.82,149.51)
  IN3 w0.508: 105.13,138.96 108.09,141.91 108.95,141.91 v2(110.53,143.49) ; 105.13,138.96 98.78,138.96 v2(98.3,138.48) ; 105.13,138.96 v2(105.13,137.12) ; v2(176.13,94.06) 176.13,94.09 175.61,94.61 175.61,98.42 176.37,99.18 v2(176.37,99.19) ; v2(211.12,149.94) 210.21,149.04 210.21,146.77 215.56,141.43 221,141.43 225.44,136.99 225.44,133.39 225.98,132.86 225.98,112.62 226.93,111.67 226.93,110.48 227.42,109.99 227.42,108.85 226.87,108.29 v2(226.87,108.16) ; v2(106.5,118.87) 106.5,119.38 107.98,120.86 107.98,121.23 108.39,121.64 108.82,121.64 109.63,120.82 109.63,120.21 110.19,119.65 111.54,119.65 111.94,119.25 v2(111.94,118.46)
  IN4 w0.508: v2(195.05,128.8) 195.97,128.8 196.7,128.06 201.76,128.06 v2(202.48,127.34) ; v2(211.12,149.94) 211.12,149.56 210.67,149.12 205.1,149.12 203.14,147.16 202.24,147.16 202.23,147.16 202.18,147.16 202.17,147.16 197.08,147.16 193.72,150.51 v2(192.43,150.51) ; v2(108.52,127.45) 108.52,129.02 v2(108.98,129.47) ; v2(111.8,6.43) 111.8,7.83 110.66,8.97 92.43,8.97 90.64,10.76 90.64,13.94 90.91,14.2 90.91,20.98 83.61,28.28 83.61,34.63 82.02,36.22 77.07,36.22 74.65,38.63 74.65,41.08 v2(75.24,41.66) ; v2(278.39,27.38) 279.63,27.38 281.32,25.69 289.08,25.69 294.29,20.48 295.08,20.48 299.93,15.63 299.93,9.57 298.43,8.07 v2(298.43,7.68) ; v2(20.93,29.31) 20.93,28.9 21.76,28.07 21.76,26.76 24.08,24.43 29.38,24.43 29.6,24.66 30.99,24.66 31.63,24.02 34.09,24.02 35.13,25.06 37.62,25.06 v2(38.31,25.75) 38.81,26.25 38.81,27.03 39.93,28.15 39.93,29.08 42.29,31.44 42.29,31.84 43.93,33.48 46.89,33.48 v2(47.42,34.02)
  BOTTOM w0.203: U636.60 163.34,96.44 163.1,96.68 v2(162.92,96.68) ; UV2.21 153.06,113.88 152.92,113.74 152.92,112.8 152.49,112.38 152.49,112.08 152.32,111.91 152.32,111.46 v2(152.33,111.46) ; U629.26 172.93,136.51 172.92,136.52 172.89,136.52 v2(172.83,136.45) ; v2(152.92,133.61) 152.92,133.69 153.26,134.02 153.26,134.26 153.14,134.38 U630.60 ; UV2.30 153.09,117.49 153.02,117.55 153.03,117.56 153.03,117.94 153.01,117.95 153.01,118 153.14,118.13 v2(153.14,118.19) ; U631.21 152.43,94.82 152.57,94.95 153.4,94.95 153.74,94.62 v2(153.74,93.92) ; U629.35 175.99,139.48 175.81,139.66 175.81,140.25 v2(175.76,140.3) ; U631.35 147.81,97.09 v2(146.85,97.09) ; U630.26 143.07,136.38 142.98,136.29 142.98,134.89 v2(142.79,134.7) 143.12,134.38 U630.21 ; U636.49 164.98,91.65 164.66,91.33 v2(164.66,91.21) ; v2(183.05,140.16) 182.48,140.16 181.59,139.27 U629.49 ; C508.1 174.22,97.43 174.16,97.37 173.62,97.37 173.17,96.92 v2(173.14,96.92) 173.38,96.68 173.38,96.6 173.21,96.44 U636.21 ; v2(172.86,134.23) 173.05,134.23 173.33,134.51 U629.21 ; v2(183.37,133.28) 183.37,133.57 183.62,133.83 183.62,134.32 183.44,134.51 U629.60 ; v2(145.77,139.66) 146.01,139.42 U630.35 ; UV2.5 160.09,112.25 v2(160.15,112.19) ; UV2.51 162.77,117.49 162.93,117.65 162.93,118.13 162.67,118.4 v2(162.42,118.4) ; U636.35 v2(170.58,90.71) ; U631.60 152.39,103.79 152.61,104.01 v2(152.61,104.74) ; U631.49 147.35,102.7 146.6,103.45 146.6,103.64 v2(146.6,103.65) ; U636.26 173.39,94.44 173.52,94.57 174.42,94.57 C509.1 ; U631.26 150.11,94.17 150.28,94 v2(150.28,93.94) ; U630.49 151.61,139.14 151.93,139.47 151.93,139.72 152.06,139.85 v2(152.06,140.04) ; UV2.57 162.85,115.09 163.61,114.33
  BOTTOM w0.254: RP3.4 189.34,111.54 189.56,111.75 ; 189.56,111.75 189.27,112.04 RP3.3 ; 189.56,111.75 v2(189.55,111.75) ; RV43.1 153.06,109.38 v2(152.54,108.86) ; 189.15,112.78 188.89,113.04 RP3.1 ; 189.15,112.78 v2(189.34,112.78) ; 189.15,112.78 188.91,112.54 RP3.2
  BOTTOM w0.305: JLPDE1.1 202.63,127.18 v2(202.48,127.34) 202.83,127.68 JLPDE1.2
  BOTTOM w0.381: C248.1 106.47,157.17 106.47,156.74 106.76,156.45 U3.5 ; Q343.3 166.71,137.67 166.54,137.5 v2(166.54,136.76) ; v2(166.3,139.2) 166.07,138.97 Q343.6 ; v2(176.13,94.06) 175.05,94.06 174.83,94.29 174.83,94.59 C509.1
  BOTTOM w0.508: v2(113.82,91.33) RD52.1 RD53.1 RD51.1 ; v2(105.07,104.99) 103.99,106.07 103.99,108.29 104.63,108.92 RH90.1 ; R118.2 R117.2 185.92,134.53 v2(186.03,134.64) ; RH319.1 143.02,117.7 v2(143.04,117.68) ; v2(162.92,96.68) 162.49,97.11 161.52,97.11 161.19,96.78 R159.2 R161.2 R162.2 R107.2 R153.2 R154.2 ; RD60.1 106.37,89.94 v2(106.6,89.71) ; v2(151.05,111.46) 150.79,111.46 150.26,110.93 R2194.1 ; v2(146.66,112.73) 146.66,113.81 145.98,114.5 R3737.1 ; v2(168.4,110.43) 169.24,109.59 169.24,108.43 169.89,107.78 R782.2 ; RC79.2 RH207.1 112.68,119.1 RH354.1 112.68,118.71 112.42,118.46 v2(111.94,118.46) 111.94,119.4 111.31,120.04 RH355.1 ; v2(110.53,143.49) 110.39,143.49 110.15,143.73 110.15,148.11 110.46,148.42 112.11,148.42 113.7,150.01 113.7,152.27 112.34,153.63 v3(112.34,154.05) 112.34,154.41 112.79,154.87 R339.1 113.74,155.64 113.94,155.84 v2(113.94,156.99) ; RH79.1 RH331.1 119.44,128.87 v2(119.44,128.9) 119.22,129.13 RH339.1 ; RV34.1 v2(165.19,111.78) ; v2(75.24,41.66) 74.44,41.66 73.64,42.46 67.15,42.46 63.39,38.7 61.55,38.7 59.49,36.65 52.73,36.65 52.17,37.21 52.17,41.38 51.44,42.11 51.44,47.98 52.17,48.71 52.17,50.31 51.23,51.25 50.47,51.25 47.82,53.91 47.82,62.69 45.6,64.92 ; RD19.1 138.8,91.83 138.33,92.3 130.05,92.3 v2(129.2,91.46) 129.37,91.29 RD20.1 RD26.1 128.41,90.7 126.32,90.7 126.06,90.44 RD58.1 124.99,90.72 124.49,91.21 v2(124.48,91.21) ; RH340.2 RH223.2 RH222.2 134.85,124.8 v2(135.11,125.05) ; v2(106.15,111.7) 106.15,112.39 RH76.1 105.9,112.7 RH318.1 ; R142.2 R140.2 156.27,132.65 156.07,132.45 156.07,132.11 v2(156.07,132.1) ; v2(138.47,115.65) 138.47,114.7 138.22,114.45 134.46,114.45 RH302.1 ; v2(106.85,158.26) 106.85,157.55 C248.1 ; v2(150.22,114.83) 150.16,114.83 149.76,115.22 R2198.1 ; v2(247.01,100.62) 246.4,100.62 v2(244.9,102.13) 244.37,102.66 244.37,103.56 244.06,103.87 v2(244.06,104.34) 243.96,104.44 243.96,105.72 241.35,108.33 234.23,108.33 233.62,107.72 232.54,107.72 231.67,108.59 227.44,108.59 227.01,108.16 v2(226.87,108.16) ; R379.1 180.05,118.79 179.52,119.32 v2(179.52,120.6) ; R99.2 R124.2 185.96,136.43 v2(186.1,136.29) ; C508.1 174.72,98.06 175.42,98.76 175.94,98.76 v2(176.37,99.19) ; R722.1 v2(167.73,134.83) ; v2(145.06,142.91) 143.36,141.21 v2(143.36,140.1) ; R119.2 185.38,138.62 186.41,139.66 v2(186.35,139.66) 186.05,139.66 185.72,139.98 185.72,140.22 R120.2 ; RE67.1 212.07,103.54 v2(211.37,102.84) ; v2(152.61,104.74) 152.61,105.2 152.32,105.49 150.59,105.49 149.64,106.45 147.43,106.45 v2(146.61,107.26) ; v2(156.91,136.48) 156.6,136.16 R109.2 R143.2 ; v2(105.39,130.2) 106.66,130.2 106.98,130.52 RH220.2 RH221.2 106.92,132.12 105.61,132.12 v2(105.4,131.91) ; v2(163.61,114.29) 163.61,114.45 CV30.1 ; R2197.1 148.25,122.08 v2(148.25,121.05) 148.3,121.1 149.61,121.1 R3736.1 ; v2(135.74,125.88) 135.23,126.39 RH224.2 RH225.2 ; R127.2 R133.2 156.27,140.14 v2(156.14,140.27) ; Q24.3 98.96,130.55 C301.1 97.92,136.98 98.3,137.36 v2(98.3,138.48)
  vias: v2(34.52,12.29) v2(34.55,11.65) v2(35.21,12.31) v2(35.21,11.7) v2(35.82,11.73) v2(250.69,82.01) v2(251.3,82) v2(251.31,81.41) v2(251.76,80.98) v2(251.88,81.87) v2(252.42,81.61) v2(253.53,101.94) v2(253.53,101.3) v2(253.53,100.67) v2(254.12,101.94) v2(254.17,101.24) v2(254.17,100.6) v2(266.3,45.68) v2(266.78,45.06) v2(266.79,44.39) v2(266.93,45.68) v2(267.44,45.04) v2(267.44,44.41) v2(277.22,26.82) v2(277.22,26.21) v2(277.22,25.6) v2(277.22,24.96) v2(277.73,27.38) v2(286.2,30.2) v2(286.2,29.56) v2(305.29,34.44) v2(305.29,33.8) v2(305.92,34.44) v2(305.92,33.8) v2(306.56,34.44) v2(306.56,33.8) v2(307.13,34.12)
+3.3V_RUN_ATS: length 6.2
  TOP w0.152: UH1.AD13 129.13,113.95 129.39,114.29 v2(129.41,114.29)
  BOTTOM w0.508: RH302.2 CH36.1 v1(130.66,113.56) 129.75,113.56 129.41,113.91 v2(129.41,114.29)
+3.3V_RUN_DIMM1: length 19.4
  TOP w0.305: JDIMM1.255 134.56,80.67 135.52,79.72 135.52,79.24
  TOP w0.508: 135.52,79.24 136.01,78.74 CD22.1 CD21.1 137.01,79.61 137.34,79.93 137.34,86.45 137.48,86.59 137.48,86.59 137.85,86.96 137.85,86.97 137.88,87 137.88,88.49 137.23,89.14 137.23,89.69 136.87,90.05 v1(136.3,90.05) 135.54,90.05 RD57.2
+3.3V_RUN_DIMM2: length 15.8
  TOP w0.508: v2(122.96,87.8) 123.17,88.01 CD26.1 CD29.1
  IN1 w0.508: v2(122.17,82.47) 122.17,82.77 122.16,82.76 122.16,87 v2(122.96,87.8)
  BOTTOM w0.305: JDIMM2.255 123.48,80.67 123.31,80.84 123.31,82.18 123.02,82.47 v2(122.17,82.47)
  BOTTOM w0.508: v1(126.32,89.05) RD58.2 124.99,88.84 123.96,87.8 v2(122.96,87.8)
+3.3V_RUN_DIMM3: length 104.9
  TOP w0.305: JDIMM3.255 119.94,80.67 120.39,81.12 120.39,82.37 v2(120.31,82.44)
  TOP w0.508: RD59.2 121.2,5.75 CD47.1 CD44.1 v1(121.64,7.13) 122,7.13 122.38,7.51 v2(122.38,9.1)
  IN1 w0.508: v2(120.31,82.44) 118.54,82.44 116.44,80.34 116.44,79.2 115.8,78.57 111.74,78.57 110.21,77.05 110.21,59.14 109.01,57.93 108.16,57.93 107.27,57.04 107.27,48.87 106.32,47.92 106.32,40.57 105.15,39.4 105.15,17.85 111.1,11.89 116.27,11.89 119.68,8.49 121.77,8.49 v2(122.38,9.1)
+3.3V_RUN_DIMM4:
  vias: v1(104.12,89.05)
+3.3V_RUN_PWR:
  vias: v1(301.84,32.92)
+3.3V_SPI: length 243.4
  TOP w0.508: v2(164.02,125.93) 163.61,126.35 RH335.2 ; v2(163.59,116.97) 163.59,117.03 163.42,117.2 163.42,118 163.26,118.16 163.26,118.71 163.71,119.16 164.44,119.16 164.91,119.63 v2(164.91,121.19) ; v2(152.02,20.28) 152.02,17.39 RC5.1
  IN1 w0.508: v2(163.59,116.97) 163.42,117.14 162.92,117.14 161.46,115.68 160.84,115.68 155.45,110.29 148.75,110.29 145.84,107.39 145.84,107.18 145.42,106.76 145.42,97.52 143.48,95.58 v2(143.48,93.11) ; v2(103.79,72.5) 103.86,72.58 103.86,82.75 104.83,83.71 105.69,83.71 109.06,87.08 114.6,87.08 115.36,87.84 115.36,88.58 116.61,89.83 118.11,89.83 118.11,89.83 124.73,89.83 125.59,90.7 v2(125.59,91.16)
  IN2 w0.508: v2(103.79,72.5) 103.79,72.65 104.25,73.11 105.33,73.11 106.21,74 115.99,74 119.42,77.43 123.36,77.43 124.44,78.51 134.34,78.51 134.47,78.63 134.59,78.63 134.6,78.63 135.1,78.63 135.11,78.63 136.88,78.63 140.95,74.57 140.95,61.49 152.02,50.41 v2(152.02,20.28) ; v2(143.48,93.11) 142.54,94.05 136.69,94.05 136.27,93.63 134.79,93.63 133.32,92.16 128.6,92.16 127.6,91.15 125.6,91.15 125.59,91.16 v2(125.59,91.16) ; v2(176.84,122.83) 176.01,122.83 175.56,122.37 171.3,122.37 170,121.08 169.21,121.08 v2(168.67,121.61) 168.05,121.61 167.58,121.14 164.96,121.14 v2(164.91,121.19)
  BOTTOM w0.305: RH185.2 164.84,122.9 164.12,123.62 JSPI1.15 164.12,125.82 164.02,125.92 v2(164.02,125.93)
  BOTTOM w0.381: R3668.1 170.13,122.91 169.92,123.12 169.36,123.12 168.62,122.38 168.62,121.66 v2(168.67,121.61)
  BOTTOM w0.457: v2(176.84,122.83) 176.84,122.61 177.58,121.87 178.52,121.87 178.9,121.48 179.65,121.48 C1216.1
  BOTTOM w0.508: R3666.1 R3665.1 178.06,124.05 v2(176.84,122.83) ; U52.8 173.19,121.76 172.95,122 172.44,122 172.13,121.69 172.13,121.37 171.77,121.01 C746.1 170.81,121.01 170.42,120.62 v3(169.99,120.62) 169.66,120.62 v2(168.67,121.61) ; v2(164.91,121.19) 164.84,121.26 RH185.2 ; U53.8 181.89,121.7 181.65,121.94 181.27,121.94 181.07,121.74 181.07,121.2 180.81,120.95 C1216.1 ; R3664.1 R3668.1
