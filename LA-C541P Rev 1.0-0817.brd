# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
BQ24780RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_EEEFK1E101YP
  oval 3.2x1.6 smd: 1(0,0) 2(5,0)
CD3301RHHR_QFN36_6X6
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 19(4,5.8) 20(3.5,5.8) 21(3,5.8) 22(2.5,5.8) 23(2,5.8) 24(1.5,5.8) 25(1,5.8) 26(0.5,5.8) 27(0,5.8)
  oval 1.194x0.254 smd: 10(4.9,0.9) 11(4.9,1.4) 12(4.9,1.9) 13(4.9,2.4) 14(4.9,2.9) 15(4.9,3.4) 16(4.9,3.9) 17(4.9,4.4) 18(4.9,4.9) 28(-0.9,4.9) 29(-0.9,4.4) 30(-0.9,3.9) 31(-0.9,3.4) 32(-0.9,2.9) 33(-0.9,2.4) 34(-0.9,1.9) 35(-0.9,1.4) 36(-0.9,0.9)
  rect 4.089x4.089 smd: 37(2,2.9)
CHENG_SMB3025500YA_2P
  rect 2.997x1.803 smd: 1(0,0) 2(4,0)
CY8C4245AXI-483_TQFP44_10X10
  oval 1.753x0.457 smd: 1(0,0) 2(0,-0.8) 3(0,-1.6) 4(0,-2.4) 5(0,-3.2) 6(0,-4) 7(0,-4.8) 8(0,-5.6) 9(0,-6.4) 10(0,-7.2) 11(0,-8) 23(11.654,-8) 24(11.654,-7.2) 25(11.654,-6.4) 26(11.654,-5.6) 27(11.654,-4.8) 28(11.654,-4) 29(11.654,-3.2) 30(11.654,-2.4) 31(11.654,-1.6) 32(11.654,-0.8) 33(11.654,0)
  oval 0.457x1.753 smd: 12(1.827,-9.827) 13(2.627,-9.827) 14(3.427,-9.827) 15(4.227,-9.827) 16(5.027,-9.827) 17(5.827,-9.827) 18(6.627,-9.827) 19(7.427,-9.827) 20(8.227,-9.827) 21(9.027,-9.827) 22(9.827,-9.827) 34(9.827,1.827) 35(9.027,1.827) 36(8.227,1.827) 37(7.427,1.827) 38(6.627,1.827) 39(5.827,1.827) 40(5.027,1.827) 41(4.227,1.827) 42(3.427,1.827) 43(2.627,1.827) 44(1.827,1.827)
CYNTE_PCME064T-R15MS_4P
  custom 0.686x0.686 smd: 1(0,0) 4(8.509,0)
  rect 2.362x0.508 smd: 2(1.448,0) 3(7.061,0)
D_0603
  oval 0.864x1.219 smd: 1(-0.711,0) 2(0.711,0)
DDTA114EUA-7-F_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMP3050LVT-7_TSOT26-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.199) 5(0.95,2.199) 6(0,2.199)
E-T_6712K-Y20N-07L_20P
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.803x1.397 smd: 21(11.15,-2.65) 22(-1.65,-2.65)
ECE5048-LZY_DQFN132_11X11
  oval 0.279x0.737 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.737x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.318x0.61 smd: B1(-0.25,0.855) B2(0.25,0.855) B3(0.75,0.855) B4(1.25,0.855) B5(1.75,0.855) B6(2.25,0.855) B7(2.75,0.855) B8(3.25,0.855) B9(3.75,0.855) B10(4.25,0.855) B11(4.75,0.855) B12(5.25,0.855) B13(5.75,0.855) B14(6.25,0.855) B15(6.75,0.855) B16(7.25,0.855) B17(7.75,0.855) B35(7.75,10.045) B36(7.25,10.045) B37(6.75,10.045) B38(6.25,10.045) B39(5.75,10.045) B40(5.25,10.045) B41(4.75,10.045) B42(4.25,10.045) B43(3.75,10.045) B44(3.25,10.045) B45(2.75,10.045) B46(2.25,10.045) B47(1.75,10.045) B48(1.25,10.045) B49(0.75,10.045) B50(0.25,10.045) B51(-0.25,10.045)
  oval 0.61x0.318 smd: B18(8.345,1.45) B19(8.345,1.95) B20(8.345,2.45) B21(8.345,2.95) B22(8.345,3.45) B23(8.345,3.95) B24(8.345,4.45) B25(8.345,4.95) B26(8.345,5.45) B27(8.345,5.95) B28(8.345,6.45) B29(8.345,6.95) B30(8.345,7.45) B31(8.345,7.95) B32(8.345,8.45) B33(8.345,8.95) B34(8.345,9.45) B52(-0.845,9.45) B53(-0.845,8.95) B54(-0.845,8.45) B55(-0.845,7.95) B56(-0.845,7.45) B57(-0.845,6.95) B58(-0.845,6.45) B59(-0.845,5.95) B60(-0.845,5.45) B61(-0.845,4.95) B62(-0.845,4.45) B63(-0.845,3.95) B64(-0.845,3.45) B65(-0.845,2.95) B66(-0.845,2.45) B67(-0.845,1.95) B68(-0.845,1.45)
  rect 5.105x5.105 smd: C1(3.75,5.45)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
FDMC7692S_MLP8-5
  oval 0.432x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.537x0.537 smd: 5(0.975,2.075)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_QL01723-D265G1-8H_144P
  round 1.092 hole 1.092 unplated: (-1.475,-0.6)
  oval 1.397x1.092 hole 1.397x1.092 unplated: (38.975,-7.4)
  oval 0.254x1.803 smd: 1(0,0) 2(0,-8) 3(0.5,0) 4(0.5,-8) 5(1,0) 6(1,-8) 7(1.5,0) 8(1.5,-8) 9(2,0) 10(2,-8) 11(2.5,0) 12(2.5,-8) 13(3,0) 14(3,-8) 15(3.5,0) 16(3.5,-8) 17(4,0) 18(4,-8) 19(4.5,0) 20(4.5,-8) 21(5,0) 22(5,-8) 23(5.5,0) 24(5.5,-8) 25(6,0) 26(6,-8) 27(6.5,0) 28(6.5,-8) 29(7,0) 30(7,-8) 31(7.5,0) 32(7.5,-8) 33(8,0) 34(8,-8) 35(8.5,0) 36(8.5,-8) 37(9,0) 38(9,-8) 39(9.5,0) 40(9.5,-8) 41(10,0) 42(10,-8) 43(10.5,0) 44(10.5,-8) 45(11,0) 46(11,-8) 47(11.5,0) 48(11.5,-8) 49(12,0) 50(12,-8) 51(13.5,0) 52(13.5,-8) 53(14,0) 54(14,-8) 55(14.5,0) 56(14.5,-8) 57(15,0) 58(15,-8) 59(15.5,0) 60(15.5,-8) 61(16,0) 62(16,-8) 63(16.5,0) 64(16.5,-8) 65(17,0) 66(17,-8) 67(17.5,0) 68(17.5,-8) 69(18,0) 70(18,-8) 71(18.5,0) 72(18.5,-8) 73(19,0) 74(19,-8) 75(19.5,0) 76(19.5,-8) 77(20,0) 78(20,-8) 79(20.5,0) 80(20.5,-8) 81(21,0) 82(21,-8) 83(21.5,0) 84(21.5,-8) 85(22,0) 86(22,-8) 87(22.5,0) 88(22.5,-8) 89(23,0) 90(23,-8) 91(23.5,0) 92(23.5,-8) 93(24,0) 94(24,-8) 95(25.5,0) 96(25.5,-8) 97(26,0) 98(26,-8) 99(26.5,0) 100(26.5,-8) 101(27,0) 102(27,-8) 103(27.5,0) 104(27.5,-8) 105(28,0) 106(28,-8) 107(28.5,0) 108(28.5,-8) 109(29,0) 110(29,-8) 111(29.5,0) 112(29.5,-8) 113(30,0) 114(30,-8) 115(30.5,0) 116(30.5,-8) 117(31,0) 118(31,-8) 119(31.5,0) 120(31.5,-8) 121(32,0) 122(32,-8) 123(32.5,0) 124(32.5,-8) 125(33,0) 126(33,-8) 127(33.5,0) 128(33.5,-8) 129(34,0) 130(34,-8) 131(34.5,0) 132(34.5,-8) 133(35,0) 134(35,-8) 135(35.5,0) 136(35.5,-8) 137(36,0) 138(36,-8) 139(36.5,0) 140(36.5,-8) 141(37,0) 142(37,-8) 143(37.5,0) 144(37.5,-8)
  oval 1.016x2.896 hole 0.711x2.591: 145(-6.425,-4) 148(43.925,-4)
  oval 1.295x1.016 hole 0.991x0.711: 146(-1.475,-2.725) 147(-1.475,-5.275) 149(38.975,-2.725) 150(38.975,-5.275)
  oval 3.302x1.067 hole 2.997x0.762: 151(-5.75,-0.075) 154(43.25,-0.075) 155(-5.75,-7.925) 162(43.25,-7.925)
  oval 1.295x1.143 hole 0.991x0.838: 152(12.75,-0.075) 153(24.75,-0.075) 160(12.75,-7.925) 161(24.75,-7.925)
  round 1.295 hole 0.991: 156(0.75,-4) 157(12.75,-4) 158(24.75,-4) 159(36.75,-4)
FOX_QT50A01-29100-9H_100P-T-S
  round 0.762 hole 0.762 unplated: (-0.5,-1.8)
  round 0.94 hole 0.94 unplated: (25,-1.8)
  oval 0.305x1.6 smd: 1(0,0) 2(0,-3.6) 3(0.5,0) 4(0.5,-3.6) 5(1,0) 6(1,-3.6) 7(1.5,0) 8(1.5,-3.6) 9(2,0) 10(2,-3.6) 11(2.5,0) 12(2.5,-3.6) 13(3,0) 14(3,-3.6) 15(3.5,0) 16(3.5,-3.6) 17(4,0) 18(4,-3.6) 19(4.5,0) 20(4.5,-3.6) 21(5,0) 22(5,-3.6) 23(5.5,0) 24(5.5,-3.6) 25(6,0) 26(6,-3.6) 27(6.5,0) 28(6.5,-3.6) 29(7,0) 30(7,-3.6) 31(7.5,0) 32(7.5,-3.6) 33(8,0) 34(8,-3.6) 35(8.5,0) 36(8.5,-3.6) 37(9,0) 38(9,-3.6) 39(9.5,0) 40(9.5,-3.6) 41(10,0) 42(10,-3.6) 43(10.5,0) 44(10.5,-3.6) 45(11,0) 46(11,-3.6) 47(11.5,0) 48(11.5,-3.6) 49(12,0) 50(12,-3.6) 51(12.5,0) 52(12.5,-3.6) 53(13,0) 54(13,-3.6) 55(13.5,0) 56(13.5,-3.6) 57(14,0) 58(14,-3.6) 59(14.5,0) 60(14.5,-3.6) 61(15,0) 62(15,-3.6) 63(15.5,0) 64(15.5,-3.6) 65(16,0) 66(16,-3.6) 67(16.5,0) 68(16.5,-3.6) 69(17,0) 70(17,-3.6) 71(17.5,0) 72(17.5,-3.6) 73(18,0) 74(18,-3.6) 75(18.5,0) 76(18.5,-3.6) 77(19,0) 78(19,-3.6) 79(19.5,0) 80(19.5,-3.6) 81(20,0) 82(20,-3.6) 83(20.5,0) 84(20.5,-3.6) 85(21,0) 86(21,-3.6) 87(21.5,0) 88(21.5,-3.6) 89(22,0) 90(22,-3.6) 91(22.5,0) 92(22.5,-3.6) 93(23,0) 94(23,-3.6) 95(23.5,0) 96(23.5,-3.6) 97(24,0) 98(24,-3.6) 99(24.5,0) 100(24.5,-3.6)
  rect 1.092x1.803 smd: 101(-2.175,-1.8) 102(26.675,-1.8)
FOX_QT50A61-29100-9H_160P-T-S
  round 0.762 hole 0.762 unplated: (-0.5,1.8)
  round 0.94 hole 0.94 unplated: (40,1.8)
  oval 0.305x1.6 smd: 1(0,0) 2(0,3.6) 3(0.5,0) 4(0.5,3.6) 5(1,0) 6(1,3.6) 7(1.5,0) 8(1.5,3.6) 9(2,0) 10(2,3.6) 11(2.5,0) 12(2.5,3.6) 13(3,0) 14(3,3.6) 15(3.5,0) 16(3.5,3.6) 17(4,0) 18(4,3.6) 19(4.5,0) 20(4.5,3.6) 21(5,0) 22(5,3.6) 23(5.5,0) 24(5.5,3.6) 25(6,0) 26(6,3.6) 27(6.5,0) 28(6.5,3.6) 29(7,0) 30(7,3.6) 31(7.5,0) 32(7.5,3.6) 33(8,0) 34(8,3.6) 35(8.5,0) 36(8.5,3.6) 37(9,0) 38(9,3.6) 39(9.5,0) 40(9.5,3.6) 41(10,0) 42(10,3.6) 43(10.5,0) 44(10.5,3.6) 45(11,0) 46(11,3.6) 47(11.5,0) 48(11.5,3.6) 49(12,0) 50(12,3.6) 51(12.5,0) 52(12.5,3.6) 53(13,0) 54(13,3.6) 55(13.5,0) 56(13.5,3.6) 57(14,0) 58(14,3.6) 59(14.5,0) 60(14.5,3.6) 61(15,0) 62(15,3.6) 63(15.5,0) 64(15.5,3.6) 65(16,0) 66(16,3.6) 67(16.5,0) 68(16.5,3.6) 69(17,0) 70(17,3.6) 71(17.5,0) 72(17.5,3.6) 73(18,0) 74(18,3.6) 75(18.5,0) 76(18.5,3.6) 77(19,0) 78(19,3.6) 79(19.5,0) 80(19.5,3.6) 81(20,0) 82(20,3.6) 83(20.5,0) 84(20.5,3.6) 85(21,0) 86(21,3.6) 87(21.5,0) 88(21.5,3.6) 89(22,0) 90(22,3.6) 91(22.5,0) 92(22.5,3.6) 93(23,0) 94(23,3.6) 95(23.5,0) 96(23.5,3.6) 97(24,0) 98(24,3.6) 99(24.5,0) 100(24.5,3.6) 101(25,0) 102(25,3.6) 103(25.5,0) 104(25.5,3.6) 105(26,0) 106(26,3.6) 107(26.5,0) 108(26.5,3.6) 109(27,0) 110(27,3.6) 111(27.5,0) 112(27.5,3.6) 113(28,0) 114(28,3.6) 115(28.5,0) 116(28.5,3.6) 117(29,0) 118(29,3.6) 119(29.5,0) 120(29.5,3.6) 121(30,0) 122(30,3.6) 123(30.5,0) 124(30.5,3.6) 125(31,0) 126(31,3.6) 127(31.5,0) 128(31.5,3.6) 129(32,0) 130(32,3.6) 131(32.5,0) 132(32.5,3.6) 133(33,0) 134(33,3.6) 135(33.5,0) 136(33.5,3.6) 137(34,0) 138(34,3.6) 139(34.5,0) 140(34.5,3.6) 141(35,0) 142(35,3.6) 143(35.5,0) 144(35.5,3.6) 145(36,0) 146(36,3.6) 147(36.5,0) 148(36.5,3.6) 149(37,0) 150(37,3.6) 151(37.5,0) 152(37.5,3.6) 153(38,0) 154(38,3.6) 155(38.5,0) 156(38.5,3.6) 157(39,0) 158(39,3.6) 159(39.5,0) 160(39.5,3.6)
  rect 1.092x1.803 smd: 161(-2.175,1.8) 162(41.675,1.8)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H_2P1
  round 2.616 hole 2.108: 1(0,0)
H_2P6X2P1
  oval 3.099x2.616 hole 2.591x2.108: 1(0,0)
H_2P6X2P1N
  oval 2.591x2.108 hole 2.591x2.108 unplated: (0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P8
  round 4.318 hole 3.81: 1(0,0)
IMD2AT-108_SC74-6
  oval 0.508x1.473 smd: 1(0,0) 2(-0.95,0) 3(-1.9,0) 4(-1.9,2.55) 5(-0.95,2.55) 6(0,2.55)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
JAE_MM70-314-310B1-1-_310P-S
  round 1.092 hole 1.092 unplated: (-1,5.2)
  round 1.6 hole 1.6 unplated: (81,5.2)
  oval 0.305x1.499 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(5.5,0) 20(5.75,8.2) 21(6,0) 22(6.25,8.2) 23(6.5,0) 24(6.75,8.2) 25(7,0) 26(7.25,8.2) 27(7.5,0) 28(7.75,8.2) 29(8,0) 30(8.25,8.2) 31(8.5,0) 32(8.75,8.2) 33(9,0) 34(9.25,8.2) 35(9.5,0) 36(9.75,8.2) 37(10,0) 38(10.25,8.2) 39(10.5,0) 40(10.75,8.2) 41(11,0) 42(11.25,8.2) 43(11.5,0) 44(11.75,8.2) 45(12,0) 46(12.25,8.2) 47(12.5,0) 48(12.75,8.2) 49(13,0) 50(13.25,8.2) 51(13.5,0) 52(13.75,8.2) 53(14,0) 54(14.25,8.2) 55(14.5,0) 56(14.75,8.2) 57(15,0) 58(15.25,8.2) 59(15.5,0) 60(15.75,8.2) 61(16,0) 62(16.25,8.2) 63(16.5,0) 64(16.75,8.2) 65(17,0) 66(17.25,8.2) 67(17.5,0) 68(17.75,8.2) 69(18,0) 70(18.25,8.2) 71(18.5,0) 72(18.75,8.2) 73(19,0) 74(19.25,8.2) 75(19.5,0) 76(19.75,8.2) 77(20,0) 78(20.25,8.2) 79(20.5,0) 80(20.75,8.2) 81(21,0) 82(21.25,8.2) 83(21.5,0) 84(21.75,8.2) 85(22,0) 86(22.25,8.2) 87(22.5,0) 88(22.75,8.2) 89(23,0) 90(23.25,8.2) 91(23.5,0) 92(23.75,8.2) 93(24,0) 94(24.25,8.2) 95(24.5,0) 96(24.75,8.2) 97(25,0) 98(25.25,8.2) 99(25.5,0) 100(25.75,8.2) 101(26,0) 102(26.25,8.2) 103(26.5,0) 104(26.75,8.2) 105(27,0) 106(27.25,8.2) 107(27.5,0) 108(27.75,8.2) 109(28,0) 110(28.25,8.2) 111(28.5,0) 112(28.75,8.2) 113(29,0) 114(29.25,8.2) 115(29.5,0) 116(29.75,8.2) 117(30,0) 118(30.25,8.2) 119(30.5,0) 120(30.75,8.2) 121(31,0) 122(31.25,8.2) 123(31.5,0) 124(31.75,8.2) 125(32,0) 126(32.25,8.2) 127(32.5,0) 128(32.75,8.2) 129(33,0) 130(33.25,8.2) 131(33.5,0) 132(33.75,8.2) 133(34,0) 134(34.25,8.2) 135(34.5,0) 136(34.75,8.2) 137(35,0) 138(35.25,8.2) 139(35.5,0) 140(35.75,8.2) 141(36,0) 142(36.25,8.2) 143(36.5,0) 144(36.75,8.2) 145(37,0) 146(37.25,8.2) 147(37.5,0) 148(37.75,8.2) 149(38,0) 150(38.25,8.2) 151(38.5,0) 152(38.75,8.2) 153(39,0) 154(39.25,8.2) 155(39.5,0) 156(39.75,8.2) 157(40,0) 158(40.25,8.2) 159(40.5,0) 160(40.75,8.2) 161(41,0) 162(43.25,8.2) 163(43,0) 164(43.75,8.2) 165(43.5,0) 166(44.25,8.2) 167(44,0) 168(44.75,8.2) 169(44.5,0) 170(45.25,8.2) 171(45,0) 172(45.75,8.2) 173(45.5,0) 174(46.25,8.2) 175(46,0) 176(46.75,8.2) 177(46.5,0) 178(47.25,8.2) 179(47,0) 180(47.75,8.2) 181(47.5,0) 182(48.25,8.2) 183(48,0) 184(48.75,8.2) 185(48.5,0) 186(49.25,8.2) 187(49,0) 188(49.75,8.2) 189(49.5,0) 190(50.25,8.2) 191(50,0) 192(50.75,8.2) 193(50.5,0) 194(51.25,8.2) 195(51,0) 196(51.75,8.2) 197(51.5,0) 198(52.25,8.2) 199(52,0) 200(52.75,8.2) 201(52.5,0) 202(53.25,8.2) 203(53,0) 204(53.75,8.2) 205(53.5,0) 206(54.25,8.2) 207(54,0) 208(54.75,8.2) 209(54.5,0) 210(55.25,8.2) 211(55,0) 212(55.75,8.2) 213(55.5,0) 214(56.25,8.2) 215(56,0) 216(56.75,8.2) 217(56.5,0) 218(57.25,8.2) 219(57,0) 220(57.75,8.2) 221(57.5,0) 222(58.25,8.2) 223(58,0) 224(58.75,8.2) 225(58.5,0) 226(59.25,8.2) 227(59,0) 228(59.75,8.2) 229(59.5,0) 230(60.25,8.2) 231(60,0) 232(60.75,8.2) 233(60.5,0) 234(61.25,8.2) 235(61,0) 236(61.75,8.2) 237(61.5,0) 238(62.25,8.2) 239(62,0) 240(62.75,8.2) 241(62.5,0) 242(63.25,8.2) 243(63,0) 244(63.75,8.2) 245(63.5,0) 246(64.25,8.2) 247(64,0) 248(64.75,8.2) 249(64.5,0) 250(65.25,8.2) 251(65,0) 252(65.75,8.2) 253(65.5,0) 254(66.25,8.2) 255(66,0) 256(66.75,8.2) 257(66.5,0) 258(67.25,8.2) 259(67,0) 260(67.75,8.2) 261(67.5,0) 262(68.25,8.2) 263(68,0) 264(68.75,8.2) 265(68.5,0) 266(69.25,8.2) 267(69,0) 268(69.75,8.2) 269(69.5,0) 270(70.25,8.2) 271(70,0) 272(70.75,8.2) 273(70.5,0) 274(71.25,8.2) 275(71,0) 276(71.75,8.2) 277(71.5,0) 278(72.25,8.2) 279(72,0) 280(72.75,8.2) 281(72.5,0) 282(73.25,8.2) 283(73,0) 284(73.75,8.2) 285(73.5,0) 286(74.25,8.2) 287(74,0) 288(74.75,8.2) 289(74.5,0) 290(75.25,8.2) 291(75,0) 292(75.75,8.2) 293(75.5,0) 294(76.25,8.2) 295(76,0) 296(76.75,8.2) 297(76.5,0) 298(77.25,8.2) 299(77,0) 300(77.75,8.2) 301(77.5,0) 302(78.25,8.2) 303(78,0) 304(78.75,8.2) 305(78.5,0) 306(79.25,8.2) 307(79,0) 308(79.75,8.2) 309(79.5,0) 310(80,0)
  rect 3.302x5.004 smd: 311(-3.95,4.1) 312(83.95,4.1)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L30ESDL5V0C3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_4X4X2_F_2P
  rect 1.194x3.708 smd: 1(0,0) 2(2.8,0)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
LED_LTW-270US5_2P
  rect 0.889x0.889 smd: 1(0,0) 2(1.9,0)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_ADDR0106-P005A_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1)
  custom 0.876x0.876 smd: 262(67.175,16.1)
LOTES_ADDR0107-P005A_260P-T
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(-67.175,7.9) 262(0.425,7.9)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLV-FY12N1R0M-O1L_2P
  rect 0.889x2.489 smd: 1(0,0) 2(2.6,0)
MAG_MMD05CZR47M_4P
  custom 0.591x0.591 smd: 1(0,0) 4(6.248,0)
  rect 1.956x0.508 smd: 2(1.257,0) 3(4.991,0)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC5085-LZY_DQFN132_11X11
  oval 0.279x0.711 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0) A13(6,0) A14(6.5,0) A15(7,0) A16(7.5,0) A33(7.5,10.9) A34(7,10.9) A35(6.5,10.9) A36(6,10.9) A37(5.5,10.9) A38(5,10.9) A39(4.5,10.9) A40(4,10.9) A41(3.5,10.9) A42(3,10.9) A43(2.5,10.9) A44(2,10.9) A45(1.5,10.9) A46(1,10.9) A47(0.5,10.9) A48(0,10.9)
  oval 0.711x0.279 smd: A17(9.2,1.7) A18(9.2,2.2) A19(9.2,2.7) A20(9.2,3.2) A21(9.2,3.7) A22(9.2,4.2) A23(9.2,4.7) A24(9.2,5.2) A25(9.2,5.7) A26(9.2,6.2) A27(9.2,6.7) A28(9.2,7.2) A29(9.2,7.7) A30(9.2,8.2) A31(9.2,8.7) A32(9.2,9.2) A49(-1.7,9.2) A50(-1.7,8.7) A51(-1.7,8.2) A52(-1.7,7.7) A53(-1.7,7.2) A54(-1.7,6.7) A55(-1.7,6.2) A56(-1.7,5.7) A57(-1.7,5.2) A58(-1.7,4.7) A59(-1.7,4.2) A60(-1.7,3.7) A61(-1.7,3.2) A62(-1.7,2.7) A63(-1.7,2.2) A64(-1.7,1.7)
  oval 0.305x0.61 smd: B1(-0.25,0.85) B2(0.25,0.85) B3(0.75,0.85) B4(1.25,0.85) B5(1.75,0.85) B6(2.25,0.85) B7(2.75,0.85) B8(3.25,0.85) B9(3.75,0.85) B10(4.25,0.85) B11(4.75,0.85) B12(5.25,0.85) B13(5.75,0.85) B14(6.25,0.85) B15(6.75,0.85) B16(7.25,0.85) B17(7.75,0.85) B35(7.75,10.05) B36(7.25,10.05) B37(6.75,10.05) B38(6.25,10.05) B39(5.75,10.05) B40(5.25,10.05) B41(4.75,10.05) B42(4.25,10.05) B43(3.75,10.05) B44(3.25,10.05) B45(2.75,10.05) B46(2.25,10.05) B47(1.75,10.05) B48(1.25,10.05) B49(0.75,10.05) B50(0.25,10.05) B51(-0.25,10.05)
  oval 0.61x0.305 smd: B18(8.35,1.45) B19(8.35,1.95) B20(8.35,2.45) B21(8.35,2.95) B22(8.35,3.45) B23(8.35,3.95) B24(8.35,4.45) B25(8.35,4.95) B26(8.35,5.45) B27(8.35,5.95) B28(8.35,6.45) B29(8.35,6.95) B30(8.35,7.45) B31(8.35,7.95) B32(8.35,8.45) B33(8.35,8.95) B34(8.35,9.45) B52(-0.85,9.45) B53(-0.85,8.95) B54(-0.85,8.45) B55(-0.85,7.95) B56(-0.85,7.45) B57(-0.85,6.95) B58(-0.85,6.45) B59(-0.85,5.95) B60(-0.85,5.45) B61(-0.85,4.95) B62(-0.85,4.45) B63(-0.85,3.95) B64(-0.85,3.45) B65(-0.85,2.95) B66(-0.85,2.45) B67(-0.85,1.95) B68(-0.85,1.45)
  rect 5.004x5.004 smd: C1(3.75,5.45)
MHPC_NS692417_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
MM3Z22VST1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
NB681GD-Z_QFN13_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 8(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 10(1.4,1.05) 11(0.9,1.05) 12(0.4,1.05) 13(-0.1,1.05)
  oval 0.889x0.254 smd: 7(1.706,-1) 9(1.706,0)
NCP81205MNTXG_QFN52_6X6
  oval 0.838x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(6.15,-4.8) 28(6.15,-4.4) 29(6.15,-4) 30(6.15,-3.6) 31(6.15,-3.2) 32(6.15,-2.8) 33(6.15,-2.4) 34(6.15,-2) 35(6.15,-1.6) 36(6.15,-1.2) 37(6.15,-0.8) 38(6.15,-0.4) 39(6.15,0)
  oval 0.203x0.838 smd: 14(0.675,-5.475) 15(1.075,-5.475) 16(1.475,-5.475) 17(1.875,-5.475) 18(2.275,-5.475) 19(2.675,-5.475) 20(3.075,-5.475) 21(3.475,-5.475) 22(3.875,-5.475) 23(4.275,-5.475) 24(4.675,-5.475) 25(5.075,-5.475) 26(5.475,-5.475) 40(5.475,0.675) 41(5.075,0.675) 42(4.675,0.675) 43(4.275,0.675) 44(3.875,0.675) 45(3.475,0.675) 46(3.075,0.675) 47(2.675,0.675) 48(2.275,0.675) 49(1.875,0.675) 50(1.475,0.675) 51(1.075,0.675) 52(0.675,0.675)
  rect 4.699x4.699 smd: 53(3.075,-2.4)
NCP81210MNTWG_QFN40_5X5
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 21(5.07,-3.6) 22(5.07,-3.2) 23(5.07,-2.8) 24(5.07,-2.4) 25(5.07,-2) 26(5.07,-1.6) 27(5.07,-1.2) 28(5.07,-0.8) 29(5.07,-0.4) 30(5.07,0)
  oval 0.203x0.864 smd: 11(0.735,-4.373) 12(1.135,-4.373) 13(1.535,-4.373) 14(1.935,-4.373) 15(2.335,-4.373) 16(2.735,-4.373) 17(3.135,-4.373) 18(3.535,-4.373) 19(3.935,-4.373) 20(4.335,-4.373)
  oval 0.203x0.94 smd: 31(4.335,0.735) 32(3.935,0.735) 33(3.535,0.735) 34(3.135,0.735) 35(2.735,0.735) 36(2.335,0.735) 37(1.935,0.735) 38(1.535,0.735) 39(1.135,0.735) 40(0.735,0.735)
  custom 0.525x0.525 smd: 41(2.535,-1.8)
  rect 1.295x1.549 smd: 42(1.285,-3.025)
  custom 0.412x0.412 smd: 43(2.535,-2.8)
  custom 0.168x0.168 smd: 44(4.1,-2.43)
NCP81382MNTXG_QFN39_4X6
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2)
  oval 0.203x0.94 smd: 7(0.825,-3.025) 8(1.225,-3.025) 9(1.625,-3.025) 10(2.025,-3.025) 11(2.425,-3.025) 12(2.825,-3.025) 13(3.225,-3.025) 14(3.625,-3.025) 15(4.025,-3.025) 16(4.425,-3.025) 17(4.825,-3.025) 18(5.225,-3.025) 20(5.225,1.025) 21(4.825,1.025) 22(4.425,1.025) 23(4.025,1.025) 24(3.625,1.025) 25(3.225,1.025) 26(2.825,1.025) 27(2.425,1.025) 28(2.025,1.025) 29(1.625,1.025) 30(1.225,1.025) 31(0.825,1.025)
  custom 0.619x0.619 smd: 19(3.025,-1)
  rect 0.533x0.584 smd: 32(2.194,-2.054)
NPCT650JAAYX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PANAS_ETQP3W2R2WFN_2P
  rect 2.362x3.505 smd: 1(0,0) 2(-6.05,0)
PDS5100H-13_POWERDI5-3
  rect 4.851x3.353 smd: 1(0,0)
  rect 1.397x1.397 smd: 2(3.982,-0.92) 3(3.982,0.92)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PI3L720ZHEX_TQFN42_9X3P5
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 22(8,3.45) 23(7.5,3.45) 24(7,3.45) 25(6.5,3.45) 26(6,3.45) 27(5.5,3.45) 28(5,3.45) 29(4.5,3.45) 30(4,3.45) 31(3.5,3.45) 32(3,3.45) 33(2.5,3.45) 34(2,3.45) 35(1.5,3.45) 36(1,3.45) 37(0.5,3.45) 38(0,3.45)
  oval 1.041x0.254 smd: 18(8.475,0.975) 19(8.475,1.475) 20(8.475,1.975) 21(8.475,2.475) 39(-0.475,2.475) 40(-0.475,1.975) 41(-0.475,1.475) 42(-0.475,0.975)
  rect 7.544x2.057 smd: 43(4,1.725)
PI3PCIE3212ZBEX_TQFN20_2P5X4P5
  oval 0.889x0.254 smd: 1(0,0) 10(4.6,0) 11(4.6,0.5) 20(0,0.5)
  oval 0.254x0.889 smd: 2(0.55,-1.05) 3(1.05,-1.05) 4(1.55,-1.05) 5(2.05,-1.05) 6(2.55,-1.05) 7(3.05,-1.05) 8(3.55,-1.05) 9(4.05,-1.05) 12(4.05,1.55) 13(3.55,1.55) 14(3.05,1.55) 15(2.55,1.55) 16(2.05,1.55) 17(1.55,1.55) 18(1.05,1.55) 19(0.55,1.55)
  rect 2.997x0.991 smd: 21(2.3,0.25)
PS8331BQFN60GTR-A0_QFN60_5X9
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8338BQFN60GTR-A0_QFN60_5X9
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8558BTQFN24GTR2-A_TQFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.692x2.692 smd: 25(2.05,-1.25)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.445x0.445 smd: 1(0,0) 4(5.004,0)
  custom 0.114x0.114 smd: 2(1.194,0) 3(3.81,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
SAMTE_BSH-030-01-L-D-A_60P
  round 1.016 hole 1.016 unplated: (-2.81,5.53) (17.316,5.53)
  oval 0.279x2.261 smd: 1(0,0) 2(0,5.728) 3(0.5,0) 4(0.5,5.728) 5(1,0) 6(1,5.728) 7(1.5,0) 8(1.5,5.728) 9(2,0) 10(2,5.728) 11(2.5,0) 12(2.5,5.728) 13(3,0) 14(3,5.728) 15(3.5,0) 16(3.5,5.728) 17(4,0) 18(4,5.728) 19(4.5,0) 20(4.5,5.728) 21(5,0) 22(5,5.728) 23(5.5,0) 24(5.5,5.728) 25(6,0) 26(6,5.728) 27(6.5,0) 28(6.5,5.728) 29(7,0) 30(7,5.728) 31(7.5,0) 32(7.5,5.728) 33(8,0) 34(8,5.728) 35(8.5,0) 36(8.5,5.728) 37(9,0) 38(9,5.728) 39(9.5,0) 40(9.5,5.728) 41(10,0) 42(10,5.728) 43(10.5,0) 44(10.5,5.728) 45(11,0) 46(11,5.728) 47(11.5,0) 48(11.5,5.728) 49(12,0) 50(12,5.728) 51(12.5,0) 52(12.5,5.728) 53(13,0) 54(13,5.728) 55(13.5,0) 56(13.5,5.728) 57(14,0) 58(14,5.728) 59(14.5,0) 60(14.5,5.728)
SBR3A40SA-13_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI4835DDY-T1-E3_SO8
  oval 0.635x1.727 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.285) 6(2.54,5.285) 7(1.27,5.285) 8(0,5.285)
SI7447DP_SO8_5P
  oval 0.635x1.778 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.962)
SI7716ADN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SINGA_2RJ1672-000111F_13P
  round 1.295 hole 0.889: 1(0,0) 2(-1.02,1.1) 3(-2.04,0) 4(-3.06,1.1) 5(-4.08,0) 6(-5.1,1.1) 7(-6.12,0) 8(-7.14,1.1)
  round 1.397 hole 0.991: 9(-9.39,-2.49) 10(-10.535,-1.19) 11(-8.245,-1.19) 12(2.245,-2.49) 13(3.395,-1.19)
  oval 1.473x3.15 hole 0.711x2.388: 14(-11.595,-7.4) 15(4.455,-7.4)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SKL-H-PCH_BGA_837P-T
  round 0.305 smd: A2(-0.354,0) A3(-0.854,0) A4(-1.355,0) A42(-20.273,0) A43(-20.773,0) A44(-21.274,0) AA17(-7.715,10.039) AA18(-8.49,10.039) AA20(-9.264,10.039) AA21(-10.039,10.039) AA23(-10.814,10.039) AA25(-11.588,10.039) AA26(-12.363,10.039) AA28(-13.138,10.039) AA29(-13.913,10.039) AB7(-2.638,10.147) AB8(-3.4,10.147) AB10(-4.162,10.147) AB11(-4.924,10.147) AB13(-5.686,10.147) AB14(-6.448,10.147) AB15(-7.007,10.147) AB31(-14.62,10.147) AB32(-15.179,10.147) AB33(-15.941,10.147) AB35(-16.703,10.147) AB36(-17.465,10.147) AB38(-18.227,10.147) AB39(-18.989,10.147) AC17(-7.715,10.814) AC18(-8.49,10.814) AC20(-9.264,10.814) AC21(-10.039,10.814) AC23(-10.814,10.814) AC25(-11.588,10.814) AC26(-12.363,10.814) AC28(-13.138,10.814) AC29(-13.913,10.814) AD7(-2.638,11.481) AD8(-3.4,11.481) AD10(-4.162,11.481) AD11(-4.924,11.481) AD13(-5.686,11.481) AD14(-6.448,11.481) AD15(-7.007,11.481) AD31(-14.62,11.481) AD32(-15.179,11.481) AD33(-15.941,11.481) AD35(-16.703,11.481) AD36(-17.465,11.481) AD38(-18.227,11.481) AD39(-18.989,11.481) AE17(-7.715,11.588) AE18(-8.49,11.588) AE20(-9.264,11.588) AE21(-10.039,11.588) AE23(-10.814,11.588) AE25(-11.588,11.588) AE26(-12.363,11.588) AE28(-13.138,11.588) AE29(-13.913,11.588) AF17(-7.715,12.363) AF18(-8.49,12.363) AF20(-9.264,12.363) AF21(-10.039,12.363) AF23(-10.814,12.363) AF25(-11.588,12.363) AF26(-12.363,12.363) AF28(-13.138,12.363) AF29(-13.913,12.363) AG7(-2.638,12.586) AG8(-3.4,12.586) AG10(-4.162,12.586) AG11(-4.924,12.586) AG13(-5.686,12.586) AG14(-6.448,12.586) AG15(-7.007,12.586) AG31(-14.62,12.586) AG32(-15.179,12.586) AG33(-15.941,12.586) AG35(-16.703,12.586) AG36(-17.465,12.586) AG38(-18.227,12.586) AG39(-18.989,12.586) AH17(-7.715,13.138) AH18(-8.49,13.138) AH20(-9.264,13.138) AH21(-10.039,13.138) AH23(-10.814,13.138) AH25(-11.588,13.138) AH26(-12.363,13.138) AH28(-13.138,13.138) AH29(-13.913,13.138) AJ7(-2.74,13.767) AJ8(-3.502,13.767) AJ10(-4.264,13.767) AJ11(-5.026,13.767) AJ13(-5.788,13.767) AJ14(-6.499,13.767) AJ15(-7.007,13.767) AJ17(-7.715,13.913) AJ18(-8.49,13.913) AJ20(-9.264,13.913) AJ21(-10.039,13.913) AJ23(-10.814,13.913) AJ25(-11.588,13.913) AJ26(-12.363,13.913) AJ28(-13.138,13.913) AJ29(-13.913,13.913) AJ31(-14.62,13.767) AJ32(-15.179,13.767) AJ33(-15.941,13.767) AJ35(-16.703,13.767) AJ36(-17.465,13.767) AJ38(-18.227,13.767) AJ39(-18.989,13.767) AL7(-2.74,14.885) AL8(-3.502,14.885) AL10(-4.264,14.885) AL11(-5.026,14.885) AL13(-5.788,14.885) AL17(-7.861,14.62) AL19(-9.042,14.62) AL22(-10.147,14.62) AL24(-11.481,14.62) AL27(-12.586,14.62) AL29(-13.767,14.62) AL32(-15.154,14.91) AL33(-15.916,14.91) AL35(-16.678,14.91) AL36(-17.44,14.91) AL38(-18.202,14.91) AL39(-18.964,14.91) AM15(-6.718,15.154) AM17(-7.861,15.179) AM19(-9.042,15.179) AM22(-10.147,15.179) AM24(-11.481,15.179) AM27(-12.586,15.179) AM29(-13.767,15.128) AN7(-2.791,15.85) AN8(-3.553,15.799) AN10(-4.315,15.799) AN11(-5.061,15.84) AN15(-6.718,15.916) AN17(-7.861,15.941) AN19(-9.042,15.941) AN22(-10.147,15.941) AN24(-11.481,15.941) AN27(-12.586,15.941) AN29(-13.767,15.84) AN31(-14.885,15.84) AN36(-17.284,15.901) AN38(-18.046,15.901) AN39(-18.808,15.901) AP11(-4.774,16.365) AR7(-2.815,16.851) AR9(-3.73,16.891) AR15(-6.718,16.678) AR17(-7.861,16.703) AR19(-9.042,16.703) AR22(-10.147,16.703) AR24(-11.481,16.703) AR27(-12.586,16.703) AR29(-13.767,16.602) AR31(-14.885,16.602) AR33(-15.84,16.566) AR34(-16.365,16.854) AR38(-18.21,16.882) AR39(-18.972,16.882) AT9(-3.876,17.527) AT10(-4.503,17.477) AT13(-5.727,17.284) AT15(-6.718,17.44) AT17(-7.861,17.465) AT19(-9.042,17.465) AT22(-10.147,17.465) AT24(-11.481,17.465) AT27(-12.586,17.465) AT29(-13.767,17.364) AT31(-14.885,17.364) AT33(-15.799,17.313) AT36(-17.477,17.125) AU7(-2.878,17.808) AU35(-16.891,17.897) AU36(-17.527,17.751) AU39(-18.804,17.955) AV6(-2.577,18.459) AV11(-4.745,18.21) AV13(-5.727,18.046) AV15(-6.718,18.202) AV17(-7.861,18.227) AV19(-9.042,18.227) AV22(-10.147,18.227) AV24(-11.481,18.227) AV27(-12.586,18.227) AV29(-13.767,18.126) AV31(-14.885,18.126) AV33(-15.799,18.075) AW9(-3.673,18.804) AW11(-4.745,18.972) AW13(-5.727,18.808) AW15(-6.718,18.964) AW17(-7.861,18.989) AW19(-9.042,18.989) AW22(-10.147,18.989) AW24(-11.481,18.989) AW27(-12.586,18.989) AW29(-13.767,18.888) AW31(-14.885,18.888) AW33(-15.85,18.837) AW35(-16.851,18.813) AW37(-17.808,18.75) AY5(-2.05,19.399) AY38(-18.459,19.051) B1(0,0.354) B2(-0.484,0.484) B3(-0.99,0.488) B43(-20.614,0.51) B44(-21.144,0.484) B45(-21.628,0.354) BA40(-19.399,19.577) BB1(0,20.273) BB45(-21.628,20.273) BC1(0,20.773) BC2(-0.488,20.637) BC44(-21.118,20.614) BC45(-21.628,20.773) BD1(0,21.274) BD2(-0.484,21.144) BD3(-1.013,21.118) BD43(-20.637,21.139) BD44(-21.144,21.144) BD45(-21.628,21.274) BE2(-0.354,21.628) BE3(-0.854,21.628) BE4(-1.355,21.628) BE42(-20.273,21.628) BE43(-20.773,21.628) BE44(-21.274,21.628) C1(0,0.854) C2(-0.51,1.013) C42(-20.102,0.954) C44(-21.139,0.99) C45(-21.628,0.854) D1(0,1.355) D45(-21.628,1.355) F8(-3.169,2.577) G9(-3.819,2.878) G11(-4.777,2.815) G13(-5.778,2.791) G15(-6.743,2.74) G17(-7.861,2.74) G19(-9.042,2.638) G22(-10.147,2.638) G24(-11.481,2.638) G27(-12.586,2.638) G29(-13.767,2.638) G31(-14.91,2.664) G33(-15.901,2.82) G35(-16.882,2.656) G37(-17.955,2.823) H13(-5.829,3.553) H15(-6.743,3.502) H17(-7.861,3.502) H19(-9.042,3.4) H22(-10.147,3.4) H24(-11.481,3.4) H27(-12.586,3.4) H29(-13.767,3.4) H31(-14.91,3.426) H33(-15.901,3.582) H35(-16.882,3.418) J7(-2.823,3.673) J10(-4.101,3.876) J11(-4.737,3.73) J39(-18.75,3.819) K10(-4.151,4.503) K13(-5.829,4.315) K15(-6.743,4.264) K17(-7.861,4.264) K19(-9.042,4.162) K22(-10.147,4.162) K24(-11.481,4.162) K27(-12.586,4.162) K29(-13.767,4.162) K31(-14.91,4.188) K33(-15.901,4.344) K36(-17.125,4.151) K37(-17.751,4.101) L7(-2.656,4.745) L8(-3.418,4.745) L12(-5.263,4.774) L13(-5.788,5.061) L15(-6.743,5.026) L17(-7.861,5.026) L19(-9.042,4.924) L22(-10.147,4.924) L24(-11.481,4.924) L27(-12.586,4.924) L29(-13.767,4.924) L31(-14.91,4.95) L37(-17.897,4.737) L39(-18.813,4.777) M35(-16.854,5.263) N7(-2.82,5.727) N8(-3.582,5.727) N10(-4.344,5.727) N15(-6.743,5.788) N17(-7.861,5.788) N19(-9.042,5.686) N22(-10.147,5.686) N24(-11.481,5.686) N27(-12.586,5.686) N29(-13.767,5.686) N31(-14.91,5.712) N35(-16.566,5.788) N36(-17.313,5.829) N38(-18.075,5.829) N39(-18.837,5.778) P17(-7.861,6.499) P19(-9.042,6.448) P22(-10.147,6.448) P24(-11.481,6.448) P27(-12.586,6.448) P29(-13.767,6.448) P31(-14.91,6.474) R7(-2.664,6.718) R8(-3.426,6.718) R10(-4.188,6.718) R11(-4.95,6.718) R13(-5.712,6.718) R14(-6.474,6.718) R17(-7.861,7.007) R19(-9.042,7.007) R22(-10.147,7.007) R24(-11.481,7.007) R27(-12.586,7.007) R29(-13.767,7.007) R33(-15.84,6.743) R35(-16.602,6.743) R36(-17.364,6.743) R38(-18.126,6.743) R39(-18.888,6.743) U7(-2.638,7.861) U8(-3.4,7.861) U10(-4.162,7.861) U11(-4.924,7.861) U13(-5.686,7.861) U14(-6.448,7.861) U15(-7.007,7.861) U17(-7.715,7.715) U18(-8.49,7.715) U20(-9.264,7.715) U21(-10.039,7.715) U23(-10.814,7.715) U25(-11.588,7.715) U26(-12.363,7.715) U28(-13.138,7.715) U29(-13.913,7.715) U31(-14.62,7.861) U32(-15.128,7.861) U33(-15.84,7.861) U35(-16.602,7.861) U36(-17.364,7.861) U38(-18.126,7.861) U39(-18.888,7.861) V17(-7.715,8.49) V18(-8.49,8.49) V20(-9.264,8.49) V21(-10.039,8.49) V23(-10.814,8.49) V25(-11.588,8.49) V26(-12.363,8.49) V28(-13.138,8.49) V29(-13.913,8.49) W7(-2.638,9.042) W8(-3.4,9.042) W10(-4.162,9.042) W11(-4.924,9.042) W13(-5.686,9.042) W14(-6.448,9.042) W15(-7.007,9.042) W31(-14.62,9.042) W32(-15.179,9.042) W33(-15.941,9.042) W35(-16.703,9.042) W36(-17.465,9.042) W38(-18.227,9.042) W39(-18.989,9.042) Y17(-7.715,9.264) Y18(-8.49,9.264) Y20(-9.264,9.264) Y21(-10.039,9.264) Y23(-10.814,9.264) Y25(-11.588,9.264) Y26(-12.363,9.264) Y28(-13.138,9.264) Y29(-13.913,9.264)
  round 0.279 smd: A5(-1.855,0) A41(-19.772,0) BA1(0,19.772) BA45(-21.628,19.772) BE5(-1.855,21.628) BE41(-19.772,21.628) E1(0,1.855) E45(-21.628,1.855)
  round 0.254 smd: A6(-2.356,0) A25(-12.039,0) A30(-14.312,0) A35(-16.586,0) A40(-19.272,0) AA2(-0.508,9.588) AA44(-21.12,9.766) AB3(-0.926,10.204) AB4(-1.411,10.331) AB5(-1.876,10.147) AB41(-19.751,10.147) AB42(-20.235,10.305) AB43(-20.743,10.33) AC3(-1.087,10.718) AC43(-20.54,10.909) AD3(-0.885,11.298) AD4(-1.393,11.323) AD5(-1.876,11.481) AD41(-19.751,11.481) AD42(-20.217,11.296) AD43(-20.702,11.423) AE2(-0.508,11.862) AE44(-21.12,12.039) AF3(-0.926,12.478) AF5(-1.929,12.535) AF41(-19.7,12.535) AG3(-1.087,12.992) AG4(-1.411,12.605) AG42(-20.235,12.578) AG43(-20.743,12.603) AH43(-20.54,13.183) AJ3(-0.885,13.571) AJ4(-1.393,13.596) AJ5(-1.978,13.767) AJ41(-19.751,13.767) AJ42(-20.217,13.569) AJ43(-20.702,13.696) AK2(-0.508,14.135) AK44(-21.12,14.312) AL3(-0.926,14.751) AL4(-1.411,14.878) AL5(-1.978,14.885) AL41(-19.7,14.91) AL42(-20.235,14.851) AL43(-20.743,14.877) AM2(-0.579,15.265) AM3(-1.087,15.265) AM43(-20.54,15.456) AN3(-0.885,15.844) AN4(-1.393,15.87) AN5(-2.029,15.977) AN41(-19.57,15.901) AN42(-20.217,15.843) AN43(-20.702,15.97) AP2(-0.508,16.408) AR3(-0.926,17.024) AR5(-1.927,16.995) AR41(-19.734,16.882) AR44(-21.12,16.586) AT3(-1.087,17.538) AT4(-1.411,17.151) AT42(-20.235,17.124) AT43(-20.743,17.15) AU41(-19.851,17.904) AU43(-20.54,17.729) AU44(-21.048,17.729) AV3(-0.885,18.168) AV4(-1.585,18.134) AV43(-20.702,18.205) AV44(-21.21,18.205) AW4(-1.379,19.018) AW42(-20.054,18.629) AY1(0,19.272) AY45(-21.628,19.272) B6(-2.364,0.518) B10(-4.089,0.579) B12(-5.219,0.508) B14(-6.363,0.579) B16(-7.492,0.508) B21(-9.766,0.508) B23(-10.909,0.579) B25(-12.039,0.508) B28(-13.183,0.579) B29(-13.696,0.418) B30(-14.312,0.508) B31(-14.973,0.386) B32(-15.456,0.579) B35(-16.586,0.508) B37(-17.729,0.579) B38(-18.205,0.418) B40(-19.515,0.459) BA4(-1.212,19.933) BA5(-2.047,19.909) BA9(-3.723,19.851) BA11(-4.745,19.734) BA13(-5.727,19.57) BA15(-6.718,19.7) BA17(-7.861,19.751) BA20(-9.092,19.7) BA22(-10.147,19.751) BA24(-11.481,19.751) BA26(-12.535,19.699) BA29(-13.767,19.65) BA31(-14.885,19.65) BA33(-15.977,19.599) BA35(-16.995,19.7) BA41(-19.909,19.581) BB3(-0.652,20.158) BB7(-2.998,20.054) BB10(-4.503,20.235) BB13(-5.785,20.217) BB15(-6.776,20.235) BB17(-8.058,20.217) BB19(-9.05,20.235) BB22(-10.331,20.217) BB24(-11.323,20.235) BB27(-12.605,20.217) BB29(-13.596,20.235) BB31(-14.878,20.217) BB33(-15.87,20.235) BB36(-17.151,20.217) BB38(-18.134,20.043) BB39(-19.018,20.248) BB41(-19.933,20.416) BB43(-20.674,20.102) BC4(-1.526,20.674) BC9(-3.898,20.54) BC10(-4.478,20.743) BC13(-5.658,20.702) BC14(-6.172,20.54) BC15(-6.751,20.743) BC17(-7.931,20.702) BC18(-8.445,20.54) BC19(-9.024,20.743) BC22(-10.204,20.702) BC23(-10.718,20.54) BC24(-11.298,20.743) BC26(-12.478,20.702) BC27(-12.992,20.54) BC29(-13.571,20.743) BC31(-14.751,20.702) BC32(-15.265,20.54) BC33(-15.844,20.743) BC35(-17.024,20.702) BC36(-17.538,20.54) BC38(-18.168,20.743) BC42(-20.158,20.976) BD8(-3.423,21.21) BD9(-3.898,21.048) BD11(-5.042,21.12) BD16(-7.315,21.12) BD21(-9.588,21.12) BD25(-11.862,21.12) BD30(-14.135,21.12) BD34(-16.408,21.12) BE6(-2.356,21.628) BE40(-19.272,21.628) C8(-3.459,0.885) C10(-4.089,1.087) C11(-4.603,0.926) C13(-5.783,0.885) C14(-6.363,1.087) C15(-6.877,0.926) C17(-8.057,0.885) C19(-8.636,1.087) C20(-9.15,0.926) C22(-10.33,0.885) C23(-10.909,1.087) C24(-11.423,0.926) C27(-12.603,0.885) C28(-13.183,1.087) C29(-13.696,0.926) C31(-14.877,0.885) C32(-15.456,1.087) C33(-15.97,0.926) C36(-17.15,0.885) C37(-17.729,1.087) C38(-18.205,0.926) D3(-0.954,1.526) D5(-1.694,1.212) D7(-2.61,1.379) D8(-3.493,1.585) D10(-4.476,1.411) D13(-5.758,1.393) D15(-6.75,1.411) D17(-8.031,1.393) D19(-9.023,1.411) D22(-10.305,1.393) D24(-11.296,1.411) D27(-12.578,1.393) D29(-13.569,1.411) D31(-14.851,1.393) D33(-15.843,1.411) D36(-17.124,1.393) D39(-18.629,1.574) D43(-20.976,1.47) E5(-1.719,2.047) E6(-2.229,2.05) E11(-4.632,1.927) E13(-5.651,2.029) E15(-6.743,1.978) E17(-7.861,1.978) E20(-9.092,1.929) E22(-10.147,1.876) E24(-11.481,1.876) E26(-12.535,1.927) E29(-13.767,1.876) E31(-14.91,1.927) E33(-15.901,2.058) E35(-16.882,1.894) E37(-17.904,1.776) E41(-19.581,1.719) E42(-20.416,1.694) F1(0,2.356) F41(-19.577,2.229) F44(-21.11,2.364) F45(-21.628,2.356) G4(-1.574,2.998) G42(-20.248,2.61) H2(-0.418,3.423) H3(-0.926,3.423) H40(-19.051,3.169) H42(-20.043,3.493) H43(-20.743,3.459) J2(-0.579,3.898) J3(-1.087,3.898) J5(-1.776,3.723) K2(-0.386,4.381) K3(-0.885,4.478) K4(-1.393,4.503) K42(-20.217,4.476) K43(-20.54,4.089) L2(-0.508,5.042) L5(-1.894,4.745) L41(-19.7,4.632) L43(-20.702,4.603) M44(-21.12,5.219) N3(-0.926,5.658) N4(-1.411,5.785) N5(-2.058,5.727) N41(-19.599,5.651) N42(-20.235,5.758) N43(-20.743,5.783) P2(-0.579,6.172) P3(-1.087,6.172) P43(-20.54,6.363) R2(-0.386,6.655) R3(-0.885,6.751) R4(-1.393,6.776) R5(-1.927,6.718) R41(-19.65,6.743) R42(-20.217,6.75) R43(-20.702,6.877) T1(0,7.315) T2(-0.508,7.315) T44(-21.12,7.492) U2(-0.418,7.931) U3(-0.926,7.931) U4(-1.411,8.058) U5(-1.876,7.861) U41(-19.65,7.861) U42(-20.235,8.031) U43(-20.743,8.057) V2(-0.579,8.445) V3(-1.087,8.445) W3(-0.885,9.024) W4(-1.393,9.05) W42(-20.217,9.023) W43(-20.54,8.636) Y5(-1.927,9.092) Y41(-19.699,9.092) Y43(-20.702,9.15)
  oval 0.203x0.254 smd: A7(-2.92,0) A9(-3.962,0) A12(-5.219,0) A14(-6.261,0) A16(-7.492,0) A18(-8.534,0) A21(-9.766,0) A23(-10.807,0) A28(-13.08,0) A32(-15.354,0) A37(-17.652,0) A39(-18.707,0) B7(-2.87,0.508) B8(-3.555,0.386) B11(-4.603,0.418) B13(-5.88,0.386) B15(-6.877,0.418) B18(-8.153,0.386) B19(-8.636,0.579) B20(-9.15,0.418) B22(-10.426,0.386) B24(-11.423,0.418) B27(-12.699,0.386) B33(-15.97,0.418) B36(-17.246,0.386) B39(-18.757,0.508) BC8(-3.423,20.702) BD6(-2.113,21.168) BD7(-2.87,21.12) BD10(-4.381,21.242) BD13(-5.658,21.21) BD14(-6.172,21.048) BD15(-6.655,21.242) BD17(-7.931,21.21) BD18(-8.445,21.048) BD19(-8.928,21.242) BD22(-10.204,21.21) BD23(-10.718,21.048) BD24(-11.201,21.242) BD26(-12.478,21.21) BD27(-12.992,21.048) BD28(-13.475,21.242) BD31(-14.751,21.21) BD32(-15.265,21.048) BD33(-15.748,21.242) BD35(-17.024,21.21) BD36(-17.538,21.048) BD38(-18.072,21.242) BD39(-18.758,21.12) BE7(-2.92,21.628) BE9(-3.975,21.628) BE11(-5.042,21.628) BE14(-6.274,21.628) BE16(-7.315,21.628) BE18(-8.547,21.628) BE21(-9.588,21.628) BE23(-10.82,21.628) BE25(-11.862,21.628) BE28(-13.094,21.628) BE30(-14.135,21.628) BE32(-15.367,21.628) BE34(-16.408,21.628) BE37(-17.666,21.628) BE39(-18.707,21.628)
  oval 0.254x0.203 smd: AA1(0,9.588) AA45(-21.628,9.766) AB2(-0.418,10.204) AB44(-21.242,10.426) AC1(0,10.82) AC2(-0.579,10.718) AC44(-21.048,10.909) AC45(-21.628,10.807) AD2(-0.386,11.201) AD44(-21.21,11.423) AE1(0,11.862) AE45(-21.628,12.039) AF2(-0.418,12.478) AG2(-0.579,12.992) AG44(-21.242,12.699) AH1(0,13.094) AH2(-0.386,13.475) AH44(-21.048,13.183) AH45(-21.628,13.08) AJ44(-21.21,13.696) AK1(0,14.135) AK45(-21.628,14.312) AL2(-0.418,14.751) AL44(-21.242,14.973) AM1(0,15.367) AM44(-21.048,15.456) AM45(-21.628,15.354) AN2(-0.386,15.748) AN44(-21.21,15.97) AP1(0,16.408) AR2(-0.418,17.024) AR45(-21.628,16.586) AT2(-0.579,17.538) AT44(-21.242,17.246) AU1(0,17.666) AU45(-21.628,17.652) AV2(-0.386,18.072) AW1(0,18.707) AW2(-0.508,18.758) AW44(-21.12,18.757) AW45(-21.628,18.707) AY44(-21.168,19.515) F2(-0.459,2.113) G1(0,2.92) G2(-0.508,2.87) G44(-21.12,2.87) G45(-21.628,2.92) H44(-21.242,3.555) J1(0,3.975) J45(-21.628,3.962) K44(-21.048,4.089) L1(0,5.042) L44(-21.21,4.603) M45(-21.628,5.219) N2(-0.418,5.658) N44(-21.242,5.88) P1(0,6.274) P44(-21.048,6.363) P45(-21.628,6.261) R44(-21.21,6.877) T45(-21.628,7.492) V1(0,8.547) V44(-21.242,8.153) V45(-21.628,8.534) W2(-0.386,8.928) W44(-21.048,8.636) Y44(-21.21,9.15)
  round 0.368 smd: AA4(-1.487,9.588) AA42(-20.138,9.766) AE4(-1.489,11.862) AE42(-20.14,12.039) AK4(-1.489,14.135) AK42(-20.14,14.312) AP4(-1.489,16.408) AR42(-20.14,16.586) AY2(-0.518,19.263) BB11(-5.042,20.14) BB16(-7.315,20.14) BB21(-9.588,20.14) BB25(-11.862,20.138) BB30(-14.135,20.138) BB34(-16.408,20.138) BD40(-19.263,21.11) C4(-1.47,0.652) D12(-5.219,1.489) D16(-7.492,1.489) D21(-9.766,1.489) D25(-12.039,1.487) D30(-14.312,1.487) D35(-16.586,1.487) L4(-1.487,5.042) M42(-20.138,5.219) T4(-1.487,7.315) T42(-20.138,7.492)
