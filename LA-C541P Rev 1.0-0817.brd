# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N9: length 73.1
  TOP w0.089: UH1.AA1 134.88,111.81 135.34,111.81 136.1,111.05 136.84,111.05 136.85,111.05 136.87,111.05
  TOP w0.102: 136.87,111.05 138.3,111.05 138.5,110.85 142.32,110.85 143.62,109.55 143.62,108.67 v2(143.99,108.3)
  IN3 w0.127: v2(143.99,108.3) 143.92,108.23 143.92,108.22 143.86,108.17 143.86,108 144.09,107.77 144.66,107.77 145.08,108.2 145.08,109.14 144.04,110.18 144.04,114.14 144.33,114.44 144.33,114.44 144.95,115.06 144.95,120.38 142.81,122.52 141.84,123.49 141.84,123.97 141.2,124.61 141.2,125.94 140.45,126.69 140.45,129.52 139.21,130.76 133.49,130.76 131.83,132.42 128.76,132.42 127.4,133.78 121.52,133.78 121.02,134.28 120.1,134.28 115.61,138.77 115.46,138.77 115.09,139.15 114.72,139.15 114.58,139.29 114.58,139.65 114.47,139.76 114.32,139.76 v2(114.16,139.59)
  BOTTOM w0.102: R429.1 116.92,140.3 L11.4 116.75,141.38 116.37,141.75 115.5,141.75 114.16,140.41 v2(114.16,139.59)
USB20_N9_R: length 29
  TOP w0.102: JTS1.2 135.3,131.45 135.69,131.85 135.69,132.02 135.51,132.21 132.94,132.21 132.79,132.35 128.96,132.35 128.16,133.15 127.3,133.15 127.17,133.01 127.17,132.79 v2(127.35,132.61)
  BOTTOM w0.102: v2(127.35,132.61) 127.14,132.82 127.14,133.02 126.84,133.32 120.48,133.32 120.43,133.36 120.38,133.42 120.05,133.75 119.89,133.9 v4(119.89,135.53) 119.89,135.86 119.64,136.11 119.36,136.11 119.17,136.3 119.17,136.86 118.9,137.13 D20.2 118.24,136.27 118.1,136.13 117.81,136.13 116.47,137.47 116.47,138.51 116.56,138.61 116.66,138.61 116.75,138.7 L11.3 116.92,139.39 R429.2
USB20_N10: length 130.9
  TOP w0.089: UH1.AJ8 v2(130.96,116.49)
  TOP w0.102: JUSH1.19 68.76,36.8 68.94,36.98 69.1,36.98 v2(69.26,36.82)
  IN3 w0.089: 135.06,101.36 135.06,102.08 134.84,102.29 134.84,107.77 135.45,108.38 135.45,111.31 133.96,112.8 133.96,115.34 133.49,115.81 131.4,115.81 131.2,116.02 131.2,116.26 v2(130.96,116.49)
  IN3 w0.127: v2(69.26,36.82) 69.58,37.14 69.58,37.58 69.85,37.85 70.09,37.85 70.43,38.18 70.43,38.76 69.98,39.2 68.81,39.2 66.23,41.78 66.08,41.93 66.08,50.6 71.32,55.84 72.14,55.84 75.15,58.85 75.15,59.45 98.71,83.01 105.57,83.01 112.08,89.52 115.32,89.52 117.15,91.34 121.7,91.34 122.3,90.74 126.01,90.74 126.12,90.85 129.24,90.85 129.87,91.47 129.87,92.29 131.71,94.13 131.71,96.44 131.71,96.64 134.1,99.03 134.1,99.6 134.15,99.65 134.15,100.45 135.06,101.36
USB20_N11: length 78.1
  TOP w0.089: 137.71,110.35 137.68,110.35 137.68,110.35 135.96,110.35 134.99,111.31 134.76,111.31 134.57,111.5 134.36,111.5 134.29,111.43 134.29,111.36 UH1.W2
  TOP w0.102: v2(142.72,108.26) 142.72,109.23 141.83,110.13 v4(140.16,110.13) 137.93,110.13 137.71,110.35
  IN3 w0.127: v2(105.39,133.85) 112.51,133.85 115.07,136.41 116.99,136.41 119.63,133.77 120.74,133.77 121.24,133.27 124.03,133.27 125.13,132.17 127.52,132.17 127.85,131.85 131.68,131.85 133.28,130.25 138.99,130.25 139.93,129.31 139.93,124.61 140.76,123.78 140.76,123.14 141.29,122.61 141.29,122.61 141.43,122.48 141.43,121.31 141.75,120.98 143.5,120.98 143.98,120.51 143.98,119.29 144.34,118.93 144.34,115.55 143.49,114.71 143.49,109.73 142.72,108.96 v2(142.72,108.26)
  BOTTOM w0.102: R427.1 103.97,132.98 L10.1 103.8,132.35 103.68,132.24 103.62,132.24 103.51,132.13 103.51,132.06 103.57,132 104.27,132 104.54,132.27 104.54,132.5 104.74,132.7 104.74,133.2 v2(105.39,133.85)
USB20_N11_R: length 31
  TOP w0.102: 120.5,142.83 120.64,143.64 120.52,143.8 120.69,144.75 121.13,145.19 121.47,145.19 v2(121.66,145)
  IN1 w0.109: v2(106.28,137.29) 106.46,137.47 112.22,137.47 113.62,138.87 115.84,138.87 117.39,140.42 117.39,142.72 119.72,145.04 120.77,145.04 121.01,145.29 121.37,145.29 v2(121.66,145)
  BOTTOM w0.102: R427.2 103.97,133.89 L10.2 103.8,134.35 103.51,134.64 103.51,135.01 103.59,135.08 104.39,135.08 104.51,135.21 D21.2 104.08,136.01 103.74,136.35 103.74,136.56 104.89,137.71 105.11,137.71 105.23,137.59 105.98,137.59 v2(106.28,137.29)
USB20_P1: length 123.7
  TOP w0.101: UH1.AG7 v2(131.82,115.33)
  TOP w0.102: JIO2.83 56.85,42.85 56.94,42.94 56.94,43.01 57.06,43.13 58.1,43.13 58.22,43.01 58.22,42.87 v2(57.85,42.5)
  IN3 w0.089: v2(131.82,115.33) 131.92,115.33 132.17,115.08 132.17,114.93 132.43,114.66 132.74,114.66 132.96,114.44 133.01,114.4 133.01,114.37 133.02,114.36
  IN3 w0.127: v2(57.85,42.5) 57.95,42.6 57.95,42.62 57.96,42.63 57.96,42.99 58.17,43.2 58.97,43.2 62.47,46.7 62.47,48.06 71.01,56.6 71.83,56.6 74.39,59.16 74.39,59.76 101.64,87.01 107.13,87.01 110.49,90.38 115.1,90.38 115.87,91.14 115.87,91.65 116.31,92.1 128.03,92.1 130.67,94.74 130.67,96.68 133.34,99.34 133.34,99.6 133.39,99.65 133.39,101.16 133.14,101.41 133.14,102.29 133.6,102.74 134.05,102.74 134.28,102.97 134.28,110 133.16,111.12 133.16,114.22 133.02,114.36
USB20_P2: length 227
  TOP w0.089: v2(131.82,114.28) 132.18,113.93 UH1.AD7
  TOP w0.102: v2(306.51,46.65) 306.51,46.11 307.27,45.36 307.88,45.36 v4(308.61,44.63) 308.94,44.3 JIO1.18
  IN4 w0.089: 141.76,110.48 141.74,110.48 141.73,110.49 141.67,110.49 141.66,110.5 134.48,110.5 133.11,111.88 133.11,112.25 132.16,113.2 132.16,114.19 132.06,114.28 v2(131.82,114.28)
  IN4 w0.109: v2(306.51,46.65) 306.51,46.93 306.33,47.11 305.82,47.11 305.3,46.59 291.02,46.59 290.33,47.28 287.38,47.28 286.53,48.12 283.04,48.12 281.48,49.68 277,49.68 272.63,54.06 268.06,58.63 266.59,58.63 260.68,64.54 260.68,67.62 259.45,68.86 259.45,69.82 257.96,71.31 257.96,73.25 257.12,74.09 257.12,74.36 257.12,76.82 255.61,78.34 255.61,79.51 255.61,79.51 255.61,79.56 254.78,80.38 254.78,82.48 254.14,83.12 254.14,85.14 251.98,87.3 250.61,87.3 247.73,90.18 247.06,90.85 244.19,90.85 243.54,91.5 240.2,91.5 240.01,91.69 239.23,91.69 239.23,91.69 238.89,91.69 238.88,91.69 238.1,91.69 237.55,92.25 237.55,92.48 237.16,92.87 237.15,92.87 237.13,92.89 234.31,92.89 234.19,93.01 232.02,95.18 230.95,95.18 228.1,98.04 225.85,98.04 225.06,98.83 218.74,98.83 217.15,97.24 213.84,97.24 212.69,96.09 208.11,96.09 207.08,95.06 205.18,95.06 203.44,96.79 201.25,96.79 200.29,95.83 196.86,95.83 196.13,96.56 195.43,96.56 195.16,96.83 194.5,96.83 192.89,98.45 190.05,98.45 189.62,98.01 182.6,98.01 182.24,97.66 181.04,97.66 180.67,98.02 180.28,98.02 179.68,98.63 177.8,98.63 177.16,99.27 176.93,99.5 176.73,99.5 176.66,99.56 175.88,100.35 175.04,100.35 174.31,101.09 174.01,101.09 173.79,101.3 172.76,101.3 172.1,101.96 168.8,101.96 168.06,102.7 168.06,105.44 167.47,106.04 166.53,106.04 165.26,107.31 164.86,107.31 163.75,108.42 162.79,108.42 162.44,108.77 161.3,108.77 160.81,108.29 156.84,108.29 156.29,108.84 153.88,108.84 152.89,107.84 150.98,107.84 150.25,108.57 149.43,108.57 149.04,108.96 146.83,108.96 145.72,110.07 143.17,110.07 142.75,110.48 141.76,110.48
USB20_P3: length 241.7
  TOP w0.089: v2(130.35,115.33) 130.65,115.03 130.65,114.94
  TOP w0.101: UH1.AG10 130.65,114.94
  TOP w0.102: v2(320.48,47.07) 320.48,46.06 320.18,45.77 v4(319.89,45.77) 319.12,45.77 317.65,44.3 JIO1.17
  IN4 w0.089: v2(130.35,115.33) 130.55,115.13 130.55,114.9 130.8,114.65 132.86,114.65 133.28,114.22 133.28,113.21 134.59,111.91 138.6,111.91 139.31,111.2 141.76,111.2
  IN4 w0.109: 141.76,111.2 143.05,111.2 143.48,110.77 146.02,110.77 147.07,109.72 149.3,109.72 149.75,109.28 150.69,109.28 150.94,109.02 151.78,109.02 152.06,109.3 153.1,109.3 153.33,109.53 153.58,109.53 153.59,109.54 156.58,109.54 156.59,109.53 163.66,109.53 165.05,108.14 165.43,108.14 166.82,106.75 167.76,106.75 169.29,105.21 169.29,104.08 170.23,103.14 172.25,103.14 173.36,102.04 174.97,102.04 175.89,101.11 177.36,101.11 179.13,99.34 179.97,99.34 180.58,98.73 188.96,98.73 189.38,99.15 193.33,99.15 193.87,98.61 196.54,98.61 197.14,98.01 203.96,98.01 204.98,96.98 207.32,96.98 207.62,97.28 211.8,97.28 213.66,99.14 217.85,99.14 218.27,99.56 225.21,99.56 225.46,99.8 229.07,99.8 231.28,97.59 231.28,96.92 234.61,93.59 237.95,93.59 238.74,92.81 240.21,92.81 240.62,92.39 240.91,92.39 241.06,92.24 246.67,92.24 250.9,88.01 252.27,88.01 254.85,85.44 254.85,83.43 255.54,82.73 255.54,80.7 256.31,79.93 256.31,79.22 256.31,78.63 257.83,77.11 257.83,74.38 258.78,73.43 258.78,72.11 260.15,70.73 260.15,69.15 261.87,67.44 261.87,65.82 265.14,62.55 277.29,50.39 281.77,50.39 283.34,48.83 286.91,48.83 287.75,47.99 290.62,47.99 291.31,47.29 305.01,47.29 306.34,48.63 310.02,48.63 312.02,50.63 315.07,50.63 318.88,46.82 319.28,46.41 320.11,46.41 320.34,46.64 320.34,46.92 v2(320.48,47.07)
USB20_P4: length 223.7
  TOP w0.089: UH1.AE2 134.31,113.99 134.41,113.89 134.79,113.89 135.02,113.66 135.18,113.66 135.32,113.79 v2(135.32,113.82)
  TOP w0.102: JIO1.30 310.5,41.3 310.02,40.82 309.13,40.82 308.47,41.48 308.47,43.11 v4(304.02,47.57) 303.73,47.86 v2(303.73,48.85)
  IN4 w0.089: v2(135.32,113.82) 135.74,113.39 135.74,113.06 135.96,112.85 139.37,112.85 139.63,113.11 141.17,113.11 141.3,113.24 141.76,113.24
  IN4 w0.109: 141.76,113.24 144.7,113.24 145.23,112.71 146.06,112.71 146.5,113.15 147.91,113.15 149.42,111.64 149.73,111.64 150.55,110.83 152.6,110.83 152.72,110.95 164.32,110.95 164.9,110.37 167.25,110.37 169.27,108.35 171.58,106.04 172.42,106.04 172.83,105.63 172.83,104.99 173.84,103.97 175.11,103.97 176.56,102.52 178.11,102.52 178.87,101.76 179.87,101.76 181.49,100.14 182.65,100.14 183.52,101 184.62,101 184.95,100.67 196.7,100.67 197.95,99.42 207.31,99.42 207.54,99.65 208.65,99.65 210.11,101.11 210.63,101.11 211.5,101.11 212.62,102.23 213.11,102.23 213.26,102.38 215.52,102.38 215.84,102.06 218.54,102.06 219.26,101.34 229.56,101.34 232.77,98.13 232.77,97.43 234.83,95.37 239.86,95.37 240.85,94.38 243.08,94.38 243.42,94.04 248.45,94.04 249.64,92.85 249.86,92.85 250.46,92.25 250.46,92.04 256.33,86.17 256.33,84.04 257.73,82.65 257.73,79.22 259.26,77.68 259.26,74.98 260.59,73.65 260.59,72.39 261.59,71.39 261.59,69.75 263.3,68.03 263.3,66.38 277.86,51.82 282.37,51.82 283.93,50.26 287.57,50.26 288.43,49.4 302.14,49.4 302.8,50.06 303.58,50.06 304.06,49.59 304.06,49.18 v2(303.73,48.85)
USB20_P5: length 76.3
  TOP w0.089: UH1.AC3 134.06,112.83 134.11,112.78 134.46,112.78 134.59,112.65 136.42,112.65 136.79,112.28 137.23,112.28 137.24,112.27 137.3,112.27 137.31,112.27 137.32,112.27
  TOP w0.102: 137.32,112.27 v4(137.95,112.27) 138.92,112.27 139.22,112.57 140.81,112.57 140.99,112.39 140.99,112.26 v2(140.82,112.1)
  IN1 w0.089: 141.6,114.23 141.59,114.21 141.59,114.2 141.47,114.08 141.47,113.03 141.05,112.61 141.05,112.32 v2(140.82,112.1)
  IN1 w0.109: 141.6,114.23 145.86,118.49 147.65,118.49 148.58,119.41 152.07,119.41 152.19,119.53 153.45,119.53 154.02,120.11 154.02,120.53 154.55,121.06 155.59,121.06 157.02,122.49 157.39,122.49 157.39,122.5 157.42,122.5 157.43,122.51 158.2,123.27 159.88,123.27 162.64,126.03 162.64,129.01 162.4,129.25 162.4,140.13 166.22,143.95 166.22,144.5 166.86,145.14 167.03,145.31 167.95,145.31 169.88,147.24 171.33,147.24 172.66,148.57 172.66,149.54 172.44,149.75 172.44,150.57 172.7,150.82 173.46,150.82 173.71,150.57 173.71,150.03 173.84,149.9 174.22,149.9 174.75,150.44 174.75,152.25 v2(174.54,152.46)
  BOTTOM w0.102: JDOCK1.66 174.75,155.02 174.92,154.85 174.92,153.81 174.71,153.59 174.71,152.62 v2(174.54,152.46)
USB20_P6: length 110.2
  TOP w0.089: 137.71,113.07 137.69,113.07 137.68,113.07 137.28,113.07 135.96,114.39 134.53,114.39 134.07,114.67 133.9,114.76 UH1.AF3
  TOP w0.102: v2(145.84,112.1) 145.84,112.26 145.39,112.71 v4(144.23,112.71) 141.23,112.71 140.87,113.07 137.71,113.07
  IN1 w0.109: v2(211.01,128.63) 208.93,128.63 207.97,129.59 204.55,129.59 199.9,134.23 199.9,137.02 198.09,138.83 197.58,138.83 196.28,140.13 189.63,140.13 188.76,140.99 182.52,140.99 182.14,140.61 182.14,140.1 181.47,139.44 174.17,139.44 173.87,139.75 168.42,139.75 165.82,137.14 165.82,133.33 166.48,132.66 166.48,124.93 163.4,121.85 163.4,120.12 162.83,119.55 162.58,119.55 161.68,118.65 160.77,118.65 159.86,117.74 158.79,117.74 155.12,114.07 154.6,114.07 153.22,115.45 150.69,115.45 150.61,115.53 149.91,115.53 148.07,113.69 146.73,113.69 145.84,112.8 v2(145.84,112.1)
  BOTTOM w0.102: v2(211.01,128.63) 211.33,128.31 211.45,128.31 211.56,128.2 JNGFF1.3
USB20_P7: length 76.6
  TOP w0.089: 137.71,111.81 137.69,111.81 137.68,111.8 136.21,111.8 135.69,112.32 135.69,112.43 135.65,112.47 135.5,112.47 135.46,112.43 135.46,112.34 135.4,112.28 135.3,112.28 135.25,112.33 135.25,112.41 135.2,112.47 135.07,112.47 135.04,112.43 135.04,112.37 134.98,112.32 134.77,112.32 134.74,112.35 134.74,112.4 134.68,112.47 134.42,112.47 UH1.AB2
  TOP w0.102: 137.71,111.81 139.01,111.81 139.25,111.56 v4(140.09,111.56) 142.47,111.56 142.59,111.68 142.59,111.77 142.52,111.83 142.24,111.83 142.17,111.91 142.17,112.05 142.24,112.11 v2(142.24,112.11)
  IN1 w0.109: v2(142.24,112.11) 142.45,112.32 142.45,114.03 146.19,117.77 147.96,117.77 148.86,118.68 152.35,118.68 152.51,118.83 154.16,118.83 154.35,118.64 155.25,118.64 155.55,118.93 155.55,120.01 155.54,120.02 157.31,121.79 157.68,121.79 157.69,121.79 157.71,121.79 157.84,121.92 158.43,122.51 160.12,122.51 163.35,125.74 163.35,126.38 163.91,126.94 163.91,128.45 163.49,128.87 163.49,131.78 163.22,132.05 163.22,139.94 166.32,143.05 167.97,143.05 169.82,144.89 170.88,144.89 171.24,145.24 171.24,145.74 176.27,150.77 176.27,150.88 v2(175.96,151.19)
  BOTTOM w0.102: v2(175.96,151.19) 176.33,151.56 176.33,155 176.25,155.07 JDOCK1.72
USB20_P8: length 276.8
  TOP w0.089: v2(131.51,117.66) 131.51,117.62 131.97,117.17 UH1.AL7
  IN4 w0.089: v2(131.51,117.66) 131.5,117.65 131.5,117.24 131.61,117.13 131.93,117.13 133.07,115.99 133.31,115.99 133.93,115.37 133.93,113.76 135.02,112.67 141.41,112.67 141.48,112.75 141.76,112.75
  IN4 w0.109: v2(326.72,24.34) 326.39,24.67 326.39,25.83 326.2,26.02 326.2,31.79 329.33,34.92 330.14,34.92 330.78,35.55 330.78,37.5 331.59,38.31 331.59,39.98 332.11,40.49 332.11,41.02 332.69,41.6 332.69,43.28 331.79,44.18 331.79,46.46 328.95,49.3 324.31,49.3 323.05,48.04 318.96,48.04 318.58,48.42 317.17,49.83 316.56,50.44 315.27,51.73 309.13,51.73 306.95,49.55 305.7,49.55 304.37,48.22 297.48,48.22 296.79,48.91 288.15,48.91 287.29,49.77 283.73,49.77 283.47,50.03 282.17,51.33 277.66,51.33 273.72,55.27 262.81,66.18 262.81,66.59 262.81,67.83 261.1,69.55 261.1,71.19 260.1,72.19 260.1,72.97 260.1,73.45 258.77,74.77 258.77,77.48 257.24,79.01 257.24,80.44 256.52,81.16 256.52,83.14 255.77,83.89 255.77,86 250.67,91.1 250.67,91.13 250.19,91.61 249.71,91.61 249.43,91.89 249.43,92.34 248.22,93.55 240.98,93.55 239.65,94.88 234.62,94.88 232.25,97.25 232.25,97.94 229.42,100.78 223.8,100.78 223.54,100.52 223.2,100.52 222.94,100.78 219.13,100.78 218.51,101.4 215.87,101.4 214.59,100.13 213.13,100.13 211.66,98.66 209.3,98.66 208.81,99.15 208.29,99.15 208.29,99.14 207.73,99.14 207.52,98.93 197.6,98.93 196.41,100.12 184.63,100.12 184.16,99.65 180.96,99.65 180.35,100.26 179.56,100.26 178.89,100.93 177.78,102.03 176.34,102.03 174.91,103.46 173.55,103.46 171.93,105.08 170.81,105.08 170.48,105.41 170.48,106.37 168.25,108.6 166.67,108.6 165.97,109.3 165.21,109.3 164.05,110.46 152.94,110.46 152.8,110.32 150.28,110.32 149.94,110.66 147.43,110.66 146.4,111.69 144.72,111.69 143.67,112.75 141.76,112.75
  BOTTOM w0.102: v2(326.72,24.34) 326.36,24.71 326.36,24.99 326.58,25.21 327.35,25.21 327.42,25.14 327.42,25.02 327.51,24.93 JNGFF2.7
USB20_P9: length 73.1
  TOP w0.089: 136.87,110.84 136.86,110.84 136.02,110.84 135.26,111.61 134.8,111.61 134.31,111.87 UH1.AA2
  TOP w0.102: v2(143.41,108.3) 143.41,109.46 142.23,110.64 138.41,110.64 138.21,110.84 136.87,110.84
  IN3 w0.127: v2(115,139.59) 115.57,139.02 115.71,139.02 120.21,134.53 121.12,134.53 121.63,134.02 127.5,134.02 128.86,132.67 131.94,132.67 133.6,131.01 139.31,131.01 140.69,129.62 140.69,126.8 141.45,126.04 141.45,124.71 142.09,124.07 142.09,123.59 142.92,122.77 145.2,120.48 145.2,114.96 144.58,114.33 144.58,114.33 144.29,114.04 144.29,110.28 145.33,109.24 145.33,108.1 144.76,107.53 143.99,107.53 143.62,107.9 143.62,108.09 v2(143.41,108.3)
  BOTTOM w0.102: v2(115,139.59) 114.93,139.53 114.8,139.53 114.37,139.95 114.37,140.32 115.59,141.54 116.28,141.54 116.54,141.29 116.54,141.02 116.48,140.96 116.32,140.96 116.25,140.9 L11.1 116.08,140.3 R430.1
USB20_P9_R: length 29
  TOP w0.102: v2(126.77,132.61) 126.95,132.79 126.95,133.1 127.21,133.36 128.25,133.36 129.05,132.57 132.88,132.57 133.03,132.42 135.59,132.42 135.91,132.11 135.91,131.85 136.3,131.45 JTS1.3
  BOTTOM w0.102: v2(126.77,132.61) 126.91,132.75 126.91,132.95 126.75,133.1 120.39,133.1 120.22,133.27 v4(119.9,133.59) 119.75,133.74 119.68,133.81 119.68,135.77 119.55,135.9 119.36,135.9 119.28,135.82 119.28,135.39 119.09,135.2 D20.3 118.24,135.78 118.11,135.91 117.72,135.91 116.25,137.38 L11.2 116.08,139.39 R430.2
USB20_P10: length 131
  TOP w0.089: UH1.AJ7 v2(131.72,116.49)
  TOP w0.102: JUSH1.18 70.37,37.3 v2(69.9,36.83)
  IN3 w0.089: v2(131.72,116.49) 131.56,116.49 131.41,116.33 131.41,116.11 131.49,116.02 133.57,116.02 134.17,115.42 134.17,112.88 135.66,111.4 135.66,108.29 135.05,107.68 135.05,102.38 135.27,102.16 135.27,101.5 135.31,101.46 135.31,101.25 135.23,101.18
  IN3 w0.127: v2(69.9,36.83) 69.83,36.9 69.83,37.47 69.95,37.6 70.2,37.6 70.67,38.08 70.67,38.86 70.08,39.45 68.92,39.45 66.33,42.03 66.33,50.5 71.43,55.59 72.24,55.59 75.39,58.74 75.39,59.34 98.81,82.76 105.68,82.76 112.18,89.27 115.43,89.27 117.25,91.09 121.6,91.09 122.19,90.49 126.12,90.49 126.22,90.6 129.35,90.6 130.12,91.37 130.12,92.18 131.81,93.88 131.96,94.03 131.96,96.54 134.34,98.93 134.34,99.49 134.4,99.55 134.4,100.35 135.23,101.18
USB20_P11: length 78.1
  TOP w0.089: 137.61,110.14 135.88,110.14 134.91,111.11 134.71,111.11 134.58,110.98 134.32,110.98 134.28,111.02 134.2,111.02 134.01,111.2 UH1.W3
  TOP w0.102: 137.61,110.14 137.84,109.91 141.74,109.91 v4(142.22,109.43) 142.5,109.14 142.5,108.63 v2(142.14,108.26)
  IN3 w0.127: v2(105.39,133.26) 105.61,133.26 105.71,133.36 105.71,133.49 105.82,133.6 112.61,133.6 115.17,136.16 116.88,136.16 119.53,133.52 120.64,133.52 121.14,133.02 123.93,133.02 125.02,131.92 127.42,131.92 127.74,131.6 131.57,131.6 133.17,130 138.89,130 139.68,129.2 139.68,124.5 140.52,123.67 140.52,123.04 141.04,122.51 141.18,122.37 141.18,121.2 141.65,120.73 143.4,120.73 143.73,120.4 143.73,119.19 144.09,118.83 144.09,115.65 143.24,114.81 143.24,109.84 142.47,109.06 142.47,108.6 142.14,108.27 v2(142.14,108.26)
  BOTTOM w0.102: R428.1 103.13,132.98 L10.4 103.3,131.97 103.48,131.78 104.36,131.78 104.75,132.18 104.75,132.41 104.96,132.61 104.96,133.11 105.11,133.26 v2(105.39,133.26)
USB20_P11_R: length 30.9
  TOP w0.102: JEDP1.16 120.14,143.73 120.31,143.84 120.33,143.94 120.49,144.86 121.04,145.41 121.48,145.41 v2(121.66,145.59)
  IN1 w0.109: v2(106.28,137.87) 106.46,137.69 112.13,137.69 113.53,139.09 115.75,139.09 117.17,140.51 117.17,142.81 119.63,145.26 120.68,145.26 120.92,145.5 121.57,145.5 v2(121.66,145.59)
  BOTTOM w0.102: v2(106.28,137.87) 106.21,137.8 105.32,137.8 105.2,137.93 104.8,137.93 103.52,136.65 103.52,136.33 103.2,136.01 D21.3 102.58,135.61 103.3,134.89 L10.3 103.13,133.89 R428.2
USB_OC0#: length 113.6
  TOP w0.089: UH1.AD43 113.89,113.93 113.69,113.93 113.61,114 113.04,114 112.76,114.28 112.37,114.28
  TOP w0.102: 112.37,114.28 111.67,114.28 111.23,114.73 109.72,114.73 v2(109,114.01) 108.33,114.68 RPH6.4 ; v2(54.08,42.33) 53.68,41.93 53.17,41.93 53.09,41.85 JIO2.80
  IN2 w0.127: v2(109,114.01) 109,113.13 108.41,112.54 107.57,112.54 106.57,111.54 106.57,111.53 106.32,111.28 106.31,111.28 105.68,110.65 105.47,110.65 102.87,108.06 102.87,104.96 103.26,104.57 103.26,103.94 104.06,103.15 104.06,102.8 103.52,102.26 103.52,99.13 105.91,96.73 105.91,94.26 105.54,93.89 105.54,90.61 v2(105.28,90.35)
  IN4 w0.109: v2(105.28,90.35) 103.98,89.05 102.94,89.05 71.16,57.27 71.16,51.09 63.02,42.95 54.7,42.95 v2(54.08,42.33)
USB_OC1#: length 297.1
  TOP w0.089: UH1.AD42 114.6,113.07 114.45,112.92 113.71,112.92 113.69,112.94 113.45,112.94 113.44,112.92 113.2,112.69 112.74,112.69 112.53,112.48 112.37,112.48
  TOP w0.102: 112.37,112.48 111.8,112.48 110.72,111.4 109.54,111.4 107.92,113.02 v2(107.92,113.26) 107.84,113.18 RPH6.1 ; v2(310.26,43.01) 310.55,43.3 JIO1.22
  IN1 w0.089: 112.37,116.03 112.69,116.03 113.83,117.18 115.92,117.18 116.9,118.15 118.19,118.15 119.01,117.34 122.57,117.34 122.66,117.42 122.96,117.42 123.8,116.58 126.64,116.58 127.29,117.24 133.19,117.24 134.55,118.59 134.55,123.12 135.92,124.49 137.91,124.49 138.73,125.31 138.73,125.95 138.61,126.07 138.61,126.2
  IN1 w0.109: 112.37,116.03 112.25,115.91 110.1,115.91 108.44,114.25 108.44,113.78 v2(107.92,113.26) ; 138.61,126.2 138.61,126.46 139.8,127.65 141.63,127.65 141.9,127.38 143.72,127.38 145.01,128.68 147.84,128.68 148.5,129.34 149.49,129.34 150.05,129.9 151.05,129.9 151.74,129.21 155.22,129.21 156.48,130.48 156.48,131.28 157.33,132.13 v2(157.33,132.16)
  IN3 w0.127: v2(310.26,43.01) 310.26,43.82 308.14,45.93 302.27,45.93 301.96,46.25 298.97,46.25 296.68,48.53 279.96,48.53 261.85,66.65 261.85,69.26 257.73,73.39 257.73,82.89 256.54,84.08 256.54,86.88 256.96,87.31 256.96,88.64 256.68,88.93 256.68,89.87 255.72,90.83 255.02,90.83 254.1,91.74 251.02,91.74 249.01,93.74 247.59,93.74 246.7,94.63 246.7,95.14 244.19,97.64 241.53,97.64 237.59,101.58 234.57,101.58 231.5,98.52 231.5,98.26 228.53,95.3 227.67,95.3 226.36,96.61 226.36,96.64 222.26,100.73 220.18,100.73 218.57,102.34 218.57,104.77 217.92,105.42 217.92,107.9 216.88,108.94 216.88,110.4 216.46,110.81 216.46,113.27 215.66,114.07 215.66,114.93 215.5,115.09 215.5,117.22 215.7,117.42 215.7,122.84 215.18,123.36 215.18,128.04 v2(215.01,128.22)
  IN4 w0.109: v2(215.01,128.22) 213.01,130.21 208.73,130.21 208.48,130.47 193.83,130.47 193.75,130.54 189.68,130.54 189.22,130.08 187.83,130.08 186.45,128.7 174.33,128.7 172.53,130.49 165.22,130.49 162.95,132.76 158.44,132.76 157.84,132.16 v2(157.33,132.16)
USB_OC2#: length 296.2
  TOP w0.089: UH1.AD39 v2(116.18,114.29)
  TOP w0.102: v2(316.74,43.3) 316.24,43.8 JIO1.19 ; v2(108.54,113.26) 108.12,113.68 RPH6.2
  IN1 w0.089: v2(116.18,114.29) 116.78,114.89 120.37,114.89 120.88,115.4 127.23,115.4 127.55,115.72 132.43,115.72 135.11,118.4 135.11,120.21 135.83,120.94 136.83,120.94 137.47,121.57 138.32,121.57 139.88,123.13 139.88,125.65 139.95,125.72
  IN1 w0.109: v2(298.84,38.65) 298.31,38.12 297.44,38.12 296.28,39.27 290.7,39.27 290.21,39.76 288.86,39.76 287.11,41.52 282.53,41.52 280.21,43.84 275.05,43.84 266.46,52.42 264.96,52.42 257.57,59.81 252.94,59.81 251.99,60.76 250.06,62.69 250.06,71.82 250.06,72.78 246.46,76.38 246.46,77.54 246.13,77.87 246.13,79.04 240.49,84.68 240.49,86.17 240.07,86.59 240.07,86.59 238.29,88.37 238.29,89.79 236.03,92.06 236.03,92.97 230.85,98.14 v2(230.16,98.14) ; 139.95,125.72 140.41,126.18 141.02,126.18 141.44,125.77 141.44,125.2 142.58,124.05 148.53,124.05 148.92,124.44 152.37,124.44 152.67,124.75 152.67,124.89 152.67,124.89 152.67,125.09 153.15,125.57 154.31,125.57 154.43,125.69 154.43,126.33 155.22,127.12 156.08,127.12 158.92,129.96 v2(158.92,130.51)
  IN2 w0.127: v2(298.84,38.65) 299.66,38.65 300.63,39.63 308.01,39.63 309.51,41.13 314.58,41.13 v2(316.74,43.3)
  IN3 w0.127: v2(228.79,125.64) 228.86,125.57 228.92,125.57 230.73,123.77 230.73,120.78 230,120.06 230,114.27 230.28,113.99 230.28,112.06 230,111.78 230,110.05 231.33,108.72 231.33,106.6 231.94,105.99 231.94,103.72 231.5,103.28 231.5,102.85 229.91,101.26 229.91,98.38 v2(230.16,98.14)
  IN4 w0.109: v2(228.79,125.64) 214.75,125.64 213.84,126.55 212.11,126.55 211.46,125.9 211.46,125.67 211.3,125.51 208.69,125.51 207.55,126.65 205.49,126.65 204.86,126.03 201.94,126.03 201.23,126.74 197.06,126.74 196.2,125.88 194.34,125.88 193.48,126.74 187.29,126.74 186.96,127.07 174.35,127.07 173.96,126.68 169.94,126.68 167.94,128.68 163.81,128.68 161.6,130.9 159.3,130.9 v2(158.92,130.51)
  BOTTOM w0.089: 112.37,113.43 112.57,113.43 113.07,112.94 114.83,112.94 v2(116.18,114.29)
  BOTTOM w0.102: 112.37,113.43 112.17,113.43 111.72,112.98 110.31,112.98 110.03,113.26 v1(109.63,113.26) v2(108.54,113.26)
USB_OC3#: length 291.7
  TOP w0.089: 112.37,113.45 112.6,113.45 112.68,113.37 113.3,113.37 113.47,113.2 UH1.AC44
  TOP w0.102: RPH6.3 107.85,114.18 v2(107.92,114.11) 108.32,114.11 109.07,113.36 v1(109.07,113.13) 109.07,112.22 109.67,111.63 110.55,111.63 111.93,113.01 111.93,113.24 112.14,113.45 112.37,113.45 ; JIO1.24 310.86,42.8 310.56,42.5 310.06,42.5 v2(309.61,42.95)
  IN1 w0.089: 112.37,116.56 112.91,116.56 113.7,117.36 115.84,117.36 116.9,118.41 117.26,118.41 117.54,118.69 119.82,118.69 120.24,118.27 122.77,118.27 123.59,117.46 128.75,117.46 129.26,117.96 129.6,117.96 129.83,118.19 132.33,118.19 134.37,120.24 134.37,123.2 135.84,124.67 137.59,124.67 137.84,124.92 137.84,125.81 138.23,126.2
  IN1 w0.109: v2(107.92,114.11) 107.92,114.29 109.92,116.29 111.74,116.29 112.01,116.56 112.37,116.56 ; v2(298.22,38.7) 297.19,38.7 296.38,39.51 290.79,39.51 290.31,40 288.96,40 287.2,41.75 282.63,41.75 280.31,44.07 275.15,44.07 266.56,52.66 265.06,52.66 257.67,60.05 253.04,60.05 252.15,60.93 252,61.09 250.3,62.78 250.3,72.87 246.7,76.47 246.7,77.64 246.37,77.97 246.37,79.18 240.72,84.83 240.72,86.27 240.58,86.41 240.58,86.41 238.53,88.46 238.53,89.89 236.26,92.16 236.26,93.06 230.09,99.24 230.09,99.94 225.78,104.24 225.78,105.5 223.9,107.38 v2(223.32,107.38) ; v2(156.7,132.16) 156.7,131.87 156.25,131.42 156.25,130.57 155.12,129.45 151.84,129.45 151.15,130.14 149.96,130.14 149.39,129.58 148.4,129.58 147.75,128.92 142.94,128.92 141.92,127.89 139.71,127.89 138.37,126.56 138.37,126.35 138.23,126.2
  IN2 w0.127: v2(298.22,38.7) 298.78,39.26 299.91,39.26 300.53,39.89 307.56,39.89 309.61,41.93 v2(309.61,42.95)
  IN3 w0.127: v2(223.32,107.38) 223.44,107.49 223.44,115 222.98,115.46 222.98,127.41 v2(222.41,127.99)
  IN4 w0.109: v2(222.41,127.99) 222.61,128.19 222.61,129.05 221.65,130.01 218.86,130.01 218.55,130.32 214.48,130.32 214.35,130.45 208.83,130.45 208.58,130.7 194.1,130.7 193.88,130.92 187.92,130.92 186.7,129.7 174.27,129.7 173.24,130.73 165.37,130.73 163.1,133 158.24,133 157.85,132.61 157.14,132.61 v2(156.7,132.16)
USB_PWR_SHR_LFT_EN#: length 217.2
  TOP w0.102: JIO2.78 53.04,41.35 53.4,41.7 53.76,41.7 v2(54.17,41.3) ; RE72.2 178.92,118.59 v2(178.44,118.11)
  IN2 w0.127: v2(188.54,113.53) 188.54,114.4 189.86,115.72 191.74,115.72 192.15,116.13 192.15,116.84 192.77,117.47 194.95,117.47 195.18,117.7 v2(195.18,117.98) ; v2(182.24,95.71) 181.8,95.27 181.02,95.27 178.92,93.17 178.92,92.29 175.05,88.41 156.07,88.41 151.8,84.14 144.24,84.14 143.49,84.88 138.82,84.88 138.34,85.36 137.01,85.36 136.25,86.12 132.19,86.12 131.55,86.76 126.07,86.76 124.99,85.68 123.84,85.68 123.02,86.51 117.29,86.51 116.92,86.88 111.37,86.88 110.62,86.13 107.94,86.13 106.53,84.72 105.73,84.72 105.07,84.06 102.71,84.06 101.14,82.48 99.65,82.48 91.89,74.72 91.89,62.33 78.54,48.98 74.7,48.98 72.46,46.74 72.46,45.72 67.02,40.29 66.83,40.29 65.9,39.35 58.92,39.35 57.17,41.1 54.36,41.1 v2(54.17,41.3)
  IN3 w0.127: v2(188.54,113.53) 188.57,113.49 188.57,108.36 186.19,105.97 186.19,104.69 185.68,104.19 185.68,102.78 184.95,102.06 184.95,99.04 182.24,96.32 v2(182.24,95.71)
  IN4 w0.109: v2(178.44,118.11) 178.61,118.11 178.79,117.93 179.97,117.93 180.12,118.08 181.21,118.08 181.59,118.46 183.19,118.46 183.54,118.81 187.74,118.81 188.65,117.9 192.41,117.9 192.68,117.63 194.83,117.63 v2(195.18,117.98)
  BOTTOM w0.102: U46.A8 179.05,116.53 179.09,116.57 179.09,117.65 178.64,118.11 v2(178.44,118.11)
USB_PWR_SHR_RHT_EN1#: length 186.7
  TOP w0.102: v2(178.07,107.57) 178.09,107.57 178.09,107.57 178.24,107.72 RE69.2 177.38,109.34 177.37,109.34 v1(177.32,109.39) ; v2(313.31,32.28) 313.14,32.46 313.14,35.67 312.75,36.06 312.75,36.56 312.51,36.8 JIO1.48
  IN2 w0.127: v2(313.31,32.28) 312.67,31.63 309.03,31.63 308.04,32.62 303.46,32.62 300.92,30.08 297.77,30.08 294.94,32.91 294.04,32.91 292.99,33.96 292.99,35.07 290.94,37.13 289.11,37.13 288.47,37.77 288.47,38.66 286.85,40.28 282.52,40.28 278.78,44.02 276.19,44.02 257.05,63.15 257.05,64.88 255.06,66.87 255.06,68.91 251.01,72.95 249.15,74.82 246.5,74.82 243.17,78.16 242.98,78.16 242.45,78.69 242.45,79.62 239.91,82.16 227.01,82.16 225.56,83.61 222.41,83.61 221.23,84.79 220.47,84.79 217.81,87.46 216.46,87.46 215.51,88.41 215.51,89.56 213.17,91.9 212.62,91.9 211.85,92.68 211.85,95.81 208.04,99.63 203.87,99.63 203.83,99.66 202.82,99.66 201.86,100.63 200.97,100.63 200.44,101.17 196.79,101.17 196.65,101.3 194.95,101.3 194.31,101.93 194.31,102.78 193.17,103.92 192.04,103.92 191.5,104.47 191.5,104.57 189.52,106.55 186.36,106.55 185.85,107.06 185.25,107.06 183.68,108.63 182.95,108.63 181.93,108.63 181.59,108.29 178.79,108.29 v2(178.07,107.57)
  BOTTOM w0.102: U46.B44 178.8,106.71 178.07,107.44 v2(178.07,107.57)
USB_PWR_SHR_RHT_EN2#: length 188.2
  TOP w0.102: JIO1.52 312.69,35.8 312.91,35.58 312.91,30.37 v2(313.8,29.48) ; RE70.2 183.01,104.47 v2(182.99,104.44) v1(182.99,103.8)
  IN2 w0.127: v2(182.99,104.44) 183.46,103.97 183.46,102.32 185.36,100.41 185.76,100.41 186.71,99.46 192.38,99.46 194.01,97.84 196.16,97.84 196.68,98.36 198.66,98.36 199.21,97.81 200.7,97.81 201.64,96.87 202.67,96.87 202.85,96.69 203.22,96.69 206.42,93.5 206.42,88.08 210.66,83.84 217.85,83.84 221.58,80.11 237.66,80.11 241.1,76.67 241.1,76.1 243.63,73.57 244.88,73.57 245.66,72.79 248.05,72.79 250.04,70.8 250.04,66.27 249.47,65.7 249.47,61.02 251.9,58.58 258.74,58.58 275.34,41.98 277.94,41.98 281.67,38.25 285.04,38.25 288.77,34.51 289.31,34.51 290.82,33 290.82,30.3 294.69,26.43 297.01,26.43 297.67,27.1 303.8,27.1 304.56,26.33 310.77,26.33 313.8,29.36 v2(313.8,29.48)
  BOTTOM w0.102: v2(182.99,104.44) 183.05,104.5 U46.A33
USB_PWR_SHR_RHT_EN3#: length 202.2
  TOP w0.102: v2(312.97,29.48) 312.68,29.78 312.68,34.56 312.44,34.8 JIO1.56 ; 182.22,118.3 182.88,117.65 v2(183.27,117.65) ; 182.22,118.3 182.07,118.46 181.36,118.46 RE71.2 ; 182.22,118.3 v1(182.22,118.31)
  IN1 w0.109: v2(183.27,117.65) 182.94,117.32 182.94,115.83 183.68,115.08 183.68,109.48 184.26,108.91 184.26,104.58 v2(184.19,104.52)
  IN2 w0.127: v2(312.97,29.48) 312.97,28.89 310.67,26.59 304.66,26.59 303.9,27.35 294.13,27.35 291.08,30.4 291.08,33.1 289.41,34.77 288.88,34.77 285.14,38.5 281.78,38.5 278.04,42.24 275.45,42.24 258.85,58.84 252.01,58.84 249.72,61.12 249.72,65.59 250.3,66.16 250.3,70.9 248.15,73.05 245.77,73.05 244.99,73.82 243.73,73.82 241.35,76.2 241.35,76.77 237.76,80.36 221.68,80.36 217.94,84.11 210.75,84.11 206.67,88.19 206.67,93.61 203.33,96.95 202.96,96.95 202.78,97.12 201.75,97.12 200.81,98.06 199.31,98.06 198.77,98.61 196.57,98.61 196.05,98.09 194.11,98.09 192.49,99.72 186.82,99.72 185.87,100.67 185.47,100.67 183.71,102.42 183.71,104.03 183.99,104.31 183.99,104.31 v2(184.19,104.52)
  BOTTOM w0.102: U46.B17 183.94,115.99 183.94,116.98 v2(183.27,117.65)
USB_PWR_SHR_VBUS_LFT_EN: length 177.2
  TOP w0.102: v2(53.56,41.29) 53.56,41.25 53.15,40.85 JIO2.76 ; v2(175.5,106.83) 175.75,106.59 RE73.2
  IN2 w0.127: v2(53.56,41.29) 54.05,41.78 54.55,41.78 54.97,41.36 57.28,41.36 57.81,40.83 59.02,40.83 59.5,40.34 59.95,40.34 60.43,40.83 64.85,40.83 69.51,45.49 71.14,45.49 71.7,46.04 71.7,47.06 74.38,49.74 78.22,49.74 91.13,62.64 91.13,75.04 99.33,83.25 99.54,83.25 99.55,83.25 99.76,83.25 100.83,83.25 102.4,84.82 104.75,84.82 105.41,85.48 106.19,85.48 107.65,86.94 110.35,86.94 111.05,87.64 117.23,87.64 117.6,87.27 123.33,87.27 124.16,86.44 124.67,86.44 125.75,87.53 131.86,87.53 132.51,86.88 136.57,86.88 137.33,86.12 138.66,86.12 139.14,85.65 143.81,85.65 144.56,84.9 151.48,84.9 156.57,89.99 162.1,89.99 162.87,89.22 174.11,89.22 176.1,91.21 176.1,92.34 177.52,93.77 177.52,93.94 177.78,94.19 177.78,94.2 v2(177.78,94.2)
  IN3 w0.127: v2(175.5,106.83) 175.5,106.63 176.57,105.56 176.57,103.75 176.27,103.45 176.27,102.21 177.89,100.59 177.89,96.55 177.21,95.86 177.21,94.73 177.74,94.2 v2(177.78,94.2)
  BOTTOM w0.102: U46.B50 175.8,106.48 175.5,106.78 v2(175.5,106.83)
USB_PWR_SHR_VBUS_RHT_EN1: length 208.2
  TOP w0.102: RE74.2 181.94,113.22 182.39,113.66 182.49,113.66 182.74,113.91 182.74,114.49 v2(182.71,114.53) ; v2(313.67,28.53) 314.24,29.1 314.24,30.12 313.61,30.75 313.61,31.89 313.8,32.08 313.8,32.6 313.36,33.03 313.36,35.77 313,36.13 313,36.95 312.65,37.3 JIO1.46
  IN1 w0.109: v2(183.57,104.48) 183.25,104.8 183.25,106.07 183.59,106.41 183.59,108.06 182.85,108.8 182.56,108.8 182.17,109.18 182.17,113.38 182.46,113.68 182.49,113.68 182.72,113.91 182.72,114.51 v2(182.71,114.53)
  IN2 w0.127: v2(183.57,104.48) 183.54,104.48 183.16,104.86 182.81,104.86 182.57,104.61 182.57,104.08 183.2,103.45 183.2,102.21 185.26,100.16 185.66,100.16 186.61,99.21 192.27,99.21 193.9,97.58 196.26,97.58 196.78,98.1 198.55,98.1 199.1,97.56 200.6,97.56 201.54,96.62 202.57,96.62 202.74,96.44 203.12,96.44 206.16,93.4 206.16,87.97 210.56,83.57 217.75,83.57 221.47,79.85 237.55,79.85 240.85,76.56 240.85,75.99 243.52,73.32 244.78,73.32 245.56,72.54 247.94,72.54 249.79,70.69 249.79,66.38 249.22,65.8 249.22,60.91 251.8,58.33 258.64,58.33 275.24,41.73 277.83,41.73 281.6,37.96 284.97,37.96 290.57,32.36 290.57,30.19 294.58,26.18 297.11,26.18 297.78,26.84 303.69,26.84 304.45,26.08 311.09,26.08 313.54,28.53 v2(313.67,28.53)
  BOTTOM w0.102: v2(182.71,114.53) 182.94,114.76 U46.B18 183.9,115.15 184.64,115.89 185.31,115.89 186.18,116.76 v3(186.18,117.2)
USB_PWR_SHR_VBUS_RHT_EN2: length 194.3
  TOP w0.102: v2(180.65,117.61) 182.02,116.24 RE75.2 ; JIO1.50 310.24,36.3 v2(310.23,36.29)
  IN1 w0.109: v2(310.23,36.29) 309.64,36.87 308.7,36.87 308.4,37.17 305.4,37.17 301.75,40.82 297.82,40.82 296.7,41.94 289.77,41.94 287.87,43.84 284.68,43.84 283.9,44.61 282.59,44.61 281.18,46.01 275.95,46.01 267.08,54.89 265.57,54.89 257.97,62.49 257.97,65.43 252.24,71.16 252.24,73.68 249.23,76.7 249.23,79.07 246.24,82.06 246.24,85.68 242.8,89.12 242.8,97.51 243.99,98.69 243.99,100.69 242.31,102.36 238.33,102.36 237.5,103.19 237.42,103.19 237.28,103.33 234.55,103.33 232.83,105.05 v2(232.39,105.05)
  IN2 w0.127: v2(180.65,117.61) 181.74,116.52 182.23,116.52 182.6,116.89 182.6,117.93 183.56,118.9 186.07,118.9 186.53,118.43 190.86,118.43 191.89,119.46 191.89,119.74 193.15,121 196.2,121 197.37,119.83 200.8,119.83 200.96,119.99 205.26,119.99 205.82,120.55 208.78,120.55 209.72,121.5 211.84,121.5 212.88,122.53 218.56,122.53 218.71,122.68 219.31,122.68 221.22,120.77 221.89,120.77 223.47,119.19 223.47,116.9 224.83,115.54 224.83,114.13 225.92,113.03 226.57,113.03 231.24,108.36 231.24,106.2 v2(232.39,105.05)
  BOTTOM w0.102: U46.A11 180.55,116.51 180.52,116.54 180.51,116.54 180.27,116.78 180.27,116.79 180.22,116.84 180.22,117.29 180.55,117.62 180.65,117.62 180.65,117.61 v2(180.65,117.61)
USB_PWR_SHR_VBUS_RHT_EN3: length 195
  TOP w0.102: v2(309.86,35.83) 310.39,35.3 JIO1.54 ; v2(180.64,116.99) 181.14,116.48 RE76.2
  IN1 w0.109: v2(225.01,110.23) 225.28,110.23 226.39,109.12 226.39,107.67 227.25,106.81 230.04,106.81 232.22,104.64 232.69,104.64 234.38,102.95 237.41,102.95 240.81,99.55 242.42,99.55 243.24,98.74 243.24,98.31 243.23,98.3 243.23,98.27 242.57,97.6 242.57,89.02 245.94,85.64 245.94,82.03 248.99,78.98 248.99,76.6 252.01,73.58 252.01,71.07 257.74,65.34 257.74,62.4 265.47,54.66 266.98,54.66 275.86,45.78 281.06,45.78 282.47,44.38 283.73,44.38 284.5,43.6 287.77,43.6 289.67,41.7 296.6,41.7 297.72,40.58 301.65,40.58 305.3,36.93 308.31,36.93 308.6,36.64 309.06,36.64 v2(309.86,35.83)
  IN2 w0.127: v2(224.16,116.82) 223.94,117.05 223.94,119.09 222.36,120.66 222.36,122.1 221.87,122.59 220.82,122.59 219.08,124.33 218.12,124.33 216.95,123.16 212.63,123.16 212.08,122.61 211.36,122.61 210.91,123.06 202.26,123.06 201.89,122.68 197.08,122.68 196.7,122.3 194.43,122.3 193.97,121.85 193.21,121.85 190.89,119.53 188.82,119.53 188.7,119.4 182.09,119.4 181.84,119.16 181.84,118.71 181.16,118.03 180.48,118.03 180.23,117.79 180.23,117.4 v2(180.64,116.99)
  IN3 w0.127: v2(225.01,110.23) 225.01,112.22 224.26,112.96 224.26,116.72 v2(224.16,116.82)
  BOTTOM w0.102: U46.A12 181.05,116.77 181.26,116.97 181.26,117.22 181.2,117.28 v3(181.16,117.28) 180.93,117.28 v2(180.64,116.99)
USH_DET#: length 179.7
  TOP w0.102: v2(176.43,100.68) 177.91,102.15 182.52,102.15 183.56,103.19 185.46,103.19 186.11,103.84 v2(186.11,103.97) ; RZ76.1 65.01,47.75 DZ3.2 64.57,48.51 69.98,53.92 v1(69.98,55.21) 69.98,65.82 93.02,88.86 97.82,88.86 99.56,90.59 100.1,90.59 104.91,95.4 106.79,95.4 108.28,93.9 108.48,93.9 109.16,93.21 109.73,93.21 110.09,92.86 v2(110.09,92.63)
  IN1 w0.109: v2(183.69,118.06) 183.78,117.97 183.78,115.32 183.92,115.18 183.92,109.58 185.08,108.42 185.08,107.37 185.92,106.53 185.92,104.7 186.11,104.51 v2(186.11,103.97)
  IN2 w0.127: v2(110.09,92.63) 110.08,92.63 111.2,93.75 132.66,93.75 134.13,95.22 135.61,95.22 136.03,95.63 146.79,95.63 149.03,97.87 154,97.87 158.32,102.19 160.59,102.19 162.6,100.18 167.45,100.18 167.72,100.45 171.35,100.45 171.67,100.13 172.55,100.13 173.54,99.14 175.72,99.14 175.95,99.37 175.95,99.37 176.2,99.61 176.2,99.62 176.39,99.82 176.39,100.6 176.43,100.64 v2(176.43,100.68)
  BOTTOM w0.102: U46.A16 183.05,116.6 182.86,116.8 182.86,117.85 183.06,118.06 v2(183.69,118.06) 183.69,118.29 183.56,118.42 182.87,118.42 182.86,118.41 182.35,118.41 182.23,118.54 181.61,118.54 181.33,118.26 R379.2
USH_DET#_R: length 4.5
  TOP w0.102: JUSH1.1 v1(65.71,45.8) 65.61,45.9 RZ76.2 65.13,46.83 65.08,46.78 DZ3.1
USH_PWR_STATE#: length 167.5
  TOP w0.102: JUSH1.5 64.88,43.8 RZ10.2 63.83,44.85 63.83,48.27 69.5,53.93 69.5,65.66 92.92,89.08 97.72,89.08 99.46,90.82 100.01,90.82 104.81,95.63 106.88,95.63 108.38,94.13 108.57,94.13 109.26,93.44 109.88,93.44 110.19,93.14 110.19,93.14 110.43,92.9 110.43,92.9 110.91,92.41 111.87,92.41 112.37,92.92 112.37,92.98 v2(112.36,93)
  IN2 w0.127: v2(112.36,93) 112.39,93 112.63,93.24 132.87,93.24 134.34,94.71 135.83,94.71 136.24,95.13 147.02,95.13 149.25,97.37 154.21,97.37 157.77,100.92 161.14,100.92 162.39,99.68 167.66,99.68 167.93,99.94 171.14,99.94 171.46,99.62 172.34,99.62 173.33,98.64 175.72,98.64 175.84,98.52 176.64,98.52 176.76,98.64 181.17,98.64 v2(181.49,98.32)
  IN3 w0.127: v2(181.49,98.32) 182.73,99.56 182.73,102.95 181.64,104.05 v2(181.46,104.05)
  BOTTOM w0.102: U46.A34 182.55,104.81 182.38,104.64 182.38,104.31 182.12,104.05 v2(181.46,104.05)
USH_SMBCLK: length 270.9
  TOP w0.102: Q366.3 244.41,103.41 244.11,103.7 243.73,103.7 243.11,104.33 242.66,104.33 242.52,104.46 241.91,104.46 241.77,104.33 240.99,104.33 240.27,105.05 239.2,105.05 v2(239.02,104.87) ; v2(69.92,38.3) JUSH1.16
  IN1 w0.109: v2(196.72,117.31) 197,117.31 197.08,117.23 197.08,116.53 197.28,116.33 197.83,116.33 198.16,116.67 198.16,117.1 198.17,117.1 198.17,118.15 198.79,118.77 200.7,118.77 201.25,118.22 201.25,118.13 201.29,118.09 201.29,117.62 201.34,117.58 201.34,117.11 201.68,116.78 204.49,116.78 204.99,117.27 207.88,117.27 212.07,113.08 216.32,113.08 216.47,112.93 219.88,112.93 220.19,113.25 223.43,113.25 224.42,112.26 227.03,112.26 228.95,110.34 229.05,110.34 229.05,110.34 229.15,110.34 229.47,110.34 230.97,108.83 230.97,108.32 230.97,108.09 232.63,106.43 233.37,106.43 233.65,106.15 238.17,106.15 238.84,105.48 238.84,105.05 v2(239.02,104.87)
  IN3 w0.127: v2(201.35,81.32) 201.47,81.44 202.03,81.44 202.46,81.87 202.46,83.25 201.17,84.53 201.17,89.1 202.49,90.42 202.49,93.77 201.03,95.23 201.03,98.54 198.2,101.37 198.2,102.38 200.17,104.35 200.17,105.03 198.54,106.66 198.54,108.54 198.43,108.66 198.43,109.43 199.53,110.53 199.53,112.52 199.02,113.03 198.8,113.03 198.21,113.63 198.21,114.14 198.43,114.37 198.43,115.36 198.04,115.76 197.59,115.76 196.72,116.63 v2(196.72,117.31)
  IN4 w0.109: v2(69.92,38.3) 69.74,38.48 69.74,38.93 70.61,39.8 70.61,42.58 97.47,69.45 97.47,73.99 97.47,74.45 111.69,88.67 115.61,88.67 116.51,89.57 124.01,89.57 124.79,90.35 134.09,90.35 134.16,90.28 136.97,90.28 137.63,89.62 139.57,89.62 140.09,90.14 141.96,90.14 143.94,88.16 148.12,88.16 153.08,83.21 162.05,83.21 162.87,82.38 162.87,81.19 164.36,79.7 170.3,79.7 172.22,81.63 174.02,81.63 175.15,80.49 179.71,80.49 180.35,81.13 184.95,81.13 186.03,82.21 198.76,82.21 199.52,81.44 201.22,81.44 v2(201.35,81.32)
  BOTTOM w0.102: U51.A50 197.25,116.97 196.92,117.31 196.7,117.31 196.7,117.31 v2(196.72,117.31)
USH_SMBDAT: length 270.1
  TOP w0.102: v2(238.41,104.87) 238.82,105.28 240.36,105.28 241.09,104.55 241.67,104.55 241.81,104.69 242.62,104.69 242.76,104.55 243.01,104.55 243.11,104.65 Q366.6 ; v2(69.32,38.29) 68.81,38.8 JUSH1.15
  IN1 w0.109: v2(197.15,115.05) 197.15,115.77 197.48,116.1 197.93,116.1 198.4,116.57 198.4,117 198.41,117 198.41,118.05 198.89,118.53 200.6,118.53 201.02,118.12 201.02,118.03 201.06,117.99 201.06,117.53 201.1,117.48 201.1,117.04 201.09,117.03 201.58,116.54 204.59,116.54 205.09,117.04 207.78,117.04 211.97,112.85 216.22,112.85 216.38,112.69 219.97,112.69 220.29,113.01 223.33,113.01 224.32,112.02 226.93,112.02 228.86,110.1 229.15,110.1 229.25,110.1 229.25,110.1 229.37,110.1 230.74,108.73 230.74,108.22 230.74,107.99 232.54,106.19 233.27,106.19 233.55,105.91 238.07,105.91 238.6,105.38 238.6,105.07 v2(238.41,104.87)
  IN3 w0.127: v2(201.35,81.9) 201.55,81.7 201.92,81.7 202.2,81.98 202.2,83.14 200.92,84.42 200.92,89.2 202.24,90.52 202.24,93.66 200.78,95.12 200.78,98.43 197.95,101.26 197.95,102.48 199.92,104.45 199.92,104.93 198.29,106.55 198.29,108.44 198.18,108.55 198.18,109.53 199.27,110.63 199.27,112.42 198.91,112.78 198.7,112.78 197.95,113.52 197.95,114.25 198.18,114.48 198.18,115.26 197.93,115.5 197.59,115.5 197.15,115.06 v2(197.15,115.05)
  IN4 w0.109: v2(201.35,81.9) 201.16,81.72 199.57,81.72 198.85,82.44 185.93,82.44 184.85,81.36 180.25,81.36 179.62,80.73 175.25,80.73 174.11,81.87 172.13,81.87 170.2,79.94 164.46,79.94 163.11,81.29 163.11,82.48 162.15,83.44 153.18,83.44 148.22,88.39 144.04,88.39 142.05,90.38 140,90.38 139.47,89.85 137.73,89.85 137.07,90.52 134.26,90.52 134.19,90.59 124.69,90.59 123.91,89.8 116.42,89.8 115.51,88.9 111.59,88.9 97.24,74.55 97.24,73.89 97.24,69.54 70.37,42.68 70.37,39.9 69.5,39.03 69.5,38.47 v2(69.32,38.29)
  BOTTOM w0.102: U51.B53 197,115.2 v2(197.15,115.05) ; v3(67.51,36.53) 67.57,36.53 v2(69.32,38.29)
VCT_LAN_R1: length 9.7
  TOP w0.102: R553.2 R558.1 254.41,119.91 253.95,119.45 253.95,118.16 253.6,117.81 253.6,116.89 253.18,116.47 252.92,116.47 251.95,115.49 251.95,114.98 251.44,114.47 v1(251.44,114.06) 251.44,113.62 251.33,113.51 U31.6
VGA_ID: length 6.9
  IN2 w0.127: v2(171.47,109.76) 172.04,109.19 173.41,109.19 174.34,110.12 v2(175.42,110.12)
  BOTTOM w0.102: R800.2 R803.1 171.57,109.86 v2(171.47,109.76) ; v2(175.42,110.12) 175.27,110.26 U46.B59
VID0_EDRAM_VR: length 5.4
  TOP w0.102: PR514.1 71.27,5.5 71.02,5.25 v1(71.02,3.45)
  TOP w0.254: PU500.4 73.47,6.55 PR512.2 72.42,5.5 PR514.1
VID0_EOPIO_VR: length 5.4
  TOP w0.102: PR1814.1 55.78,5.3 55.95,5.14 v1(55.95,3.31)
  TOP w0.254: PR1812.2 PR1814.1 55.99,5.81 55.99,5.99 56.35,6.36 PU1800.4
VID1_EDRAM_VR: length 5.3
  TOP w0.102: v1(68.64,5.49) PR513.2
  TOP w0.254: PR513.2 69.59,5.49 PR511.1 71.13,6.09 72.47,6.09 72.97,6.59 PU500.3
VID1_EOPIO_VR: length 5.4
  TOP w0.254: PU1800.3 55.85,6.56 55.58,6.28 55.2,6.28 55.08,6.41 v1(54.49,6.41) 54.35,6.41 54.06,6.12 54.06,5.79 PR1811.1 PR1813.2 PR1815.1
VLDOIN_1.2V:
  vias: v1(62.39,16)
VR_SVID_ALERT#: length 102.2
  TOP w0.102: PR1199.2 v2(263.68,41.74) PR1115.1 ; v2(204.69,7.85) 204.69,4.39 204.26,3.96 198.23,3.96 197.39,4.8 RC156.1 RC155.2 196.55,4.82 v1(195.94,4.21) ; PR1609.1 v2(257.84,33.68)
  IN1 w0.109: v2(257.84,33.68) 261.52,37.36 261.52,39.58 v2(263.68,41.74)
  IN4 w0.109: v2(257.84,33.68) 257.84,33.62 257.4,33.19 250.55,33.19 247.67,30.31 247.67,13.03 243.96,9.33 241.43,9.33 240.13,8.02 220.9,8.02 220.11,8.81 217.53,8.81 215.68,6.96 205.57,6.96 v2(204.69,7.85)
VR_SVID_CLK: length 134
  TOP w0.089: CPU1.BH32 194.41,28.97 v2(194.73,28.65)
  TOP w0.102: PR1104.2 263.97,42.69 v2(263.68,42.4) 263.39,42.69 PR1117.2 ; PR1611.1 256.64,33.36 v2(256.64,33.68)
  IN1 w0.109: v2(256.64,33.68) 256.65,33.68 257.07,34.1 257.56,34.1 261.03,37.56 261.03,40.52 261.14,40.63 261.85,40.63 261.95,40.74 261.95,40.95 261.85,41.06 261.14,41.06 261.03,41.17 261.03,41.39 261.14,41.5 261.85,41.5 261.95,41.61 261.95,41.83 261.85,41.94 260.68,41.94 260.56,42.06 260.56,42.37 260.68,42.5 262.21,42.5 262.34,42.37 262.34,41.68 262.46,41.55 262.74,41.55 262.87,41.68 262.87,42.39 263,42.51 263.56,42.51 v2(263.68,42.4)
  IN4 w0.089: 199.08,17.89 199.08,18.1 198.45,18.72 198.45,23.28 197.45,24.28 197.45,27.72 196.89,28.28 195.1,28.28 v2(194.73,28.65)
  IN4 w0.109: 199.08,17.89 199.08,15.79 200.92,13.95 200.92,10.41 202.37,8.96 204.3,8.96 205.81,7.45 215.48,7.45 217.33,9.3 220.31,9.3 221.1,8.51 239.93,8.51 241.23,9.82 243.76,9.82 247.18,13.23 247.18,30.51 250.34,33.68 251.01,33.68 251.12,33.78 251.12,34.82 251.24,34.95 251.42,34.95 251.55,34.82 251.55,33.78 251.66,33.68 251.88,33.68 251.99,33.78 251.99,34.12 252.1,34.23 252.32,34.23 252.43,34.12 252.43,33.78 252.54,33.68 252.75,33.68 252.86,33.78 252.86,34.12 252.97,34.23 253.19,34.23 253.3,34.12 253.3,33.78 253.41,33.68 253.63,33.68 253.74,33.78 253.74,34.65 253.86,34.78 254.05,34.78 254.17,34.65 254.17,33.78 254.28,33.68 254.5,33.68 254.61,33.78 254.61,34.48 254.74,34.6 254.92,34.6 255.05,34.48 255.05,33.78 255.16,33.68 255.38,33.68 255.48,33.78 255.48,35.24 255.61,35.36 255.79,35.36 255.92,35.24 255.92,33.78 256.03,33.68 v2(256.64,33.68)
  BOTTOM w0.102: v1(263.05,43.03) v2(263.68,42.4)
VR_SVID_DATA: length 126.5
  TOP w0.089: CPU1.BH29 192,29.58 v2(191.63,29.58)
  TOP w0.102: PR1105.1 v2(263.68,40.79) PR1113.2 ; PR1608.1 259.03,33.36 259.03,34.03 v2(259.08,34.08) ; RC157.2 197.34,6.45 197.62,6.73 v2(197.62,7.36)
  IN1 w0.109: v2(263.68,40.79) 262.01,39.12 262.01,37.01 v2(259.08,34.08)
  IN4 w0.089: v2(191.63,29.58) 191.78,29.43 192.44,29.43 193.91,27.96 193.91,27.83 194.68,27.06 195.95,27.06 196.05,26.95 196.45,26.55 196.45,24.78 198.1,23.13 198.1,17.89
  IN4 w0.109: v2(259.08,34.08) 258.93,33.93 258.93,33.58 258.05,32.69 255.72,32.69 254.49,31.46 249.52,31.46 248.16,30.1 248.16,12.83 244.16,8.83 241.64,8.83 240.33,7.53 220.7,7.53 219.91,8.32 217.73,8.32 215.89,6.47 202.9,6.47 201.56,7.82 199.19,7.82 198.35,6.98 198,6.98 v2(197.62,7.36) 197.62,7.71 199.94,10.03 199.94,13.55 198.1,15.39 198.1,17.89
VRALERT#: length 8.6
  TOP w0.089: UH1.BD23 124.1,123.64 124.76,124.31 v2(124.76,124.92)
  TOP w0.102: RH203.1 121.78,129.37 122.99,129.37 v2(123.47,128.89)
  BOTTOM w0.089: 123.47,126.2 123.47,126.01 124.56,124.92 v2(124.76,124.92)
  BOTTOM w0.102: 123.47,126.2 v1(123.47,128.19) v2(123.47,128.89)
VSET_5085: length 9.9
  BOTTOM w0.102: U51.A17 204.25,105.31 204.35,105.21 205.21,105.21 205.65,104.77 205.65,104.41 205.52,104.28 205.52,103.71 205.65,103.59 205.74,103.49 205.74,103.19 205.87,103.07 v1(205.87,101.7) 205.87,101.44 205.53,101.1 205.53,100.79 205.94,100.38 206.78,100.38 206.99,100.17 C320.1 R425.1
VSN_1PH: length 10
  TOP w0.102: PC1140.2 265.54,51.65 265.54,53.01 v1(265.46,53.09)
  TOP w0.203: PR1107.2 263.56,50.57 262.34,50.57 262.21,50.44 262.21,49.55 261.39,48.73 261.39,47.68 261.09,47.38 260.74,47.38 260.53,47.17 PU1100.51
  TOP w0.254: PC1140.2 PR1107.2
VSN_3PH_A: length 8.9
  TOP w0.203: v2(260.76,52.85) 260.95,52.85 261.14,52.66 261.14,50 261.01,49.87 260.6,49.87 260.22,49.49 259.77,49.49 258.95,48.66 PU1100.2
  BOTTOM w0.102: v1(259.84,54.95) 260.13,54.65 PR1123.2
  BOTTOM w0.254: PR1123.2 PC1110.2 260.44,53.17 v2(260.76,52.85)
VSP_1PH: length 6.4
  TOP w0.203: PC1105.2 261.86,50.64 261.86,49.72 261.24,49.1 v1(261.2,49.1) 261.16,49.1 260.86,48.8 260.21,48.8 260,48.58 260,48.23 260.07,48.16 260.07,48.15 260.34,47.88 260.34,47.63 260.28,47.57 PU1100.52
  TOP w0.254: PR1109.2 PC1105.2
VSP_3PH_A: length 7.8
  TOP w0.203: v2(261.71,51.96) 261.53,51.79 v1(261.53,51.02) 261.53,49.87 261.2,49.54 260.74,49.54 260.36,49.16 259.94,49.16 259.35,48.57 PU1100.1
  BOTTOM w0.254: v2(261.71,51.96) 261.45,52.22 PC1109.2 PR1121.2
VSYNC_DOCK: length 78.7
  TOP w0.102: JMXM1.190 173.25,80.51 173.49,80.75 173.49,80.98 174.03,81.53 174.39,81.53 175.62,82.76 176.57,82.76 177.65,83.84 177.65,84.79 177.22,85.22 v2(177.18,85.22)
  IN3 w0.127: v2(173.21,145.56) 173.21,145.24 174.31,144.14 174.31,136.76 175.68,135.39 175.68,128.62 176.8,127.5 176.8,125.66 180.01,122.46 180.01,115.64 179.46,115.09 179.46,113.58 179.72,113.32 179.72,108.3 180.34,107.69 180.34,105.76 179.45,104.87 179.45,103.29 181.08,101.65 181.08,99.43 180.33,98.68 180.33,94.33 179.05,93.05 179.05,91.17 178.86,90.98 178.86,87.61 178.52,87.27 178.52,86.72 178.25,86.44 178.25,85.77 177.7,85.22 v2(177.18,85.22)
  BOTTOM w0.102: JDOCK1.67 175.25,146.84 174.64,146.24 173.88,146.24 v2(173.21,145.56)
WLAN_DISBL#: length 73.5
  TOP w0.102: v2(226.76,113.75) 227.77,113.75 228.21,113.3 v1(229.06,113.3) 229.08,113.33 229.08,113.75 228.52,114.31 U15.4
  IN2 w0.127: v2(173.49,114.99) 173.49,116.19 174.17,116.87 174.73,116.87 174.88,117.03 174.88,117.23 175.33,117.69 175.77,117.69 176.35,117.11 177.2,117.11 177.55,117.47 177.55,118.32 177.86,118.63 178.64,118.63 178.96,118.31 178.96,118.08 179.1,117.94 179.67,117.94 180.62,118.89 180.62,119.04 180.96,119.37 181.34,119.37 182.12,120.16 188.51,120.16 188.98,120.63 189.86,120.63 190.58,121.35 191.99,121.35 193,122.36 193.76,122.36 194.21,122.81 196.49,122.81 196.88,123.2 199.91,123.2 199.93,123.19 201.09,123.19 202.2,124.3 205.02,124.3 205.62,123.71 215.84,123.71 216.99,124.85 219.28,124.85 220.31,123.82 221.84,123.82 223.09,122.57 223.09,121.36 224.44,120.01 224.44,117.5 226.58,115.37 226.58,113.93 v2(226.76,113.75)
  BOTTOM w0.102: U46.B68 174.28,114.76 174.05,114.99 v2(173.49,114.99)
WLAN_WIGIG60GHZ_DIS#: length 56.6
  TOP w0.102: D31.1 219.9,113.38 219.9,117.66 v1(218.82,118.75) 218.06,119.5 218.06,119.95 v2(217.66,120.35)
  IN2 w0.127: v2(175.55,116.96) 176.5,116.01 183.49,116.01 183.87,116.39 183.87,116.92 183.84,116.94 183.84,117.54 184.23,117.93 191.07,117.93 192.65,119.51 192.65,119.77 192.93,120.05 192.92,120.05 193.1,120.23 194.08,120.23 194.49,119.82 195.72,119.82 196.22,119.32 201.02,119.32 201.17,119.48 205.47,119.48 205.89,119.9 209.82,119.9 210.91,120.99 212.15,120.99 213.07,121.9 216.1,121.9 v2(217.66,120.35)
  BOTTOM w0.102: U46.A1 v2(175.55,116.96)
WLAN_WIGIG60GHZ_DIS#_R: length 4.7
  TOP w0.102: D31.2 221.29,112.86 221.45,113.02 v2(221.45,113.88) 221.45,113.92 221.98,114.45 v1(222.46,114.45)
  BOTTOM w0.102: v2(221.45,113.88) 221.27,114.07 221.27,114.55 220.86,114.95 JNGFF1.48
