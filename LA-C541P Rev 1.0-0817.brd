# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1_SMBDATA: length 139.6
  TOP w0.089: UH1.AW45 113.32,120.99 113.54,120.78 114.28,120.78 v2(114.59,120.47)
  TOP w0.102: RH81.2 107.39,123.61 107.76,123.97 v2(107.76,124)
  IN1 w0.089: 134.64,126.2 134.64,126.19 134.63,126.18 134.63,125.35 133.37,124.09 131.79,124.09 131.2,124.68 130.41,124.68 128.1,122.37 126.87,122.37 126.52,122.72 125.85,122.72 125.49,122.37 120.54,122.37 120.53,122.38 120.18,122.38 117.65,119.86 116.55,119.86 116.27,120.14 115.78,120.14 115.62,120.29 114.77,120.29 v2(114.59,120.47)
  IN1 w0.109: 134.64,126.2 134.64,126.4 134.92,126.68 134.92,128.96 134.92,129.17 136.53,130.78 141.04,130.78 141.77,131.51 141.77,131.75 142.12,132.1 145.65,132.1 146.79,133.24 149.72,133.24 150.83,132.13 151.97,132.13 152.59,131.51 153.64,131.51 153.89,131.76 154.74,131.76 154.98,131.99 v2(154.98,132.11)
  IN2 w0.089: 112.37,121.37 112.38,121.37 112.4,121.35 112.47,121.35 112.49,121.33 112.67,121.33 112.95,121.05 113.71,121.05 114.29,120.47 v2(114.59,120.47)
  IN2 w0.127: v2(107.76,124) 107.9,124 108.37,123.53 108.37,123.06 108.88,122.56 111.43,122.56 111.99,121.99 111.99,121.64 112.26,121.37 112.37,121.37
  IN3 w0.127: v2(206.67,112.86) 206.84,112.86 206.88,112.9 206.88,112.9 207.16,113.18 208.75,113.18 209.15,113.58 209.15,125.18 207.69,126.64 207.69,127.57 206.8,128.46 206.8,129.75 206.67,129.88 206.67,131.49 v2(206.84,131.66)
  IN4 w0.109: v2(154.98,132.11) 155.03,132.11 156.95,134.03 158.17,134.03 158.58,133.62 163.17,133.62 165.57,131.22 173.45,131.22 174.03,130.64 179.35,130.64 179.66,130.33 183.96,130.33 184.48,130.85 185.06,130.85 185.63,131.43 187.73,131.43 187.78,131.48 194.2,131.48 194.49,131.2 206.25,131.2 206.71,131.66 v2(206.84,131.66)
  BOTTOM w0.102: U51.A5 v2(206.67,112.86)
SNB_0.95V:
  vias: v1(327.36,11.92)
SNUB_1.35V:
  vias: v1(62.79,17.06)
SNUB_3V:
  vias: v1(346.56,26.43)
SNUB_CHG: length 5
  TOP w0.102: PR724.2 286.6,17.55 286.24,17.19 282.68,17.19 v1(282.55,17.32)
SOFT_START_GC: length 407.6
  TOP w0.254: v2(331.89,49.74) 332.2,50.05 PU1001.2
  IN2 w0.127: v2(336.31,45.9) 336.95,45.26 336.95,31.04 337.27,30.72 337.27,25.6 335.81,24.15 332.02,24.15 331.42,24.75 327.75,24.75 327.74,24.76 318.98,24.76 318.43,24.21 316.18,24.21 313.82,21.86 309.52,21.86 307.25,24.13 303.15,24.13 302.43,23.41 292.41,23.41 287.87,27.96 280.21,27.96 277.89,30.27 277.89,32.17 277.91,32.18 277.91,33.4 276.47,34.84 276.47,38.94 275.63,39.78 272.71,39.78 268.61,43.88 268.61,45.65 263.78,50.48 261.16,50.48 255.31,56.33 250.97,56.33 247.18,60.11 247.18,67.61 243.86,70.94 240.67,70.94 237.4,74.21 236.42,74.21 233.58,77.05 219.89,77.05 219.8,77.14 215.4,77.14 211.46,73.2 209.8,73.2 209,74 209,77.52 203.29,83.23 193.18,83.23 193.16,83.21 185.32,83.21 183.09,80.98 176.68,80.98 175.92,80.22 155.74,80.22 150.73,75.2 142.03,75.2 136.89,80.34 120.52,80.34 118.59,78.41 111.65,78.41 110.22,76.98 106.21,76.98 104.75,75.52 101.15,75.52 100.09,74.46 100.09,74.02 97.46,71.39 97.46,60.02 70.57,33.13 66.23,33.13 65.51,32.41 53.76,32.41 50.75,35.41 50.75,41.79 48.76,43.78 44.55,43.78 43.52,42.75 v2(43.52,41.73)
  BOTTOM w0.102: v2(336.31,45.9) 335.84,45.9 334.18,47.56 333.71,47.56 333.18,48.08 333.18,48.35 v1(332.69,48.84) 331.89,49.64 v2(331.89,49.74)
  BOTTOM w0.254: PR20.2 v2(43.52,41.73)
SPI_CLKTPM: length 3.8
  BOTTOM w0.102: v1(188.83,133.54) 189.39,132.98 RZ35.2 RZ26.2 191,132.65 U637.19
SPI_DINTPM: length 4.3
  BOTTOM w0.102: U637.24 193.5,132.52 194.03,133.05 194.03,133.06 v1(195.01,134.04) 195.03,134.06 RZ30.2
SPI_DOTPM: length 3.4
  BOTTOM w0.102: U637.21 192,132.4 RZ29.2 193.04,132.98 193.46,133.39 v1(193.46,133.83)
SPKR: length 295.9
  TOP w0.089: 121.61,125.64 121.61,125.78 121.19,126.2
  TOP w0.102: v2(119.68,131.86) 119.56,131.74 119.56,130.24 119.56,130.23 119.56,129.9 119.56,129.89 119.56,129.46 120.04,128.98 120.04,127.58 120.41,127.21 RH86.2 120.77,126.62 121.19,126.2 ; 121.61,125.64 122.2,125.05 122.2,124.74 122.41,124.53 122.41,124.23 122.32,124.13 122.32,123.79 122.34,123.78 UH1.BD26 ; JIO1.55 v2(318.03,34.8)
  IN1 w0.109: v2(247.04,97.48) 247.81,97.48 251,94.29 251,91.89 252.8,90.09 252.8,87.12 255.63,84.3 255.63,77.2 257.13,75.7 257.13,73.34 262.93,67.54 262.93,66.08 278.11,50.9 283.37,50.9 284.43,49.85 286.16,49.85 286.39,49.61 286.68,49.33 289.42,49.33 291.93,46.82 304.04,46.82 304.28,47.06 308.79,47.06 310.15,45.7 313.57,45.7 316.78,42.49 319.03,42.49 321.08,40.44 321.08,36.52 319.94,35.38 318.6,35.38 v2(318.03,34.8)
  IN2 w0.127: v2(247.04,97.48) 245.82,97.48 241.06,102.24 241.06,104.15 238.82,106.38 238.29,106.38 234.09,110.59 234.09,116.68 232.48,118.29 232.48,119.97 231.32,121.14 231.32,122.84 231.61,123.13 231.61,131.12 225.01,137.73 210.65,137.73 209.02,136.1 201.93,136.1 201.77,135.94 197.19,135.94 197.02,136.11 189.53,136.11 189.26,136.39 187.82,136.39 186.4,137.81 183.17,137.81 182.38,137.01 174.7,137.01 173.81,137.91 171.02,137.91 170.55,138.39 168.68,138.39 168.05,137.76 164.13,137.76 161.69,140.21 157.2,140.21 156.27,141.14 151.87,141.14 151.49,140.76 151.49,140.06 151.02,139.59 149.5,139.59 148.83,138.92 143.22,138.92 141.97,140.17 141.97,140.98 140.94,142.01 137.05,142.01 134.09,139.05 134.09,138.01 133.01,136.93 133.01,136.65 130.94,134.58 122.39,134.58 v2(119.68,131.86)
SRTCRST#: length 11.8
  TOP w0.089: UH1.BB10 130.08,122.76 130.08,123.02 130.03,123.07 130.03,124.57 130.56,125.1 130.56,125.61 130.2,125.96 130.2,126.2
  TOP w0.102: v2(130.72,127.8) 130.2,127.28 130.2,126.2
  BOTTOM w0.102: CH41.2 132.48,131.52 RH201.2 132.17,131.22 132.17,130.49 131.78,130.09 131.78,128.55 v1(131.85,128.48) 131.85,128.27 131.38,127.8 v2(130.72,127.8)
SS1_ON: length 206.4
  TOP w0.102: JIO2.54 53.79,35.35 v2(54.27,35.83) ; v2(179.44,95.99) 181.25,95.99 181.69,96.44 184.05,96.44 v1(184.63,95.86) 185.3,95.19 185.3,94.48 185.48,94.3 185.81,94.3 185.98,94.13 185.98,93.47 v2(186.38,93.07)
  IN2 w0.127: v2(54.27,35.83) 56.52,35.83 57.09,36.41 59.89,36.41 60.24,36.06 66.84,36.06 68.65,37.87 70.08,37.87 72.47,40.26 72.47,41.19 74.66,43.38 78.23,43.38 95.52,60.66 95.52,71.96 97.65,74.1 97.65,75.02 98.32,75.68 98.56,75.68 100.28,77.4 102.58,77.4 106.74,81.55 108.21,81.55 108.35,81.69 119.68,81.69 119.85,81.87 125.18,81.87 127.37,84.07 130.36,84.07 132.39,82.04 134.14,82.04 134.47,82.37 137.04,82.37 142.56,76.85 147.03,76.85 148.82,78.64 148.82,78.7 150.92,80.79 152.88,80.79 154.76,82.67 155.85,82.67 157.2,84.03 158.98,84.03 160.13,82.89 165.52,82.89 166.03,82.38 168.89,82.38 170.03,83.52 173.72,83.52 174.16,83.08 177.27,83.08 177.52,82.82 181.92,82.82 183.61,84.51 183.61,90.48 185.61,92.48 185.96,92.48 186.38,92.9 v2(186.38,93.07)
  IN3 w0.127: v2(179.44,95.99) 179.17,95.99 178.4,96.77 178.4,100.8 177.5,101.7 177.5,103.52 177.36,103.66 177.36,107.23 177.38,107.24 177.38,108.24 177.69,108.56 177.69,108.95 176.6,110.04 176.6,110.19 175.81,110.98 175.81,111.48 v2(175.98,111.65)
  BOTTOM w0.102: v2(175.98,111.65) 175.98,111.74 175.46,112.26 U46.B63
STSTART_DCBLOCK_GC: length 342.8
  TOP w0.254: v2(339.89,54.82) 337.93,54.82 337.8,54.69 PU1001.16
  IN1 w0.109: v2(127.08,144.76) 127.08,144.13 127.61,143.59 128.78,143.59 129.19,143.18 135.11,143.18 135.87,143.94 136.76,143.94 137.55,144.74 149.58,144.74 150.6,145.75 150.6,145.74 v2(150.61,145.74)
  IN2 w0.127: v2(320.65,44.48) 320.65,44.5 ; 320.65,44.5 322.91,46.76 323.52,46.76 324.73,47.96 326.95,47.96 327.91,48.93 328.25,48.93 332.37,53.04 335.85,53.04 336.45,53.65 338.25,53.65 338.86,53.04 339.17,53.04 339.89,53.76 v2(339.89,54.82) ; 320.65,44.5 320.18,44.03 318.22,44.03 317.31,44.94 315.85,44.94 313.91,46.88 312.02,46.88 311.72,47.18 295.97,47.18 294.67,48.47 285.78,48.47 283.74,50.51 278.77,50.51 262.89,66.39 262.89,67.3 260.9,69.3 260.9,71.63 257.72,74.81 257.72,77.27 254.59,80.41 254.59,85.02 253.45,86.16 253.45,88.95 250.74,91.65 250.74,91.88 250.14,92.48 249.99,92.48 249.28,93.19 249.28,95.95 248.07,97.15 248.07,98.36 242.36,104.08 242.36,105.15 241.45,106.05 241.11,106.05 241.02,105.96 239.96,105.96 234.89,111.04 234.89,116.96 233.25,118.61 233.25,123.24 232.42,124.07 232.42,131.39 225.11,138.7 207.65,138.7 206.78,139.57 200.46,139.57 199.58,140.46 196.44,140.46 196.28,140.29 190.13,140.29 188.1,142.32 168.13,142.32 164.94,145.51 160.14,145.51 159.73,145.11 158.11,145.11 157.48,145.73 153.5,145.73 152.85,145.08 151.27,145.08 v2(150.61,145.74)
  IN3 w0.127: v2(320.65,44.48) 320.65,43.39 319.99,42.72 317.72,40.46 314.94,40.46 314.06,39.58 292.48,39.58 291.41,38.51 288.08,38.51 v2(288.05,38.48)
  BOTTOM w0.102: v2(127.08,144.76) 127.08,144.73 126.62,144.28 PR1002.1 ; PQ1005.4 272.89,40.99 273.22,40.66 279.82,40.66 282,38.48 v2(288.05,38.48)
SUSACK#: length 121.7
  TOP w0.089: 126.34,126.2 126.34,125.55 125.81,125.02 125.81,123.85 125.65,123.69 125.65,123.43 v2(125.17,122.95) 125.59,122.52 UH1.BB19
  TOP w0.102: 126.34,126.2 126.34,126.95 RH84.1
  IN1 w0.089: v2(125.17,122.95) 125.64,123.41 127.74,123.41 129.35,125.03 129.35,125.46 129.55,125.66 130.46,125.66 130.52,125.6 132.48,125.6 133.08,126.2
  IN1 w0.109: 133.08,126.2 133.95,127.07 133.95,129.57 136.13,131.75 139.73,131.75 140.6,132.61 141.27,132.61 142.44,133.78 143.57,133.78 144.17,134.38 151.02,134.38 151.03,134.36 151.16,134.36 152.29,133.23 152.29,133.22 152.67,132.84 152.86,132.84 152.96,132.74 152.96,132.74 152.97,132.75 v2(152.97,132.76)
  IN3 w0.127: v2(197.84,132.42) 197.84,132.25 198.23,131.87 198.23,131.75 198.95,131.03 199.47,131.03 205.29,125.2 205.29,119.8 204.7,119.21 204.7,118.21 204.99,117.93 204.99,117.91 205.08,117.82 205.08,117.52 203.12,115.57 202.62,115.57 202.26,115.21 202.26,113.2 202.49,112.97 203.48,112.97 v2(203.7,112.75) 203.7,112.73 204.26,112.17 206.05,112.17 206.18,112.3 206.86,112.3 v2(207.35,111.82)
  IN4 w0.109: v2(197.84,132.42) 194.86,132.42 194.18,133.1 187,133.1 186.29,132.39 184.62,132.39 183.86,131.63 174.4,131.63 173.84,132.18 165.97,132.18 163.16,135 156.26,135 155.57,134.31 155.57,134.04 155.16,133.63 154.88,133.63 154.22,132.96 153.19,132.96 152.98,132.75 152.97,132.75 v2(152.97,132.76)
  BOTTOM w0.102: v2(203.7,112.75) 203.71,112.74 203.71,112.64 204.2,112.15 204.88,112.15 204.9,112.13 205.08,112.13 U51.B7 ; R837.2 207.83,112.3 v2(207.35,111.82)
SUSCLK: length 460.5
  TOP w0.089: v2(128.63,117.86) 128.28,118.2 UH1.AN15
  TOP w0.102: R360.2 25.43,13.13 v2(25.1,13.46) ; v2(103.03,110.13) 101.66,110.13 99.47,107.94 98.3,107.94 96.59,106.23 96.03,106.23 95.34,105.54 94.88,105.54 94.3,104.96 94.3,104.5 90.35,100.55 90.35,89.17 67.43,66.25 67.43,66.21 67.37,66.15 67.37,54.55 61.98,49.17 61.98,45.82 61.48,45.31 61.48,43.93 62.08,43.33 62.08,38.86 62.09,38.85 62.09,37.97 62.44,37.62 v2(62.44,36.48)
  IN1 w0.109: v2(319.7,40.34) 318.4,41.65 316.3,41.65 314.37,43.58 312.27,43.58 311.13,44.72 309.2,44.72 308.77,45.15 304.2,45.15 303.14,46.21 291.67,46.21 289.17,48.71 286.42,48.71 285.9,49.23 284.17,49.23 283.12,50.28 277.85,50.28 262.31,65.82 262.31,66.62 262.31,67.28 256.51,73.08 256.51,75.45 255.01,76.95 255.01,83.69 253.15,85.55 252.34,85.55 252.11,85.78 252.11,86.17 252.12,86.18 252.12,89.9 250.39,91.64 250.39,93.4 250.38,93.4 250.38,93.41 v2(250.37,93.41)
  IN4 w0.089: 141.76,117.23 141.55,117.23 140.63,118.15 132.08,118.15 132.03,118.1 128.88,118.1 v2(128.63,117.86) 128.23,118.26 122.31,118.26 121.04,119.53 121.04,120.95 120.71,121.28 120.25,121.28 ; 119.28,121.28 118.62,120.62 118.62,119.22 118.18,118.78 118.18,118.35 118.65,117.88 118.65,116.66 118.01,116.02 114.91,116.02 113.01,114.12 112.37,114.12
  IN4 w0.109: 141.76,117.23 149.07,117.23 149.85,116.46 150.96,116.46 151.48,115.94 152.94,115.94 153.12,115.76 157.38,115.76 157.72,116.1 158.2,116.1 158.59,115.7 162.99,115.7 163.13,115.56 165.13,115.56 165.52,115.17 166.09,115.17 166.23,115.03 170.14,115.03 171.22,113.95 172.4,113.95 175.18,111.17 175.65,111.17 176.47,110.35 180.24,110.35 180.35,110.24 181.42,109.18 182.18,109.18 182.46,108.89 184.42,108.89 185.35,107.96 186.28,107.96 186.48,108.16 190.41,108.16 190.98,107.59 192.57,107.59 193.45,106.71 194.28,106.71 194.88,107.31 195.15,107.31 196,108.16 196.97,108.16 197.36,108.54 197.76,108.54 197.78,108.57 198.13,108.57 198.95,107.75 198.95,107.4 199.3,107.05 199.64,107.05 199.91,107.32 199.91,107.68 200.18,107.94 200.18,108.72 200.12,108.78 200.12,109.63 200.72,110.23 206,110.23 206.28,109.95 208.1,109.95 208.46,110.3 208.46,111.05 208.66,111.24 209.22,111.24 209.54,110.92 211.61,110.92 213.43,109.09 213.43,107.6 214.27,106.76 216.01,106.76 216.4,106.37 216.4,106.18 216.93,105.66 218.93,105.66 219.26,105.98 v2(219.55,105.98) 220.7,105.98 220.83,106.1 223.87,106.1 226.77,103.21 231.31,103.21 231.63,103.53 233.02,103.53 233.21,103.33 238.12,103.33 239.02,102.43 240.63,102.43 241.46,101.6 241.73,101.6 241.89,101.44 241.89,99.84 241.48,99.44 241.48,97.25 241.96,96.77 241.96,96.5 243.71,94.75 248.74,94.75 249.56,93.94 249.85,93.94 250.37,93.41 v2(250.37,93.41) ; 112.37,114.12 112.02,114.12 111.71,113.81 111.71,113.23 111.33,112.85 109.5,112.85 106.79,110.13 v2(103.03,110.13) ; v2(62.44,36.48) 63.02,35.9 63.02,32.15 62.54,31.67 62.54,29.4 60.72,27.58 56,27.58 50.52,33.05 48.09,33.05 47.67,32.63 44.3,32.63 43.11,31.44 43.11,29.46 42.5,28.85 41.79,28.85 39.87,26.93 39.87,25.76 38.28,24.18 35.77,24.18 34.78,23.18 33.62,23.18 32.4,21.97 25.86,21.97 23.33,19.43 23.33,15.43 25.1,13.66 v2(25.1,13.46) ; 119.28,121.28 120.25,121.28
  BOTTOM w0.089: v2(128.63,117.86) 128.9,117.86 129.25,118.21 RH83.2
  BOTTOM w0.102: JNGFF2.60 319.87,40.18 v2(319.7,40.34) ; JNGFF1.42 219.22,116.45 218.99,116.68 218.55,117.11 218.49,117.11 218.49,117.12 217.98,117.12 217.98,117.12 217.93,117.12 217.92,117.11 217.77,117.11 217.25,116.59 217.25,116.36 217.02,116.13 217.02,116.1 216.86,115.93 216.86,113.15 218.23,111.78 218.23,111.34 216.9,110 216.9,108.99 217.69,108.19 218.32,108.19 218.8,108.67 219.24,108.67 219.64,108.27 219.64,106.07 219.55,105.98 v2(219.55,105.98)
SUSCLK_R: length 7.8
  TOP w0.102: R360.1 25.43,11.45 v2(24.55,10.57)
  BOTTOM w0.102: v2(24.55,10.57) 21.58,10.57 21.25,10.24 19.73,10.24 19.5,10.47 JNGFF3.60
SW1:
  vias: v2(344,39.83) v2(344,39.2) v2(346.54,42.57) v2(346.54,41.93) v2(346.54,41.3) v2(347.18,42.57) v2(347.18,41.93) v2(347.18,41.3) v2(347.81,42.57) v2(347.81,41.93) v2(347.81,41.3) v2(348.45,42.57) v2(348.45,41.93) v2(348.78,34.3) v2(349.08,42.57) v2(349.08,41.93) v2(349.37,34.3) v2(349.72,42.57) v2(349.72,41.93)
SW1_3PH_A: length 43.2
  TOP w0.254: v2(250.3,51.16) 250.54,51.41 v1(250.54,52.26) PR1143.1
  IN4 w0.254: v2(250.3,51.16) 249.97,50.83 244.77,50.83 242.25,53.35 242.25,55.53 241.51,56.28 241.51,64.61 239.95,66.16 239.95,66.81 238.66,68.1 233.05,68.1 231.82,66.87 v2(231.82,66.89)
  BOTTOM w0.254: v2(250.3,51.16) 250.79,51.66 251.99,51.66 PR1154.1 ; PL1200.2 231.8,62.89 231.29,63.39 231.29,66.36 v2(231.82,66.89)
SW1_3PH_B: length 63.3
  TOP w0.254: PR1145.2 251.28,36.09 248.73,38.64 248.73,40.38 v2(249.9,41.55) ; PL1400.2 225.7,12.97 225.08,13.6 225.08,19.34 225.45,19.71 v2(225.45,19.96)
  IN3 w0.254: v2(225.45,19.96) 225.34,20.07 225.34,20.47 225.47,20.59 229.59,20.59 230.99,19.2 232.61,19.2 233.96,20.54 235.54,20.54 243.51,28.52 243.51,33.5 247.18,37.17 251.09,37.17 252.6,38.68 252.6,40.96 251.52,42.04 250.3,42.04 249.9,41.64 v2(249.9,41.55)
  BOTTOM w0.254: v2(249.9,41.55) 249.9,41.74 250.22,42.06 250.85,42.06 251.22,41.69 PR1160.2
SW1_EDP_AUXN: length 54.8
  TOP w0.089: v2(111.22,155.51) 111.47,155.76 111.69,155.76 C373.1
  IN3 w0.114: v2(147.24,141.77) 147.08,141.92 147.08,142.09 147.18,142.2 147.41,142.2 147.51,142.09 147.64,142.09 147.74,142.2 147.74,142.44 146.24,143.94 136.62,143.94 135.41,143.25 121.79,143.25 118.03,147.01 118.03,149.05 118.01,149.07 118.01,149.19 116.88,150.32 116.88,151.53 115.97,152.45 115.97,153.13 113.17,155.93 111,155.93 110.91,155.84 110.91,155.61 111.02,155.51 v2(111.22,155.51)
  BOTTOM w0.089: R339.2 111.64,155.89 111.48,155.89 111.22,155.62 v2(111.22,155.51) ; v2(147.24,141.77) 145.25,141.77 144.31,140.84 144.31,139.2 144.41,139.1 U630.31
SW1_EDP_AUXN_C: length 14
  TOP w0.089: C373.2 113.3,155.06 113.38,155.06 113.43,155.11 113.43,155.62 113.49,155.68 113.62,155.68 113.96,155.34 v1(113.96,154.01) 113.96,152.04 114.76,151.24 114.76,146.01 114.13,145.37 114.13,145.09 113.73,144.7 JEDP1.29
SW1_EDP_AUXP: length 54.8
  TOP w0.089: v2(111.19,156.34) 111.42,156.1 111.73,156.1 C371.1
  IN3 w0.114: v2(111.19,156.34) 111.23,156.29 113.33,156.29 116.34,153.28 116.34,152.6 117.25,151.68 117.25,150.47 118.38,149.34 118.38,149.22 118.39,149.21 118.39,147.16 121.94,143.62 135.31,143.62 136.53,144.3 146.4,144.3 148.11,142.59 148.11,142.04 147.32,141.26 147.31,141.26 v2(147.24,141.19)
  BOTTOM w0.089: v2(111.19,156.34) 111.4,156.13 111.51,156.13 111.88,156.49 R336.2 ; v2(147.24,141.19) 147.24,141.03 147.16,140.95 146.86,140.95 146.79,141.02 146.79,141.35 146.71,141.43 145.39,141.43 144.66,140.7 144.66,139.35 144.81,139.2 U630.32
SW1_EDP_AUXP_C: length 14
  TOP w0.089: JEDP1.28 114.24,144.72 114.47,144.95 114.47,145.23 115.1,145.86 115.1,151.38 114.3,152.18 114.3,155.48 v1(114.05,155.74) 113.76,156.03 113.22,156.03 C371.2
SW1_EDP_HPD: length 48.1
  TOP w0.102: JEDP1.25 115.77,144.54 115.77,145.35 117.12,146.71 119.68,146.71 v2(120.5,147.53) ; v2(150.54,141.05) v1(151.49,141.05)
  IN1 w0.109: v2(120.37,145.82) 120.57,146.01 122.03,146.01 126.71,141.32 135.26,141.32 136.46,142.52 144.81,142.52 145.14,142.2 149.39,142.2 v2(150.54,141.05)
  IN2 w0.127: v2(120.37,145.82) 120.37,146.98 120.5,147.11 v2(120.5,147.53)
  BOTTOM w0.102: R222.2 119.89,146.3 v2(120.37,145.82) ; U630.44 149.61,139.3 149.71,139.4 149.71,140.55 149.97,140.8 150.28,140.8 v2(150.54,141.05) ; R103.2 120.46,147.57 v2(120.5,147.53)
SW1_EDP_N0: length 62
  TOP w0.089: C380.1 109.76,149.46 109.76,149.96 109.24,150.48 108.61,150.48 108.39,150.26 v2(108.31,150.26)
  IN3 w0.114: v2(108.31,150.26) 108.53,150.48 108.69,150.48 108.82,150.35 108.82,150.17 108.67,150.02 108.67,149.93 108.73,149.87 109.54,149.87 110.39,149.02 110.39,145.94 113.67,142.67 115.22,142.67 120.64,137.24 121.21,137.24 122.55,135.91 125.77,135.91 128.49,138.63 133.09,138.63 134.36,137.35 134.36,136.65 136.14,134.88 139.94,134.88 140.97,135.91 145.71,135.91 146.76,136.96 149.94,136.96 150.35,137.37 150.35,139.92 150.29,139.99 150.19,139.99 150.14,140.04 v2(150.14,140.38)
  BOTTOM w0.089: U630.45 150.01,139.16 150.07,139.21 150.07,139.54 150.14,139.61 v2(150.14,140.38)
SW1_EDP_N0_C: length 3.9
  TOP w0.089: C380.2 109.8,148.18 109.8,146.82 109.22,146.25 109.22,145.62 109.3,145.54 JEDP1.38
SW1_EDP_N1: length 61.3
  TOP w0.089: v2(109.9,152.38) 110.02,152.51 110.88,152.51 111.17,152.22 C378.1
  IN3 w0.114: v2(149.14,141.18) 149.28,141.04 149.28,140.92 149.15,140.79 149.15,138.39 148.84,138.09 141.75,138.09 139.53,135.87 136.8,135.87 135.35,137.31 135.35,137.77 133.48,139.64 128.11,139.64 125.37,136.91 123,136.91 121.63,138.29 121.63,138.86 118.36,142.13 117.15,142.13 115.63,143.66 114.09,143.66 113.2,144.55 113.2,148.04 110.91,150.32 110.91,151.46 110.41,151.96 110.41,152.47 110.32,152.56 110.08,152.56 v2(109.9,152.38)
  BOTTOM w0.089: U630.42 148.81,139.16 148.86,139.21 148.86,139.43 148.99,139.56 148.99,140.71 149.25,140.97 149.25,141.07 v2(149.14,141.18)
SW1_EDP_N1_C: length 6
  TOP w0.089: JEDP1.36 110.28,145.34 110.19,145.51 110.19,145.75 111.02,146.58 v1(111.02,149.04) 111.02,150.1 C378.2
SW1_EDP_N2: length 57.5
  TOP w0.089: C376.1 107.47,154.13 106.2,154.13 v2(106.04,154.29)
  IN3 w0.114: v2(106.04,154.29) 106.13,154.2 107.81,154.2 108.2,153.82 112.2,153.82 114.34,151.67 114.34,146.53 117.73,143.14 118.79,143.14 120.83,141.1 129.75,141.1 130.28,141.64 135.83,141.64 137.05,142.32 140.21,142.32 143.39,139.15 147.24,139.15 147.69,139.61 147.69,140 148.12,140.43 148.36,140.43 v2(148.5,140.57)
  BOTTOM w0.089: v2(148.5,140.57) 148.38,140.45 148.36,140.45 147.97,140.06 147.96,140.06 147.61,139.72 U630.39
SW1_EDP_N2_C: length 14.6
  TOP w0.089: C376.2 108.85,154.05 111.61,154.05 112.12,153.54 v1(112.12,152.42) 112.12,151.28 113.16,150.24 113.16,146.63 112.64,146.11 111.87,146.11 111.29,145.54 111.29,145.37 JEDP1.34
SW1_EDP_N3: length 59.2
  TOP w0.089: C374.1 107.54,156.23 107.31,156.23 107.04,155.96 107.04,155.72 106.98,155.66 106.79,155.66 106.62,155.82 v2(106.62,155.9)
  IN3 w0.114: v2(106.62,155.9) 106.96,155.56 106.96,155.39 106.84,155.26 106.66,155.26 106.2,155.72 106.2,156.17 106.57,156.53 107.23,156.53 107.94,155.82 107.94,154.95 108.43,154.46 113.23,154.46 114.98,152.72 114.98,151.6 115.31,151.27 115.73,151.27 115.86,151.14 115.86,150.71 115.73,150.58 115.31,150.58 114.98,150.25 114.98,149.37 115.36,148.99 116.81,148.99 117.02,148.77 117.02,148.06 116.62,147.66 116.62,146.57 121.45,141.73 129.37,141.73 129.9,142.26 135.67,142.26 136.88,142.95 140.47,142.95 142.16,141.26 145.76,141.26 146.45,140.57 146.45,140.27 v2(146.28,140.1)
  BOTTOM w0.089: v2(146.28,140.1) 146.41,139.97 U630.36
SW1_EDP_N3_C: length 16.6
  TOP w0.089: C374.2 108.86,155.82 109.36,155.82 v1(109.78,155.4) 110.19,154.99 112,154.99 113.33,153.66 113.33,151.79 114.15,150.96 114.15,146.28 113.02,145.16 112.45,145.16 112.31,145.02 112.23,144.94 112.12,144.31
SW1_EDP_P0: length 62
  TOP w0.089: C379.1 109.41,149.6 109.41,149.81 109.09,150.13 108.75,150.13 108.54,149.92 108.54,149.76 108.45,149.68 v2(108.06,149.68)
  IN3 w0.114: v2(150.72,140.38) 150.72,137.22 150.09,136.59 146.91,136.59 145.86,135.54 141.12,135.54 140.1,134.51 135.98,134.51 134,136.5 134,137.2 132.93,138.26 128.64,138.26 125.93,135.54 122.39,135.54 121.06,136.88 120.49,136.88 115.07,142.3 113.51,142.3 110.02,145.79 110.02,148.86 109.39,149.5 108.55,149.5 108.37,149.68 v2(108.06,149.68)
  BOTTOM w0.089: v2(150.72,140.38) 150.48,140.14 150.48,139.47 150.41,139.4 150.41,138.85 U630.46
SW1_EDP_P0_C: length 3.9
  TOP w0.089: JEDP1.39 108.84,145.68 108.88,145.72 108.88,146.39 109.46,146.97 109.46,147.96 C379.2
SW1_EDP_P1: length 61.3
  TOP w0.089: v2(109.9,151.8) 110.26,152.16 110.73,152.16 110.82,152.07 110.82,151.71 110.76,151.65 110.38,151.65 110.28,151.54 C377.1
  IN3 w0.114: v2(109.9,151.8) 110.05,151.8 110.55,151.3 110.55,150.17 112.83,147.89 112.83,144.39 113.94,143.29 115.48,143.29 117,141.76 118.2,141.76 121.26,138.7 121.26,138.13 122.85,136.55 125.53,136.55 128.26,139.28 133.33,139.28 134.99,137.62 134.99,137.16 136.64,135.5 139.69,135.5 141.9,137.72 148.99,137.72 149.52,138.24 149.52,140.63 149.65,140.77 149.65,141.1 v2(149.72,141.18)
  BOTTOM w0.089: v2(149.72,141.18) 149.59,141.05 149.59,140.83 149.33,140.57 149.33,139.42 149.2,139.29 149.2,139.16 149.21,139.15 U630.43
SW1_EDP_P1_C: length 6
  TOP w0.089: JEDP1.37 109.79,145.39 109.79,145.39 109.85,145.57 109.85,145.9 110.67,146.72 v1(110.67,147.45) 110.67,149.85 C377.2
SW1_EDP_P2: length 57.5
  TOP w0.089: v2(106.04,153.71) 106.11,153.79 107.31,153.79 C375.1
  IN3 w0.114: v2(148.5,139.99) 148.43,140.06 148.28,140.06 148.06,139.85 148.06,139.45 147.39,138.78 143.23,138.78 140.06,141.96 137.15,141.96 135.93,141.27 130.43,141.27 129.9,140.74 120.67,140.74 118.64,142.77 117.58,142.77 113.97,146.37 113.97,151.52 112.04,153.45 108.04,153.45 107.66,153.83 106.16,153.83 v2(106.04,153.71)
  BOTTOM w0.089: v2(148.5,139.99) 148.68,139.8 148.68,139.66 148.54,139.52 148.4,139.52 148.2,139.72 148.1,139.72 147.95,139.57 147.95,139.23 148.01,139.17 U630.40
SW1_EDP_P2_C: length 14.6
  TOP w0.089: C375.2 108.97,153.04 109.21,153.04 109.3,153.13 109.3,153.63 109.38,153.71 v1(110.6,153.71) 111.47,153.71 111.78,153.4 111.78,151.13 112.82,150.09 112.82,146.77 112.5,146.45 111.74,146.45 110.79,145.5 JEDP1.35
SW1_EDP_P3: length 59.3
  TOP w0.089: C372.1 107.56,155.32 v2(106.02,155.32)
  IN3 w0.114: v2(146.87,140.11) 146.87,140.11 146.82,140.16 146.82,140.73 145.92,141.63 142.31,141.63 140.62,143.31 136.79,143.31 135.57,142.63 129.75,142.63 129.21,142.09 121.61,142.09 116.98,146.72 116.98,147.51 117.39,147.91 117.39,148.93 116.96,149.36 115.51,149.36 115.35,149.52 115.35,150.1 115.46,150.21 115.89,150.21 116.23,150.55 116.23,151.29 115.89,151.63 115.46,151.63 115.35,151.75 115.35,152.87 113.39,154.83 108.58,154.83 108.31,155.1 108.31,155.98 107.38,156.9 106.42,156.9 105.83,156.32 105.83,155.51 v2(106.02,155.32)
  BOTTOM w0.089: v2(146.87,140.11) 146.81,140.05 U630.37
SW1_EDP_P3_C: length 16.5
  TOP w0.089: C372.2 108.89,154.9 108.98,154.9 109.05,154.96 109.05,155.42 109.11,155.48 109.21,155.48 110.05,154.65 111.86,154.65 v1(112.24,154.26) 112.98,153.52 112.98,151.64 113.81,150.82 113.81,146.43 112.88,145.5 112.31,145.5 112.07,145.26 111.7,144.9 JEDP1.33
SW1_LAN0_MDIN0: length 13.3
  TOP w0.089: T156.2 240.03,128.45 239.32,129.17 237.83,129.17 236.4,127.74 v4(236.4,127.19) 236.4,122.23 236.33,122.16 U32.25
SW1_LAN0_MDIN1: length 18
  TOP w0.089: T156.6 245.11,125.49 245.05,125.42 244.83,125.42 244.71,125.31 244.71,124.72 244.82,124.61 244.99,124.61 245.14,124.76 v2(245.14,124.9) ; v2(234.28,121.95) 234.4,121.83 234.4,121.35 234.33,121.27 U32.29
  IN1 w0.102: v2(245.14,124.9) 245.05,124.9 244.88,125.06 243.72,125.06 243.06,124.4 242.66,124.4 241.98,123.72 240.26,123.72 237.79,121.24 236.71,121.24 235.14,122.8 234.67,122.8 234.28,122.41 v2(234.28,121.95)
SW1_LAN0_MDIN2: length 24.3
  TOP w0.089: v2(247.65,124.17) T156.8 ; U32.34 231.83,121.27 231.88,121.33 231.88,121.99 v2(231.73,122.14)
  IN1 w0.102: v2(231.73,122.14) 231.73,121.14 233.13,119.74 233.7,119.74 234.52,118.92 238.14,118.92 238.62,119.4 240.14,119.4 243.96,123.22 245.24,123.22 245.35,123.34 247.37,123.34 247.65,123.62 v2(247.65,124.17)
SW1_LAN0_MDIN3: length 44.6
  TOP w0.089: U32.38 229.83,121.45 v2(229.64,121.63) ; T156.12 v2(252.73,124.21)
  IN1 w0.102: v2(229.64,121.63) 229.64,120.95 230.12,120.47 230.43,120.47 234.08,116.82 237.89,116.82 240.17,114.54 249.41,114.54 249.52,114.43 251.78,114.43 252.33,113.88 254.68,113.88 256.33,115.53 256.33,120.09 252.73,123.69 v2(252.73,124.21)
SW1_LAN0_MDIP0: length 13.3
  TOP w0.089: U32.24 236.83,121.44 236.67,121.6 236.67,122.01 236.75,122.09 v4(236.75,124.86) 236.75,127.6 237.98,128.83 239.17,128.83 239.69,128.31 239.69,127.82 239.56,127.69 239.26,127.69 239.21,127.74 239.21,127.81 239.15,127.87 238.89,127.87 238.76,127.75 T156.1
SW1_LAN0_MDIP1: length 18
  TOP w0.089: U32.28 234.83,121.23 234.75,121.31 234.75,121.83 v2(234.87,121.95) ; T156.5 243.84,125.49 243.93,125.4 244.32,125.4 244.37,125.36 244.37,124.58 244.58,124.36 v2(244.58,124.26)
  IN1 w0.102: v2(244.58,124.26) 244.66,124.19 244.85,124.19 244.97,124.31 244.97,124.47 244.73,124.71 243.86,124.71 243.2,124.05 242.81,124.05 242.12,123.36 240.41,123.36 237.93,120.89 236.56,120.89 235,122.45 234.82,122.45 234.64,122.26 234.64,122.18 v2(234.87,121.95)
SW1_LAN0_MDIP2: length 24.3
  TOP w0.089: T156.7 246.38,125.58 246.51,125.45 247.23,125.45 247.31,125.37 247.31,124.49 v2(247,124.18) ; v2(232.32,122.14) 232.32,122.14 232.22,122.04 232.22,121.41 232.33,121.31 U32.33
  IN1 w0.102: v2(232.32,122.14) 232.09,121.91 232.09,121.29 233.28,120.1 233.84,120.1 234.67,119.27 237.99,119.27 238.48,119.76 239.99,119.76 243.81,123.58 245.09,123.58 245.2,123.69 247.23,123.69 247.3,123.76 247.3,123.87 v2(247,124.18)
SW1_LAN0_MDIP3: length 44.5
  TOP w0.089: U32.37 230.33,121.24 230.38,121.3 230.38,121.47 v2(230.23,121.63) ; T156.11 251.46,125.49 251.55,125.4 252.29,125.4 252.39,125.31 252.39,124.45 v2(252.15,124.21)
  IN1 w0.102: v2(252.15,124.21) 252.18,124.21 252.38,124.01 252.38,123.54 255.97,119.95 255.97,115.67 254.53,114.23 252.48,114.23 251.92,114.78 249.66,114.78 249.56,114.89 240.32,114.89 238.04,117.18 234.23,117.18 230.58,120.83 230.26,120.83 230,121.09 230,121.4 v2(230.23,121.63)
SW1_LAN1_MDIN0: length 75.2
  TOP w0.089: U32.23 237.33,120.74 237.33,120.73 237.33,121.94 237.71,122.32 237.71,122.63 237.95,122.87 238.05,122.87 v2(238.13,122.95)
  IN1 w0.102: v2(185.79,157.64) 185.63,157.47 185.46,157.31 185.46,155.66 188.57,152.55 188.57,149.38 190.3,147.66 195.59,147.66 198.18,145.07 206.6,145.07 206.71,145.18 211.46,145.18 232.25,124.39 234.43,124.39 234.78,124.04 235.37,124.04 236.69,122.72 237.53,122.72 237.68,122.88 237.68,123.04 237.81,123.17 238,123.17 238.13,123.04 v2(238.13,122.95)
  BOTTOM w0.089: v2(185.79,157.64) 185.64,157.49 185.64,157.12 185.75,157.01 JDOCK1.106
SW1_LAN1_MDIN1: length 73.3
  TOP w0.089: v2(235.68,126.52) 235.58,126.42 235.23,126.42 234.74,125.93 v4(234.74,125.45) 234.74,125.26 235.39,124.62 235.39,121.38 235.33,121.32 U32.27
  IN1 w0.102: v2(235.68,126.52) 235.68,126.12 235.59,126.03 231.97,126.03 226.13,131.87 226.13,132.45 224.77,133.81 224.19,133.81 212.53,145.47 211.86,146.15 206.31,146.15 206.2,146.03 198.58,146.03 195.94,148.67 192.28,148.67 190.22,150.73 190.22,152.36 187.07,155.52 187.07,157.31 v2(187.4,157.64)
  BOTTOM w0.089: v2(187.4,157.64) 187.2,157.44 187.2,157.06 187.25,157 JDOCK1.112
SW1_LAN1_MDIN2: length 68.7
  TOP w0.089: U32.32 232.83,123.2 231.96,124.07 v4(231.96,125.49) 231.96,127.33 232.75,128.12 233.04,128.12 v2(233.1,128.18)
  IN1 w0.102: v2(190.29,157.64) 189.97,157.64 189.91,157.58 189.91,156.93 190.37,156.46 190.37,154.47 193.98,150.87 195.11,150.87 198.98,147 205.8,147 205.91,147.11 212.26,147.11 212.93,146.44 213.07,146.3 224.39,134.98 225,134.98 227.52,132.46 227.52,131.85 231.61,127.76 233.1,127.76 233.23,127.88 233.23,128.06 233.11,128.18 v2(233.1,128.18)
  BOTTOM w0.089: JDOCK1.124 190.25,156.84 190.17,156.92 190.17,157.16 190.05,157.28 190.05,157.4 v2(190.29,157.64)
SW1_LAN1_MDIN3: length 66.3
  TOP w0.089: v2(230.92,130.76) 230.32,130.16 230.32,129.31 230.78,128.85 v4(230.78,128.1) 230.78,121.73 230.9,121.61 230.9,121.47 230.83,121.39 U32.36
  IN1 w0.102: v2(191.79,157.64) 191.79,156.93 192.17,156.55 193.76,156.55 194.52,157.31 202.99,157.31 204.08,156.22 204.08,155.05 209.94,149.18 211.55,149.18 224.76,135.98 226.22,135.98 228.77,133.42 228.77,131.96 230.4,130.33 231.16,130.33 231.26,130.44 231.26,130.72 231.21,130.76 v2(230.92,130.76)
  BOTTOM w0.089: v2(191.79,157.64) 191.67,157.52 191.67,156.99 191.75,156.91 JDOCK1.130
SW1_LAN1_MDIP0: length 75.2
  TOP w0.089: U32.22 237.83,121.44 237.67,121.6 237.67,121.8 237.83,121.95 238.36,121.95 238.5,122.09 238.5,122.23 238.36,122.37 v2(238.13,122.37)
  IN1 w0.102: v2(185.11,157.64) 185.11,155.51 188.22,152.4 188.22,149.23 190.15,147.3 195.44,147.3 198.03,144.71 206.75,144.71 206.86,144.83 211.31,144.83 232.1,124.03 234.28,124.03 234.64,123.68 235.23,123.68 236.54,122.37 v2(238.13,122.37)
  BOTTOM w0.089: v2(185.11,157.64) 185.3,157.45 185.3,157.07 185.25,157.02 JDOCK1.104
SW1_LAN1_MDIP1: length 73.4
  TOP w0.089: U32.26 235.83,121.38 235.73,121.48 v4(235.73,123.82) 235.73,124.76 235.08,125.41 235.08,125.79 235.38,126.08 235.73,126.08 235.81,126 235.81,125.66 v2(235.77,125.62)
  IN1 w0.102: v2(186.71,157.64) 186.71,155.37 189.87,152.21 189.87,150.58 192.13,148.32 195.79,148.32 198.43,145.68 206.35,145.68 206.46,145.79 211.71,145.79 212.38,145.12 224.05,133.45 224.63,133.45 225.77,132.31 225.77,131.73 231.83,125.67 235.72,125.67 v2(235.77,125.62)
  BOTTOM w0.089: JDOCK1.110 186.75,157.01 186.83,157.08 186.83,157.52 v2(186.71,157.64)
SW1_LAN1_MDIP2: length 68.7
  TOP w0.089: U32.31 233.33,121.37 233.28,121.42 233.21,121.42 233.17,121.47 233.17,123.35 v4(232.62,123.89) 232.3,124.21 232.3,127.19 232.89,127.78 233.18,127.78 233.32,127.64 v2(233.32,127.38)
  IN1 w0.102: v2(189.47,157.64) 189.55,157.56 189.55,156.78 190.02,156.31 190.02,154.33 193.83,150.52 194.96,150.52 198.83,146.64 205.95,146.64 206.06,146.76 212.11,146.76 212.78,146.08 212.92,145.94 224.24,134.62 224.85,134.62 227.16,132.31 227.16,131.7 231.46,127.4 233.28,127.4 233.31,127.38 v2(233.32,127.38)
  BOTTOM w0.089: v2(189.47,157.64) 189.71,157.41 189.71,157.13 189.83,157.02 189.83,156.92 189.75,156.84 JDOCK1.122
SW1_LAN1_MDIP3: length 66.3
  TOP w0.089: U32.35 231.33,121.37 231.25,121.45 231.25,121.75 231.12,121.88 v4(231.12,126.87) 231.12,128.99 230.66,129.45 230.66,130.02 230.97,130.32 231.12,130.32 231.2,130.25 v2(231.2,129.92)
  IN1 w0.102: v2(191.21,157.64) 191.44,157.41 191.44,156.78 192.03,156.19 193.91,156.19 194.67,156.95 202.84,156.95 203.72,156.07 203.72,154.9 209.8,148.83 211.4,148.83 224.61,135.62 226.07,135.62 228.42,133.28 228.42,131.81 230.3,129.93 231.18,129.93 v2(231.2,129.92)
  BOTTOM w0.089: v2(191.21,157.64) 191.33,157.52 191.33,157.02 191.25,156.94 JDOCK1.128
SW2:
  vias: v1(348.93,24.27)
SW2_3PH_A: length 38
  TOP w0.254: PR1146.1 252,53.18 v1(252.35,52.83) 252.35,52.39 v2(252.26,52.3)
  IN3 w0.254: v2(252.26,52.3) 251.79,52.77 250.08,52.77 247.31,50.01 243.63,50.01 242.62,51.01 242.62,55.2 239.96,57.87 233.97,57.87 232.13,56.03 231.42,56.03 231.29,56.15 v2(231.29,56.73)
  BOTTOM w0.254: v2(252.26,52.3) 252.26,52.3 253.01,51.56 253.01,51.53 PR1161.1 ; v2(231.29,56.73) 231.29,53.23 231.8,52.73 PL1201.2
SW2_3PH_B: length 47.8
  TOP w0.254: 249.54,40.17 249.39,40.03 249.39,39.02 251.31,37.1 PR1147.2 ; 249.54,40.17 v1(249.54,40.17) ; 249.54,40.17 v2(249.9,40.53) ; v2(225.32,27.39) 225.32,23.52 225.7,23.13 PL1401.2
  IN3 w0.254: v2(249.9,40.53) 249.9,40.62 250.3,41.02 251.19,41.02 251.67,40.55 251.67,39.3 250.68,38.31 246.4,38.31 241.92,33.83 238.36,33.83 232.72,28.19 225.53,28.19 225.21,27.87 225.21,27.5 v2(225.32,27.39)
  BOTTOM w0.254: PR1162.2 251.22,40.61 250.79,41.04 250.22,41.04 249.9,40.72 v2(249.9,40.53)
SW2_DP_AUXN: length 21.2
  TOP w0.089: v2(172.19,140.36) 172.08,140.25 171.35,140.25 169.12,142.49 169.12,143.85 168.38,144.58 168.07,144.58 167.84,144.36 167.84,143.89 167.97,143.77 168.14,143.77 168.26,143.89 v2(168.26,143.95)
  BOTTOM w0.089: JDOCK1.35 166.25,147.1 166.1,146.95 166.1,145.66 166.36,145.4 167.54,145.4 v4(167.93,145.01) 168.13,144.81 168.13,144.08 v2(168.26,143.95) ; U629.31 174.39,139.51 174.42,139.54 174.42,139.62 173.44,140.6 172.78,140.6 172.62,140.45 172.62,140.21 172.5,140.09 172.36,140.09 172.27,140.18 172.27,140.29 v2(172.19,140.36) 172,140.17 172,139.85 172.13,139.72 172.54,139.72 172.66,139.6 172.66,139.43 172.54,139.31 171.8,139.31 171.67,139.44 171.67,139.85 171.54,139.98 Q365.4
SW2_DP_AUXP: length 21.3
  TOP w0.089: v2(167.43,144) 167.5,144.07 167.5,144.51 167.92,144.93 168.52,144.93 169.46,143.99 169.46,142.63 171.49,140.6 171.84,140.6 v2(172.19,140.95)
  BOTTOM w0.089: U629.32 174.79,139.51 174.76,139.54 174.76,139.77 173.58,140.95 v2(172.19,140.95) 172.19,141.69 171.51,142.37 170.51,142.37 Q365.1 ; JDOCK1.33 165.75,145.53 v4(166.02,145.25) 166.22,145.05 167.39,145.05 167.78,144.66 167.78,144.36 v2(167.43,144)
SW2_DP_HPD: length 25.5
  TOP w0.102: C695.1 R757.1 ; C695.1 168.03,147.81 168.03,145.66 168.29,145.4 168.72,145.4 169.7,144.42 v1(174.88,144.42) 177.4,144.42 178.18,143.63 v2(178.31,143.63) ; C695.1 167.41,148.85 v2(168.57,150.01)
  BOTTOM w0.102: v2(178.31,143.63) 178.35,143.59 178.35,142.26 178.57,142.04 178.57,140.66 178.92,140.31 179.45,140.31 179.69,140.07 179.69,139.74 179.59,139.64 U629.44 ; JDOCK1.39 167.25,148.88 168.1,149.72 168.29,149.72 v2(168.57,150.01)
SW2_DP_N0: length 33.2
  TOP w0.089: C367.2 155.17,144.77 155.16,144.77 155.1,144.84 154.89,144.84 v2(154.66,144.61)
  IN4 w0.102: v2(180.33,140.2) 180.24,140.11 180.24,139.52 179.46,138.73 176.37,138.73 176.08,139.03 175.71,139.39 175.57,139.53 174.54,139.53 172.55,141.52 169.68,141.52 169.1,140.95 168.91,140.95 168.9,140.94 161.93,140.94 159.95,142.92 158.07,142.92 156.04,144.95 154.91,144.95 154.66,144.71 v2(154.66,144.61)
  BOTTOM w0.089: U629.45 179.99,139.38 180.18,139.57 180.18,139.71 179.91,139.98 179.91,140.41 179.96,140.47 180.18,140.47 180.33,140.32 v2(180.33,140.2)
SW2_DP_N0_C: length 1.1
  TOP w0.089: R2165.1 156.84,144.88 156.51,144.88 C367.1
SW2_DP_N0_R: length 7.9
  TOP w0.089: R2165.2 158.14,144.73 158.53,144.73 v4(159.38,145.58) 160.19,146.39 160.19,149.53 v2(160.29,149.64)
  BOTTOM w0.089: JDOCK1.11 160.25,148.94 160.16,149.03 160.16,149.51 v2(160.29,149.64)
SW2_DP_N1: length 26.1
  TOP w0.089: C369.2 161.82,145.05 161.51,144.74 161.51,144.66 161.14,144.29 160.98,144.29 v2(160.77,144.09)
  IN4 w0.102: v2(178.7,139.91) 178.85,140.06 178.85,140.17 178.67,140.34 178.08,140.34 177.49,139.75 176.81,139.75 176.41,140.14 176.41,140.27 175.91,140.76 175.81,140.76 174.08,142.49 169.28,142.49 168.7,141.92 162.35,141.92 161.24,143.02 161.24,144.46 161.14,144.56 160.71,144.56 160.61,144.46 160.61,144.25 v2(160.77,144.09)
  BOTTOM w0.089: U629.42 178.79,139.51 178.81,139.53 178.81,139.79 v2(178.7,139.91)
SW2_DP_N1_C: length 1.1
  TOP w0.089: C369.1 161.56,146.92 161.56,147.26 R2167.1
SW2_DP_N1_R: length 7.7
  TOP w0.089: R2167.2 161.82,149.87 161.13,150.57 160.74,150.57 160.46,150.85 160.27,150.85 v2(160.1,151.02)
  BOTTOM w0.089: v2(160.1,151.02) 160.29,150.83 160.4,150.83 160.67,150.55 161.17,150.55 161.75,149.97 161.75,149.07 JDOCK1.17
SW2_DP_N2: length 24.4
  TOP w0.089: C425.2 163.34,145.48 163.34,145.03 163.14,144.83 163.14,144.31 162.72,143.9 162.41,143.9 v2(162.35,143.83)
  IN4 w0.102: v2(162.35,143.83) 162.21,143.97 162.21,144.19 162.27,144.25 162.61,144.25 162.78,144.08 162.78,143.36 163.26,142.88 168.3,142.88 169.71,144.29 173.64,144.29 175.88,142.06 177.6,142.06 177.66,142 177.66,141.85 v2(177.43,141.63)
  BOTTOM w0.089: v2(177.43,141.63) 177.59,141.47 177.59,139.51 U629.39
SW2_DP_N2_C: length 1.1
  TOP w0.089: R2169.1 163.33,147.24 163.33,146.93 C425.1
SW2_DP_N2_R: length 10.7
  TOP w0.089: R2169.2 163.6,148.78 163.3,149.08 163.3,150.06 v4(162.38,150.98) 161.43,151.93 v2(160.89,151.93)
  BOTTOM w0.089: JDOCK1.23 163.25,150.99 162.31,151.93 v2(160.89,151.93)
SW2_DP_N3: length 23.6
  TOP w0.089: v2(163.8,143.7) 163.85,143.75 164.42,143.75 165.38,144.7 C427.2
  IN4 w0.102: v2(176.08,143.21) 175.99,143.31 175.99,143.5 176.09,143.61 176.24,143.61 176.31,143.68 176.31,143.87 175.76,144.42 174.93,144.42 173.8,145.54 173.8,145.99 173.38,146.41 169.49,146.41 168,144.93 166.35,144.93 165.62,144.2 163.99,144.2 163.8,144 v2(163.8,143.7)
  BOTTOM w0.089: U629.36 176.39,139.51 176.21,139.69 176.21,143.09 v2(176.08,143.21)
SW2_DP_N3_C: length 1.1
  TOP w0.089: R2171.1 165.1,147.24 165.1,146.93 C427.1
SW2_DP_N3_R: length 2.8
  TOP w0.089: v2(164.93,149.43) 164.83,149.33 164.83,149.2 165.08,148.95 165.08,148.73 R2171.2
  BOTTOM w0.089: JDOCK1.29 164.75,149.25 v2(164.93,149.43)
SW2_DP_P0: length 33.1
  TOP w0.089: C366.2 155.02,145.18 154.79,145.18 v2(154.66,145.31)
  IN4 w0.102: v2(180.26,140.86) 179.81,140.42 179.81,139.59 179.31,139.09 176.52,139.09 176.33,139.28 176.06,139.54 175.72,139.89 174.69,139.89 172.69,141.88 169.53,141.88 168.96,141.31 168.77,141.31 168.75,141.29 162.08,141.29 160.1,143.27 158.22,143.27 156.19,145.31 v2(154.66,145.31)
  BOTTOM w0.089: v2(180.26,140.86) 180.74,140.38 180.74,139.98 180.56,139.81 180.56,139.45 180.39,139.28 U629.46
SW2_DP_P0_C: length 1.1
  TOP w0.089: C366.1 156.53,145.22 156.83,145.22 R2164.1
SW2_DP_P0_R: length 7.9
  TOP w0.089: v2(159.71,149.64) 159.85,149.5 v4(159.85,148.84) 159.85,146.53 158.39,145.07 157.95,145.07 157.85,145.17 157.85,145.33 R2164.2
  BOTTOM w0.089: v2(159.71,149.64) 159.82,149.53 159.82,149.09 159.75,149.02 JDOCK1.9
SW2_DP_P1: length 26.1
  TOP w0.089: C368.2 161.31,145.36 161.4,145.36 161.48,145.29 161.48,145.19 161.17,144.88 161.17,144.8 161,144.63 160.79,144.63 160.73,144.69 v2(160.73,144.98)
  IN4 w0.102: v2(179.28,139.91) 179.2,139.98 179.2,140.32 178.82,140.7 177.94,140.7 177.34,140.1 176.95,140.1 176.76,140.29 176.76,140.41 176.06,141.12 175.95,141.12 174.23,142.84 169.13,142.84 168.56,142.27 162.5,142.27 161.6,143.17 161.6,144.6 161.29,144.91 160.8,144.91 v2(160.73,144.98)
  BOTTOM w0.089: v2(179.28,139.91) 179.15,139.78 179.15,139.53 179.19,139.49 U629.43
SW2_DP_P1_C: length 1.1
  TOP w0.089: R2166.1 161.22,147.23 161.22,146.94 C368.1
SW2_DP_P1_R: length 7.6
  TOP w0.089: R2166.2 160.93,148.69 161.08,148.84 161.41,148.84 161.48,148.91 161.48,149.73 v4(161.27,149.94) 160.99,150.22 160.59,150.22 160.31,150.5 160.21,150.5 v2(159.95,150.24)
  BOTTOM w0.089: v2(159.95,150.24) 159.95,150.43 160.01,150.49 160.29,150.49 160.35,150.43 160.35,150.29 160.43,150.21 161.03,150.21 161.41,149.83 161.41,149.21 161.35,149.16 161.29,149.16 161.25,149.11 JDOCK1.15
SW2_DP_P2: length 24.4
  TOP w0.089: v2(162.32,144.71) 162.32,144.7 162.18,144.56 162.18,144.38 162.32,144.24 162.58,144.24 162.79,144.46 162.79,144.97 163,145.17 163,145.46 C424.2
  IN4 w0.102: v2(178.02,141.63) 178.02,142.14 177.75,142.41 176.02,142.41 173.79,144.65 169.57,144.65 168.16,143.24 163.4,143.24 163.14,143.5 163.14,144.23 162.75,144.61 162.42,144.61 v2(162.32,144.71)
  BOTTOM w0.089: U629.40 177.99,139.51 177.93,139.56 177.93,141.54 v2(178.02,141.63)
SW2_DP_P2_C: length 1.1
  TOP w0.089: C424.1 162.98,146.93 162.98,147.25 R2168.1
SW2_DP_P2_R: length 10.7
  TOP w0.089: R2168.2 163.1,148.43 163.15,148.48 163.15,148.8 162.96,148.99 v4(162.96,149.58) 162.96,149.92 161.7,151.18 161.64,151.18 161.41,151.4 161.41,151.46 161.29,151.59 161.14,151.59 161.04,151.49 161.04,151.37 v2(160.85,151.18)
  BOTTOM w0.089: JDOCK1.21 162.75,149.09 162.91,149.25 162.91,150.85 162.16,151.59 161.92,151.59 161.77,151.44 161.6,151.44 161.45,151.59 161.17,151.59 161.12,151.53 161.12,151.44 v2(160.85,151.18)
SW2_DP_P3: length 23.6
  TOP w0.089: v2(163.76,144.55) 163.76,144.31 163.99,144.09 164.28,144.09 165.04,144.85 165.04,145.19 C426.2
  IN4 w0.102: v2(163.76,144.55) 165.47,144.55 166.2,145.28 167.85,145.28 169.34,146.77 173.52,146.77 174.16,146.13 174.16,145.69 175.07,144.77 175.91,144.77 176.67,144.01 v2(176.67,143.21)
  BOTTOM w0.089: U629.37 176.79,139.51 176.73,139.56 176.73,139.65 176.55,139.83 176.55,143.09 v2(176.67,143.21)
SW2_DP_P3_C: length 1.1
  TOP w0.089: R2170.1 164.76,147.25 164.76,146.93 C426.1
SW2_DP_P3_R: length 2.8
  TOP w0.089: R2170.2 164.74,148.68 164.74,148.81 164.49,149.06 164.49,149.29 v2(164.35,149.43)
  BOTTOM w0.089: JDOCK1.27 164.25,148.81 164.41,148.97 164.41,149.37 v2(164.35,149.43)
SW3_3PH_A: length 40.5
  TOP w0.254: v2(253.52,52.98) 253.12,52.98 252.87,53.22 PR1148.1
  IN3 w0.254: v2(231.29,46.57) 231.25,46.52 231.25,45.87 231.75,45.36 233.79,45.36 235.64,47.21 239.18,47.21 242.86,43.53 247.82,43.53 251.11,46.82 251.11,49.74 253.03,51.66 253.03,52.54 253.32,52.83 253.36,52.83 v2(253.52,52.98)
  BOTTOM w0.254: v2(231.29,46.57) 231.29,43.07 231.8,42.57 PL1202.2 ; PR1163.1 v1(254.15,52.26) 254.15,52.56 253.73,52.98 v2(253.52,52.98)
SW3_3PH_B: length 38.3
  TOP w0.254: v2(225.32,37.55) 225.32,33.68 225.7,33.29 PL1402.2 ; v2(249.9,39.52) 249.9,39.13 v1(250.44,38.59) 250.91,38.12 PR1149.2
  IN3 w0.254: v2(249.9,39.52) 245.26,39.52 241.35,35.61 235.69,35.61 234.41,36.89 231.07,36.89 229.7,38.26 225.51,38.26 225.19,37.95 225.19,37.68 v2(225.32,37.55)
  BOTTOM w0.254: PR1164.2 251.22,39.59 250.79,40.03 250.28,40.03 249.9,39.64 v2(249.9,39.52)
SW3_DP1_AUXN: length 60.3
  IN1 w0.102: v2(147.49,119.21) 147.39,119.31 147.39,119.75 147.67,120.04 151.3,120.04 v2(152.12,120.86) 152.21,120.95 152.71,120.95 152.99,121.23 153.66,121.23 154.13,121.7 155.07,121.7 155.36,121.7 156.77,123.1 156.93,123.1 157.76,123.93 159.64,123.93 161.56,125.85 161.56,129.11 161.79,129.34 161.79,140.38 165.52,144.12 165.52,146.46 168,148.93 168,150.38 167.47,150.91 167.19,150.91 v2(167.1,151)
  BOTTOM w0.089: v2(167.1,151) 167.19,150.91 167.19,150.71 167.06,150.58 166.5,150.58 166.32,150.76 166.32,154.33 166.09,154.56 166.09,155 166.14,155.04 166.2,155.04 166.25,155.09 JDOCK1.36 ; v2(152.12,120.86) 152.29,120.7 152.29,120.54 152.15,120.4 152.07,120.4 152,120.48 151.86,120.48 151.81,120.43 151.81,120.3 151.52,120.01 151.52,119.7 151.22,119.41 151.22,117.96 151.36,117.82 151.36,117.71 v4(152.02,117.06) 152.44,116.63 152.44,116.52 152.73,116.23 152.89,116.23 152.95,116.29 UV2.27 ; v2(147.49,119.21) 147.49,119.15 147.82,118.81 Q364.4
SW3_DP1_AUXP: length 60.3
  IN1 w0.102: v2(146.74,119.21) 147.03,119.5 147.03,119.9 147.53,120.39 151.15,120.39 151.49,120.73 v2(151.49,120.86) 151.49,121.03 151.77,121.31 152.56,121.31 152.85,121.59 153.52,121.59 153.99,122.05 155.21,122.05 156.62,123.46 156.78,123.46 157.03,123.71 157.61,124.29 159.5,124.29 161.21,126 161.21,129.26 161.43,129.49 161.43,140.53 165.17,144.26 165.17,146.6 167.64,149.08 167.64,150.23 167.32,150.55 167.16,150.55 167.09,150.48 167.09,150.2 v2(167.11,150.18)
  BOTTOM w0.089: UV2.26 152.59,115.88 152.1,116.38 152.1,116.49 151.02,117.57 151.02,117.67 150.88,117.81 v4(150.88,118.92) 150.88,119.55 151.17,119.84 151.17,120.15 151.49,120.47 v2(151.49,120.86) ; v2(146.74,119.21) 146.73,119.22 146.54,119.22 146.42,119.34 146.42,119.72 146.52,119.82 Q364.1 ; v2(167.11,150.18) 167.05,150.24 166.36,150.24 165.98,150.61 165.98,154.19 165.75,154.42 JDOCK1.34
SW3_DP1_HPD: length 50.4
  TOP w0.102: v2(167.13,154.73) 166.84,155.02 C696.1 R2160.1 ; v2(159.5,136.05) 159.5,135.91 156.1,132.51 155.77,132.51 155.66,132.4 155.66,131.94 155.67,131.93 155.44,131.7 154.24,131.7 154.01,131.47 154.01,130.21 157.17,127.05 157.17,125.05 v1(158.1,124.13) 161.58,120.64 161.92,120.64 162.16,120.41 162.16,120.07 161.87,119.78 161.65,119.78 v2(161.01,119.15)
  IN1 w0.109: v2(167.13,154.73) 167.14,154.72 167.14,154.48 163.43,150.77 163.05,150.77 161.79,149.51 161.79,148.47 161.24,147.93 161.24,143.46 159.56,141.77 159.56,136.11 v2(159.5,136.05)
  BOTTOM w0.102: v2(167.13,154.73) 167.25,154.85 JDOCK1.40 ; UV2.48 160.89,119.02 v2(161.01,119.15)
SW3_DP1_N0: length 50.2
  TOP w0.089: v2(159.47,152.51) 159.47,152.59 159.9,153.02 159.9,153.4 C438.2
  IN3 w0.114: v2(161.17,120.24) 161.17,120.45 161.25,120.54 161.33,120.54 161.38,120.59 161.38,123.11 162.57,124.3 162.57,128.84 162.2,129.22 162.2,140.85 164.39,143.05 164.39,147.43 166.16,149.19 166.16,153.99 164.55,155.61 160.71,155.61 159.67,154.57 159.67,153.31 159.06,152.7 159.06,152.62 159.27,152.41 159.36,152.41 v2(159.47,152.51)
  BOTTOM w0.089: UV2.49 161.29,118.85 161.43,118.99 161.43,119.45 161.29,119.6 161.29,120.1 161.17,120.22 v2(161.17,120.24)
SW3_DP1_N0_C: length 1.1
  TOP w0.089: C438.1 159.91,154.85 159.91,155.19 R2173.2
SW3_DP1_N0_R: length 3.4
  TOP w0.089: v2(160.23,157.76) 160.03,157.56 160.03,156.51 R2173.1
  BOTTOM w0.089: JDOCK1.12 160.25,156.91 160.14,157.02 160.14,157.67 v2(160.23,157.76)
SW3_DP1_N1: length 39.8
  TOP w0.089: v2(163.38,152.1) 163.38,152.06 163.17,151.85 162.84,151.85 v4(162.21,152.48) 161.82,152.88 161.46,152.88 161.4,152.94 161.4,153.16 161.46,153.22 161.79,153.22 161.95,153.38 C440.2
  IN3 w0.114: v2(163.38,152.1) 163.31,152.03 163.13,151.85 162.67,151.85 162.29,151.47 162.29,149.93 162.76,149.45 162.76,143.07 161.21,141.51 161.21,124.77 160.09,123.65 160.09,120.57 v2(159.99,120.47)
  BOTTOM w0.089: v2(159.99,120.47) 160.13,120.34 160.13,119.88 160.23,119.78 160.23,119.08 160.12,118.97 160.12,118.69 160.09,118.66 UV2.46
SW3_DP1_N1_C: length 1.1
  TOP w0.089: R2175.2 161.68,155.18 161.68,154.87 C440.1
SW3_DP1_N1_R: length 3.1
  TOP w0.089: R2175.1 161.68,156.64 161.68,157.52 v2(161.79,157.63)
  BOTTOM w0.089: v2(161.79,157.63) 161.67,157.51 161.67,157.14 161.75,157.06 161.75,157.06 JDOCK1.18
SW3_DP1_N2: length 40.4
  TOP w0.089: v2(163.57,152.99) 163.52,152.99 163.39,153.12 163.39,153.34 C442.2
  IN3 w0.114: v2(163.57,152.99) 163.5,153.06 163.5,153.49 163.11,153.88 162.14,153.88 161.6,153.33 161.6,152.19 161.3,151.89 161.3,148.91 160.84,148.45 160.84,146.6 159.76,145.52 159.76,143 160.08,142.68 160.08,129.9 159.57,129.4 159.57,124.53 159.1,124.07 159.1,120.09 159.28,119.91 159.28,119.76 v2(159.14,119.62)
  BOTTOM w0.089: v2(159.14,119.62) 159.29,119.48 UV2.44
SW3_DP1_N2_C: length 1.1
  TOP w0.089: R2177.2 163.45,155.18 163.45,154.87 C442.1
SW3_DP1_N2_R: length 3.3
  TOP w0.089: v2(163.29,157.63) 163.17,157.51 163.17,157.27 163.46,156.98 163.46,156.64 R2177.1
  BOTTOM w0.089: JDOCK1.24 163.25,157.06 163.25,157.06 163.17,157.14 163.17,157.51 v2(163.29,157.63)
SW3_DP1_N3: length 48.8
  TOP w0.089: v2(165.6,150.22) 165.35,150.48 165.35,150.91 C444.2
  IN3 w0.114: v2(157.86,120.47) 157.93,120.54 157.93,121.39 158.08,121.55 158.08,128.29 156.83,129.54 156.83,130.47 158.04,131.68 158.04,144.77 157.6,145.22 157.6,147.56 158.61,148.57 158.61,150.77 160.58,152.74 160.58,154.22 161.24,154.88 163.96,154.88 165.49,153.36 165.49,150.34 v2(165.6,150.22)
  BOTTOM w0.089: UV2.41 158.09,118.7 158.12,118.73 158.12,119.12 157.98,119.26 157.98,120.34 157.86,120.46 v2(157.86,120.47)
SW3_DP1_N3_C: length 1.1
  TOP w0.089: C444.1 165.31,152.31 165.31,152.65 R2179.2
SW3_DP1_N3_R: length 5.9
  TOP w0.089: R2179.1 165.3,154.1 165.3,156.49 v4(165,156.78) 164.67,157.12 164.67,157.51 v2(164.79,157.63)
  BOTTOM w0.089: JDOCK1.30 164.75,157.06 164.75,157.06 164.67,157.14 164.67,157.51 v2(164.79,157.63)
SW3_DP1_P0: length 50.2
  TOP w0.089: v2(158.87,153.09) 159.02,152.94 159.33,152.94 159.55,153.16 159.55,153.35 159.38,153.53 159.38,153.58 C431.2
  IN3 w0.114: v2(158.87,153.09) 158.93,153.09 159.3,153.46 159.3,154.72 160.56,155.98 164.7,155.98 166.53,154.15 166.53,149.04 164.76,147.28 164.76,142.9 162.56,140.7 162.56,129.37 162.94,128.99 162.94,124.14 161.75,122.96 v2(161.75,120.24)
  BOTTOM w0.089: UV2.50 161.69,118.83 161.78,118.92 161.78,119.59 161.63,119.74 161.63,120.12 v2(161.75,120.24)
SW3_DP1_P0_C: length 1.1
  TOP w0.089: R2172.2 159.57,155.17 159.57,154.88 C431.1
SW3_DP1_P0_R: length 3.4
  TOP w0.089: v2(159.65,157.76) 159.65,157.76 159.65,156.74 R2172.1
  BOTTOM w0.089: JDOCK1.10 159.75,157.06 159.8,157.1 159.8,157.61 v2(159.65,157.76)
SW3_DP1_P1: length 39.8
  TOP w0.089: v2(163.38,151.51) 162.7,151.51 161.67,152.53 161.32,152.53 161.06,152.79 C439.2
  IN3 w0.114: v2(160.58,120.47) 160.46,120.6 160.46,123.5 161.57,124.62 161.57,141.36 163.13,142.91 163.13,149.61 162.66,150.08 162.66,151.32 162.82,151.48 162.91,151.48 162.97,151.42 162.97,151.18 163.06,151.09 163.3,151.09 163.38,151.16 v2(163.38,151.51)
  BOTTOM w0.089: UV2.47 160.49,118.67 160.46,118.7 160.46,118.83 160.57,118.94 v4(160.57,119.46) 160.57,119.92 160.47,120.02 160.47,120.36 v2(160.58,120.47)
SW3_DP1_P1_C: length 1.1
  TOP w0.089: R2174.2 161.33,155.18 161.33,154.86 C439.1
SW3_DP1_P1_R: length 3.1
  TOP w0.089: R2174.1 161.33,156.64 161.33,157.51 v2(161.21,157.63)
  BOTTOM w0.089: v2(161.21,157.63) 161.33,157.51 161.33,157.14 161.25,157.06 JDOCK1.16
SW3_DP1_P2: length 40.4
  TOP w0.089: v2(162.72,153.07) 162.87,153.07 163.05,153.25 163.05,153.47 C441.2
  IN3 w0.114: v2(159.73,119.62) 159.64,119.71 159.64,120.06 159.47,120.24 159.47,123.91 159.94,124.38 159.94,129.24 160.23,129.53 160.44,129.75 160.44,142.83 160.13,143.15 160.13,145.37 161.21,146.45 161.21,148.29 161.67,148.75 161.67,151.74 161.97,152.04 161.97,153.18 162.3,153.51 162.96,153.51 163.14,153.33 163.14,152.77 163.01,152.65 162.69,152.65 162.56,152.77 162.56,152.95 162.69,153.07 v2(162.72,153.07)
  BOTTOM w0.089: v2(159.73,119.62) 159.62,119.52 159.62,118.96 159.69,118.89 UV2.45
