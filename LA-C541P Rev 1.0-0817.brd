# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_BA1: length 82.5
  TOP w0.089: CPU1.AH9 v2(177.22,45.14)
  TOP w0.203: JDIMM3.145 117.17,53.17 116.87,53.47 113.35,53.47 v2(112.91,53.03)
  IN4 w0.089: v2(177.22,45.14) 176.85,44.76 175.82,44.76 175.54,45.04 171.77,45.04 171.49,45.32 164.46,45.32 163.47,46.3 162.46,46.3 162.18,46.58 162.02,46.58
  IN4 w0.208: 162.02,46.58 153.55,46.58 148.48,51.65 140,51.65 137.29,54.37 130.15,54.37 130.15,54.37 127.88,54.37 127.88,54.37 125.78,54.37 125.28,53.88 120.54,53.88 120.28,54.13 112.18,54.13 112.06,54.01 112.06,53.41 112.18,53.28 112.66,53.28 v2(112.91,53.03)
  BOTTOM w0.203: v2(112.91,53.03) 112.77,53.17 112.55,53.17 112.35,52.97 112.35,52.1 112.15,51.9 111.74,51.9 111.54,52.1 111.54,52.97 111.33,53.17 JDIMM4.145
DDR_B_BG0: length 77
  TOP w0.089: CPU1.AR9 v2(177.22,39.65)
  TOP w0.203: v2(116.43,42.46) 116.43,42.47 117.63,43.68 JDIMM3.115
  IN4 w0.089: v2(177.22,39.65) 177.22,39.48 177.02,39.28 175.69,39.28 175.32,38.9 175.32,38.51 174.01,37.2 169.53,37.2 168.46,36.13 165.27,36.13 162.97,33.83 162.58,33.83
  IN4 w0.208: v2(116.43,42.46) 116.54,42.34 117.04,42.34 119.32,40.05 123.63,40.05 124.29,39.4 125.83,39.4 126.41,38.81 133.8,38.81 134.14,38.47 139.38,38.47 143.35,34.5 143.35,34.5 144.02,33.83 162.58,33.83
  BOTTOM w0.203: v2(116.43,42.46) 116.43,42.57 116.04,42.95 114.36,42.95 114.33,42.91 112.4,42.91 111.64,43.68 JDIMM4.115
DDR_B_BG1: length 78.3
  TOP w0.089: CPU1.AR7 v2(175.92,39.65)
  TOP w0.203: v2(113.89,42.45) 113.89,42.41 114.34,41.96 114.81,41.96 114.93,41.84 116.56,41.84 117.9,43.17 JDIMM3.113
  IN4 w0.089: v2(175.92,39.65) 175.81,39.65 175.14,38.98 175.14,38.6 174.72,38.18 173.88,38.18 173.2,37.5 168.65,37.5 167.55,36.41 165.04,36.41 163.01,34.38 162.65,34.38
  IN4 w0.208: 162.65,34.38 144.25,34.38 143.34,35.29 139.61,39.02 134.37,39.02 134.02,39.36 130.05,39.36 129.47,39.95 124.78,39.95 124.13,40.61 119.55,40.61 117.24,42.92 115.43,42.92 115.34,43 114.21,43 113.89,42.68 v2(113.89,42.45)
  BOTTOM w0.203: v2(113.89,42.45) 113.89,42.46 113.73,42.61 112.28,42.61 111.71,43.17 JDIMM4.113
DDR_B_CB0: length 86.3
  TOP w0.089: CPU1.AW11 v2(178.52,36.91)
  TOP w0.14: v2(115.04,39.96) 114.58,40.42 111.95,40.42 111.44,40.92 JDIMM3.104
  IN3 w0.089: v2(178.52,36.91) 178.94,37.32 178.94,37.98 178.63,38.29 175.84,38.29 175.55,38.58 175.55,39.21 174.09,40.67 173.57,40.67
  IN3 w0.17: v2(115.04,39.96) 115.04,40.24 115.14,40.34 117.02,40.34 120.82,44.14 123.36,44.14 125.43,46.21 133.1,46.21 133.27,46.04 133.27,45.33 133.4,45.2 133.83,45.2 133.95,45.33 133.95,46.04 134.12,46.21 137.79,46.21 137.96,46.04 137.96,45.45 138.09,45.32 138.52,45.32 138.65,45.45 138.65,46.04 138.82,46.21 139.16,46.21 139.33,46.04 139.33,45.52 139.45,45.4 139.88,45.4 140.01,45.52 140.01,46.04 140.18,46.21 145.19,46.21 150.7,40.7 171.22,40.7 171.25,40.67 173.57,40.67
  BOTTOM w0.14: JDIMM4.104 118.06,40.92 117.45,40.32 116.57,40.32 116.52,40.27 116.52,40.03 116.39,39.9 116.09,39.9 115.96,40.03 115.96,40.27 115.82,40.41 115.49,40.41 v2(115.04,39.96)
DDR_B_CB1: length 87.7
  TOP w0.089: CPU1.AY11 v2(178.52,35.99)
  TOP w0.14: v2(113.88,35.75) 114.31,36.19 114.31,36.41 114.19,36.53 113.33,36.53 112.96,36.16 112.76,36.16 112.56,36.36 112.37,36.36 112.09,36.08 111.91,36.08 111.69,36.3 111.69,36.47 111.97,36.75 111.97,36.95 111.8,37.12 111.61,37.12 111.42,36.92 JDIMM3.88
  IN3 w0.089: v2(178.52,35.99) 178.4,35.99 177.85,35.44 176.4,35.44 176.22,35.26 175.62,35.26 174.92,35.97 174.92,36.16 174.6,36.48 174.2,36.48
  IN3 w0.17: v2(113.88,35.75) 115.5,34.13 116.18,34.13 116.29,34.02 121.15,34.02 121.73,34.6 121.73,35.06 122.12,35.45 123.54,35.45 126.06,37.96 126.06,39.56 126.61,40.1 144.13,40.1 144.69,39.55 144.93,39.55 145.07,39.69 145.31,39.69 145.55,39.45 145.55,39.21 145.41,39.07 145.41,38.83 145.65,38.59 145.89,38.59 146.03,38.73 146.27,38.73 146.51,38.49 146.51,38.25 146.37,38.11 146.37,37.87 146.61,37.63 146.85,37.63 146.99,37.77 147.23,37.77 147.47,37.53 147.47,37.29 147.33,37.14 147.33,36.9 149.14,35.1 165.14,35.1 165.69,35.65 169.65,35.65 170.48,36.48 174.2,36.48
  BOTTOM w0.14: v2(113.88,35.75) 114.37,35.26 116.69,35.26 117.23,35.81 117.23,36.57 117.59,36.92 JDIMM4.88
DDR_B_CB2: length 88.2
  TOP w0.089: CPU1.AY8 v2(176.57,35.99)
  TOP w0.102: JDIMM3.91 117.98,37.68 117.74,37.92 117.5,37.92 117.24,37.66 117.24,37.52 117.54,37.21 117.54,37.04 117.42,36.92 117.26,36.92 116.95,37.23 116.81,37.23 116.66,37.08 116.66,36.94 117.04,36.56 117.04,36.4 116.92,36.28 116.75,36.28 116.38,36.65 116.23,36.65 116,36.42 116,36.21 v2(116.42,35.8)
  IN3 w0.089: v2(176.57,35.99) 176.45,35.99 176.08,35.62 175.77,35.62 175.33,36.06 175.33,36.25 174.95,36.63 174.95,36.69 174.64,37 174.24,37
  IN3 w0.17: v2(116.42,35.8) 116.42,35.07 116.66,34.82 117.68,34.82 117.85,34.99 117.85,35.33 117.98,35.45 118.4,35.45 118.53,35.33 118.53,34.95 118.66,34.82 119.09,34.82 119.21,34.95 119.21,35.58 119.34,35.71 119.77,35.71 119.89,35.58 119.89,35 120.02,34.87 120.67,34.87 120.8,35 120.8,35.73 121.44,36.37 123.34,36.37 125.11,38.14 125.11,40.17 125.85,40.9 145.24,40.9 145.84,40.3 146.08,40.3 146.3,40.52 146.54,40.52 146.78,40.28 146.78,40.04 146.56,39.82 146.56,39.58 146.8,39.34 147.05,39.34 147.26,39.55 147.5,39.55 147.74,39.31 147.74,39.07 147.53,38.86 147.53,38.62 147.77,38.37 148.01,38.37 148.23,38.59 148.47,38.59 148.71,38.35 148.71,38.11 148.49,37.89 148.49,37.65 148.73,37.41 148.97,37.41 149.19,37.63 149.43,37.63 149.67,37.39 149.67,37.15 149.45,36.93 149.45,36.69 149.69,36.45 167.55,36.45 168.63,37.54 170.08,37.54 170.62,37 174.24,37
  BOTTOM w0.14: JDIMM4.91 111.74,37.68 112.21,37.2 113.29,37.2 113.77,36.72 115.49,36.72 v2(116.42,35.8)
DDR_B_CB3: length 87.6
  TOP w0.089: v2(176.62,36.95) CPU1.AW8
  TOP w0.14: JDIMM3.92 111.75,37.92 112.22,37.45 112.22,37.04 112.46,36.81 114.2,36.81 114.33,36.94 114.33,37.21 114.19,37.35 113.65,37.35 v2(113.23,37.77)
  IN3 w0.089: v2(176.62,36.95) 175.19,38.38 175.19,38.9 174.19,39.9 173.79,39.9
  IN3 w0.17: v2(113.23,37.77) 113.23,38.89 113.45,39.12 114.43,39.12 114.6,38.95 114.6,38.6 114.77,38.42 115.11,38.42 115.28,38.6 115.28,38.95 115.45,39.12 118.15,39.12 119.18,40.14 121.12,40.14 121.35,40.37 121.35,40.96 121.23,41.09 119.88,41.09 119.78,41.2 119.78,41.44 120.81,42.48 123.42,42.48 125.35,44.41 145.87,44.41 150.37,39.9 173.79,39.9
  BOTTOM w0.14: v2(113.23,37.77) 113.8,37.2 116.91,37.2 117.63,37.92 JDIMM4.92
DDR_B_CB4: length 86.3
  TOP w0.089: CPU1.AY10 v2(177.87,35.99)
  TOP w0.14: v2(115.15,35.78) 115,35.64 115,35.35 115.11,35.23 116.45,35.23 117.9,36.68 JDIMM3.87
  IN3 w0.089: 174.1,36.74 174.59,36.74 175.13,36.2 175.13,36.01 175.69,35.44 176.15,35.44 176.33,35.62 177.5,35.62 v2(177.87,35.99)
  IN3 w0.17: v2(115.15,35.78) 115.11,35.75 115.11,35.08 115.66,34.53 116.34,34.53 116.45,34.42 120.89,34.42 121.2,34.73 121.2,35.48 121.64,35.92 123.46,35.92 125.58,38.05 125.58,40.07 126.01,40.5 145.06,40.5 148.02,37.55 148.02,37.31 147.85,37.14 147.85,36.96 148.15,36.65 148.33,36.65 148.5,36.82 148.74,36.82 148.98,36.58 148.98,36.34 148.81,36.17 148.81,35.99 149.11,35.69 149.29,35.69 149.46,35.86 149.7,35.86 149.93,35.63 150.42,35.63 150.59,35.8 150.59,35.93 150.72,36.06 151.14,36.06 151.27,35.93 151.27,35.62 151.4,35.5 151.82,35.5 151.95,35.62 151.95,35.93 152.08,36.06 152.5,36.06 152.63,35.93 152.63,35.62 152.76,35.5 153.18,35.5 153.31,35.62 153.31,35.93 153.44,36.06 153.87,36.06 153.99,35.93 153.99,35.62 154.12,35.5 154.55,35.5 154.67,35.62 154.67,35.93 154.8,36.06 155.23,36.06 155.35,35.93 155.35,35.62 155.48,35.5 155.91,35.5 156.17,35.76 165.09,35.76 165.38,36.05 169.63,36.05 170.32,36.74 174.1,36.74
  BOTTOM w0.14: v2(115.15,35.78) 114.71,36.22 113.41,36.22 112.96,36.68 JDIMM4.87
DDR_B_CB5: length 87.7
  TOP w0.089: CPU1.AW10 v2(177.87,36.91)
  TOP w0.14: JDIMM3.105 118.02,41.17 117.57,40.72 117.57,40.49 117.43,40.36 116.05,40.36 115.21,39.52 114.16,39.52 v2(113.75,39.93)
  IN3 w0.089: v2(177.87,36.91) 177.33,37.45 176.42,37.45 175.37,38.51 175.37,39.04 174.06,40.35 173.57,40.35
  IN3 w0.17: 173.57,40.35 171.1,40.35 171.05,40.3 150.54,40.3 145.52,45.32 145.13,45.32 144.96,45.15 144.96,45 144.79,44.83 144.45,44.83 144.28,45 144.28,45.46 144.15,45.59 143.72,45.59 143.6,45.46 143.6,45 143.43,44.83 143.09,44.83 142.92,45 142.92,45.15 142.75,45.32 142.41,45.32 142.23,45.15 142.23,45 142.06,44.83 141.72,44.83 141.55,45 141.55,45.15 141.38,45.32 140.58,45.32 140.06,44.81 124.85,44.81 123.23,43.19 120.51,43.19 118.92,41.6 118.92,41.36 119.24,41.04 119.24,40.8 119,40.56 118.76,40.56 118.44,40.88 118.2,40.88 117.96,40.63 117.96,40.39 118.28,40.08 118.28,39.83 118.04,39.59 117.8,39.59 117.48,39.91 117.24,39.91 116.84,39.51 114.16,39.51 v2(113.75,39.93)
  BOTTOM w0.14: JDIMM4.105 111.73,41.17 111.87,41.04 111.87,40.56 112.02,40.41 112.4,40.41 112.55,40.55 112.55,40.99 112.71,41.15 112.94,41.15 113.11,40.99 113.11,40.58 113.27,40.41 113.43,40.41 113.59,40.57 113.88,40.57 114.02,40.44 114.02,40.2 v2(113.75,39.93)
DDR_B_CB6: length 87.6
  TOP w0.089: CPU1.AY7 v2(175.92,35.99)
  TOP w0.14: JDIMM3.100 111.45,39.92 111.97,39.4 111.97,38.67 112.42,38.22 112.94,38.22 113.06,38.35 113.06,38.65 112.94,38.78 112.79,38.78 112.66,38.91 112.66,39.21 112.79,39.34 113.19,39.34 113.31,39.46 113.31,39.7 v2(113.09,39.93)
  IN3 w0.089: v2(175.92,35.99) 175.84,35.99 175.13,36.7 175.13,36.94 174.81,37.26 174.23,37.26
  IN3 w0.17: v2(113.09,39.93) 112.1,38.94 112.1,36.64 112.38,36.36 119.21,36.36 119.98,37.14 121.07,37.14 121.25,36.96 123.2,36.96 124.69,38.45 124.69,40.96 125.79,42.06 140.25,42.06 140.8,41.51 146.24,41.51 150.72,37.03 167.25,37.03 168.02,37.8 170.28,37.8 170.82,37.26 174.23,37.26
  BOTTOM w0.14: JDIMM4.100 117.95,39.92 117.48,39.45 113.56,39.45 v2(113.09,39.93)
DDR_B_CB7: length 88.2
  TOP w0.089: v2(175.96,36.95) CPU1.AW7
  TOP w0.14: v2(116.74,38.67) 116.42,38.35 115.86,38.35 115.57,38.65 115.57,39.22 116.43,40.09 116.87,40.09 116.99,39.97 116.99,39.59 117.13,39.45 117.41,39.45 117.58,39.63 117.58,40.03 117.73,40.17 JDIMM3.101
  IN3 w0.089: v2(175.96,36.95) 175.96,37.29 175.01,38.24 175.01,38.76 174.68,39.1 174.21,39.1
  IN3 w0.17: v2(116.74,38.67) 117.08,38.67 117.25,38.5 117.25,37.79 117.42,37.62 117.93,37.62 118.1,37.79 118.1,38.5 119.17,39.57 121.48,39.57 121.61,39.69 121.61,40.04 121.73,40.16 122.17,40.16 122.29,40.29 122.29,40.72 122.17,40.84 122.07,40.84 121.9,41.01 121.9,41.65 122.33,42.08 123.87,42.08 125.81,44.01 141.7,44.01 141.87,43.84 141.87,42.96 142.04,42.79 142.38,42.79 142.55,42.96 142.55,43.84 142.72,44.01 143.06,44.01 143.23,43.84 143.23,42.96 143.4,42.79 143.74,42.79 143.91,42.96 143.91,43.84 144.08,44.01 144.42,44.01 144.59,43.84 144.59,42.96 144.76,42.79 145.1,42.79 145.27,42.96 145.27,43.84 145.44,44.01 145.7,44.01 150.28,39.43 170.93,39.43 171.26,39.1 174.21,39.1
  BOTTOM w0.14: JDIMM4.101 111.65,40.17 112.29,39.54 112.86,39.54 113.27,39.14 116.28,39.14 v2(116.74,38.67)
DDR_B_CKE0: length 79.5
  TOP w0.089: CPU1.AT8 v2(176.57,38.74)
  IN4 w0.089: v2(176.57,38.74) 176.54,38.74 175.18,37.38 175.18,36.17 174.67,35.65 170.77,35.65 170.46,35.35 165.76,35.35 162.67,32.26 162.46,32.26
  IN4 w0.178: 162.46,32.26 143.37,32.26 140.95,34.68 138.41,34.68 136.66,36.43 134.76,36.43 134.25,35.92 133.21,35.92 133.03,36.1 133.03,36.34 132.9,36.47 132.45,36.47 132.32,36.34 132.32,35.92 132.19,35.79 131.73,35.79 131.61,35.92 131.61,36.66 131.48,36.79 126.16,36.79 125.71,37.23 125.26,37.23 125.14,37.36 125.14,37.68 124.95,37.86 124.44,37.86 124.31,37.74 124.31,37.42 124.12,37.23 123.62,37.23 123.49,37.36 123.49,37.79 123.27,38.01 122.91,38.01 122.77,37.87 122,37.87 121.65,38.21 121.65,38.22 121.39,38.48 121.39,38.48 121.38,38.48 119.7,38.48 119.57,38.36 119.57,37.87 119.45,37.75 118.98,37.75 118.85,37.87 118.85,38.36 118.73,38.48 118.26,38.48 116.47,40.27 116.11,40.27 115.79,40.6 115.79,41.21 115.66,41.34 115.08,41.34 114.95,41.21 114.95,41.01 114.83,40.89 114.08,40.89 113.95,41.01 v2(113.95,41.63)
  BOTTOM w0.165: JDIMM4.109 111.75,42.17 111.84,42.08 113.5,42.08 v2(113.95,41.63)
DDR_B_CKE1: length 79.1
  TOP w0.089: CPU1.AT10 v2(177.87,38.74)
  IN4 w0.089: v2(177.87,38.74) 178.01,38.6 178.01,38.48 177.9,38.37 176.43,38.37 175.36,37.3 175.36,36.03 174.8,35.48 170.99,35.48 170.62,35.1 165.93,35.1 162.61,31.77 162.41,31.77
  IN4 w0.178: v2(121.71,37.4) 121.71,37.47 121.58,37.59 121.14,37.59 121.01,37.47 121.01,37.1 121.25,36.86 121.25,36.5 121.07,36.33 121.07,36.02 121.2,35.89 121.91,35.89 122.04,36.02 122.04,36.84 122.17,36.97 122.62,36.97 122.75,36.84 122.75,36.02 122.88,35.89 123.34,35.89 123.46,36.02 123.46,36.62 123.59,36.75 124.05,36.75 124.17,36.62 124.17,35.92 124.3,35.79 124.76,35.79 124.89,35.92 124.89,36.6 125.01,36.73 125.53,36.73 125.66,36.6 125.66,36.2 125.77,36.08 126.18,36.08 126.4,36.3 130.99,36.3 131.12,36.18 131.12,35.44 131.25,35.31 137.1,35.31 138.21,34.2 138.61,34.2 138.74,34.07 138.74,33.93 138.87,33.8 139.29,33.8 139.41,33.93 139.41,34.07 139.54,34.2 139.95,34.2 140.07,34.07 140.07,33.91 140.19,33.79 141.16,33.79 143.17,31.77 162.41,31.77
  BOTTOM w0.165: v2(121.71,37.4) 121.74,37.43 121.74,41.83 121.32,42.25 120.06,42.25 119.88,42.42 JDIMM4.110
DDR_B_CKE2: length 78.1
  TOP w0.089: CPU1.AT7 v2(175.92,38.74)
  TOP w0.165: v2(116.83,40.79) 116.83,41.07 117.94,42.17 JDIMM3.109
  IN4 w0.089: v2(175.92,38.74) 175.92,38.48 174.9,37.45 174.9,36.8 174.6,36.51 170.51,36.51 170.29,36.28 170.29,35.92 169.97,35.61 165.61,35.61 162.75,32.74 162.51,32.74
  IN4 w0.178: v2(116.83,40.79) 116.83,40.59 117.13,40.29 117.6,40.29 117.91,39.98 117.91,39.51 118.46,38.97 121.58,38.97 121.59,38.96 121.59,38.96 122.06,38.49 123.61,38.49 123.76,38.35 125.28,38.35 126.32,37.3 130.92,37.3 131.04,37.43 131.04,37.6 131.17,37.73 131.74,37.73 131.87,37.6 131.87,37.08 132,36.95 132.46,36.95 132.58,37.08 132.58,37.6 132.71,37.73 133.35,37.73 133.47,37.6 133.47,36.53 133.6,36.41 134.06,36.41 134.18,36.53 134.18,37.21 134.31,37.33 134.74,37.33 134.87,37.21 134.87,37.04 134.99,36.91 137.35,36.91 137.53,36.74 137.53,36.3 137.66,36.18 138.11,36.18 138.24,36.3 138.24,37.25 138.37,37.38 138.83,37.38 138.96,37.25 138.96,36 138.83,35.87 138.62,35.87 138.5,35.75 138.5,35.3 138.64,35.16 139.59,35.16 139.72,35.29 139.72,35.98 139.87,36.13 140.24,36.13 140.43,35.94 140.43,35.4 140.64,35.19 141.13,35.19 142.9,33.41 143.57,32.74 162.51,32.74
DDR_B_CKE3: length 76.9
  TOP w0.089: CPU1.AT11 v2(178.52,38.74)
  TOP w0.165: JDIMM3.110 111.82,42.42 v2(112.66,41.59)
  IN4 w0.089: v2(178.52,38.74) 177.98,38.19 176.5,38.19 175.54,37.23 175.54,35.92 174.92,35.3 171.17,35.3 170.72,34.84 166.13,34.84 162.57,31.29 162.39,31.29
  IN4 w0.178: 162.39,31.29 142.97,31.29 140.96,33.31 138.42,33.31 136.9,34.83 131.03,34.83 130.55,35.31 123.38,35.31 123.27,35.41 120.63,35.41 116.36,39.69 116,39.69 115.28,40.4 113.85,40.4 v2(112.66,41.59)
DDR_B_CLK0: length 78.3
  TOP w0.089: CPU1.AM9 v2(177.22,42.39)
  IN4 w0.089: v2(177.22,42.39) 177.22,42.19 177.06,42.03 177.06,42.03 175.55,42.03 175.28,42.3 175.28,42.91 174.85,43.35 172.91,43.35 172.68,43.12 172.68,42.74 172.53,42.59 162.72,42.59 162.51,42.39 162.51,42.05 162.35,41.88 161.15,41.88 160.77,42.26 160.67,42.26
  IN4 w0.109: v2(113.36,49.76) 113.45,49.86 113.45,50.21 113.47,50.22 113.72,50.47 120.46,50.47 120.65,50.28 121.2,50.28 121.2,50.28 121.42,50.28 121.94,49.77 122.03,49.77 124.52,49.77 125.07,49.22 125.08,49.22 125.14,49.16 125.96,49.16 126.03,49.22 131.87,49.22 132.3,48.79 132.3,48.43 132.48,48.25 133.02,48.25 133.1,48.34 133.1,48.52 133.32,48.74 133.67,48.74 133.86,48.93 134.15,49.22 136.34,49.22 136.43,49.13 136.67,49.13 137.34,48.46 138.21,47.59 142.82,47.59 147.89,42.53 154.33,42.53 154.58,42.29 154.58,42.03 154.7,41.9 155.11,41.9 155.24,42.03 155.24,42.29 155.5,42.55 156.04,42.55 156.3,42.29 156.3,42.02 156.43,41.89 156.79,41.89 156.91,42.02 156.91,42.24 157.22,42.55 157.64,42.55 157.95,42.24 157.95,42.02 158.08,41.89 158.62,41.89 158.99,42.26 160.67,42.26
  BOTTOM w0.102: JDIMM4.137 111.62,49.17 111.72,49.27 111.85,49.27 112.08,49.5 112.08,50.1 112.29,50.31 113.41,50.31 113.53,50.19 113.53,49.94 v2(113.36,49.76)
DDR_B_CLK1: length 80.3
  TOP w0.089: v2(175.92,42.39) 175.5,42.39 175.39,42.29 175.39,42.14 CPU1.AM7
  IN4 w0.089: v2(175.92,42.39) 176.08,42.39 176.23,42.54 176.23,42.72 176.14,42.82 175.63,42.82 174.92,43.52 172.52,43.52 172.41,43.41 172.41,43.08 172.23,42.91 165.6,42.91 165.53,42.97
  IN4 w0.109: v2(116.08,50.94) 115.97,51.05 115.7,51.05 115.64,51.11 115.64,51.28 115.71,51.35 116.99,51.35 117.05,51.3 117.05,51.2 117.25,51 118.39,51 118.6,51.21 118.6,51.28 118.67,51.34 119.12,51.34 119.2,51.27 119.2,51.2 119.4,51 120.79,51 120.98,50.81 121.67,50.81 122.19,50.29 124.86,50.29 125.05,50.1 125.05,49.99 125.36,49.68 125.78,49.68 125.84,49.74 126.21,49.74 126.56,50.08 130.88,50.08 131.23,49.74 132.27,49.74 132.33,49.68 132.33,49.51 132.59,49.25 133.22,49.25 133.48,49.51 133.48,49.75 133.55,49.82 134.79,49.82 135.06,50.09 136.21,50.09 136.32,50.2 136.52,50.2 137.17,49.55 137.17,49.38 138.4,48.15 143.02,48.15 143.18,47.99 143.47,47.99 143.59,48.11 143.77,48.11 144.02,47.87 144.02,47.69 143.93,47.59 143.93,47.22 144.27,46.88 144.64,46.88 144.71,46.96 144.89,46.96 145.1,46.75 145.1,46.57 145.02,46.5 145.02,46.13 145.37,45.79 145.74,45.79 145.82,45.88 146,45.88 146.21,45.67 146.21,45.49 146.11,45.39 146.11,45.04 146.47,44.68 146.82,44.68 146.92,44.78 147.1,44.78 147.31,44.56 147.31,44.42 147.21,44.32 147.21,43.95 147.55,43.61 147.92,43.61 148.02,43.71 148.17,43.71 148.8,43.07 149.62,43.07 149.95,43.4 150.11,43.4 150.44,43.07 158.12,43.07 158.41,42.78 160.11,42.78 160.41,43.07 160.71,43.07 160.84,42.95 160.84,42.69 161.29,42.23 161.82,42.23 162.08,42.5 162.08,43.14 162.21,43.26 162.73,43.26 162.97,43.02 165.48,43.02 165.53,42.97
  BOTTOM w0.102: JDIMM4.138 118.01,49.43 117.89,49.55 117.7,49.55 117.25,49.99 117.12,49.99 116.92,50.2 116.92,50.6 117.1,50.78 117.1,51.09 117.01,51.18 117.01,51.5 117.09,51.58 117.09,51.73 116.56,52.26 116.34,52.26 116.2,52.11 116.2,51.87 115.96,51.63 115.78,51.63 115.64,51.49 115.64,51.07 115.77,50.94 v2(116.08,50.94)
DDR_B_CLK2: length 79
  TOP w0.089: CPU1.AM11 v2(178.52,42.39)
  TOP w0.102: JDIMM3.137 119.82,49.17 119.95,49.3 120.39,49.3 120.5,49.19 120.5,49.07 120.76,48.81 121.33,48.81 121.59,49.07 121.59,49.19 121.72,49.32 122.32,49.32 122.58,49.58 122.58,49.98 122.32,50.24 121.48,50.24 121.35,50.36 121.35,50.55 121.48,50.68 122.43,50.68 122.64,50.89 122.64,50.98 123.01,51.35 v2(123.01,51.45)
  IN4 w0.089: 165.33,43.89 165.34,43.89 165.35,43.88 165.74,43.88 165.97,43.65 171.43,43.65 171.51,43.72 171.51,43.94 171.69,44.12 175.16,44.12 175.85,43.43 176.58,43.43 177.06,42.95 178.18,42.95 178.37,42.76 178.37,42.55 v2(178.52,42.39)
  IN4 w0.109: v2(123.01,51.45) 123.19,51.26 125.4,51.26 125.69,50.97 126.08,50.97 126.18,51.07 126.18,51.19 126.43,51.44 131.31,51.44 131.56,51.19 131.56,50.85 131.69,50.72 132.16,50.72 132.29,50.85 132.29,51.11 132.55,51.37 133.13,51.37 133.39,51.11 133.39,50.95 133.55,50.79 133.79,50.79 133.94,50.95 133.94,51.11 134.2,51.37 135.18,51.37 135.48,51.06 135.79,51.06 136.09,51.37 136.73,51.37 136.86,51.24 137.23,50.87 137.79,50.31 138.98,49.12 144.15,49.12 144.63,48.64 144.78,48.64 145.27,49.13 145.64,49.13 145.98,48.79 145.98,48.42 145.5,47.94 145.5,47.76 145.71,47.55 145.88,47.55 146.43,48.1 146.8,48.1 147.14,47.76 147.14,47.39 146.6,46.85 146.6,46.67 146.81,46.46 146.99,46.46 147.53,47 147.9,47 148.24,46.66 148.24,46.29 147.7,45.76 147.7,45.58 147.91,45.37 148.09,45.37 148.63,45.91 149,45.91 149.34,45.57 149.34,45.2 148.81,44.67 148.81,44.49 149.14,44.17 149.32,44.17 149.84,44.69 150.22,44.69 150.85,44.05 163.69,44.05 163.85,43.89 165.33,43.89
DDR_B_CLK3: length 80.4
  TOP w0.089: CPU1.AJ10 v2(177.87,44.22)
  TOP w0.102: JDIMM3.138 111.47,49.43 111.59,49.54 111.83,49.54 112.07,49.78 112.07,50.3 112.4,50.63 112.4,51.31 112.6,51.52 113.55,51.52 113.7,51.36 113.7,51.23 v2(113.41,50.94)
  IN4 w0.089: 164.28,44.53 164.29,44.53 164.3,44.52 165.5,44.52 165.67,44.7 171.36,44.7 171.55,44.51 175.32,44.51 175.97,43.86 178.13,43.86 178.21,43.94 178.21,44.04 178.03,44.22 v2(177.87,44.22)
  IN4 w0.109: 164.28,44.53 164.05,44.53 163.77,44.81 151.17,44.81 146.11,49.88 139.27,49.88 137.04,52.12 131.72,52.12 131.65,52.19 126.12,52.19 126.01,52.09 119.78,52.09 119.54,52.33 115.17,52.33 114.99,52.51 111.76,52.51 111.5,52.25 111.5,51.76 111.76,51.5 113.55,51.5 113.69,51.36 113.69,51.15 113.48,50.94 v2(113.41,50.94)
DDR_B_CLK#0: length 78.3
  TOP w0.089: CPU1.AN9 v2(177.22,41.48)
  IN4 w0.089: 160.67,42.03 160.71,42.03 161.07,41.67 162.43,41.67 162.72,41.96 162.72,42.3 162.81,42.39 172.62,42.39 172.89,42.65 172.89,43.03 172.99,43.14 174.76,43.14 175.08,42.82 175.08,42.21 175.44,41.85 176.86,41.85 v2(177.22,41.48)
  IN4 w0.109: v2(113.99,49.76) 113.69,50.05 113.69,50.13 113.81,50.25 120.37,50.25 120.56,50.05 121.1,50.05 121.33,50.05 121.84,49.54 122.03,49.54 124.43,49.54 124.97,48.99 124.99,48.99 125.05,48.93 126.06,48.93 126.12,48.99 131.77,48.99 132.07,48.69 132.07,48.34 132.38,48.03 133.11,48.03 133.33,48.25 133.33,48.42 133.42,48.51 133.76,48.51 134.09,48.84 134.09,48.84 134.24,48.99 136.24,48.99 136.34,48.9 136.58,48.9 138.11,47.37 142.73,47.37 147.79,42.3 154.24,42.3 154.35,42.19 154.35,41.94 154.61,41.68 155.2,41.68 155.47,41.94 155.47,42.2 155.59,42.32 155.95,42.32 156.07,42.2 156.07,41.92 156.34,41.66 156.88,41.66 157.14,41.92 157.14,42.15 157.32,42.32 157.55,42.32 157.73,42.15 157.73,41.92 157.99,41.66 158.72,41.66 159.08,42.03 160.67,42.03
  BOTTOM w0.102: v2(113.99,49.76) 113.78,49.97 113.78,50.27 113.5,50.54 112.2,50.54 111.85,50.2 111.85,49.6 111.76,49.5 111.64,49.5 111.47,49.68 JDIMM4.139
DDR_B_CLK#1: length 80.3
  TOP w0.089: v2(176.57,42.39) 176.57,42.12 176.39,41.94 CPU1.AM8
  IN4 w0.089: v2(176.57,42.39) 176.44,42.52 176.44,42.81 176.23,43.02 175.71,43.02 175,43.73 172.43,43.73 172.2,43.5 172.2,43.17 172.15,43.12 166.06,43.12
  IN4 w0.109: 166.06,43.12 165.71,43.12 165.58,43.25 163.07,43.25 162.82,43.49 162.11,43.49 161.85,43.23 161.85,42.59 161.73,42.46 161.38,42.46 161.07,42.78 161.07,43.04 160.8,43.3 160.31,43.3 160.02,43.01 158.51,43.01 158.21,43.3 150.54,43.3 150.21,43.63 149.85,43.63 149.52,43.3 148.9,43.3 148.27,43.94 147.92,43.94 147.82,43.83 147.64,43.83 147.43,44.04 147.43,44.22 147.54,44.33 147.54,44.65 147.19,45 146.82,45 146.72,44.9 146.57,44.9 146.33,45.14 146.33,45.29 146.44,45.4 146.44,45.76 146.1,46.11 145.73,46.11 145.64,46.02 145.46,46.02 145.25,46.22 145.25,46.4 145.32,46.47 145.32,46.84 144.98,47.18 144.61,47.18 144.54,47.11 144.36,47.11 144.15,47.32 144.15,47.5 144.25,47.59 144.25,47.96 143.87,48.34 143.5,48.34 143.37,48.22 143.27,48.22 143.12,48.37 138.5,48.37 137.4,49.47 137.4,49.64 136.62,50.43 136.22,50.43 136.12,50.32 134.97,50.32 134.69,50.05 133.46,50.05 133.25,49.84 133.25,49.6 133.13,49.47 132.68,49.47 132.55,49.6 132.55,49.78 132.36,49.97 131.32,49.97 130.98,50.31 126.46,50.31 126.12,49.96 125.75,49.96 125.69,49.91 125.45,49.91 125.28,50.08 125.28,50.2 124.96,50.52 122.29,50.52 121.77,51.04 121.08,51.04 120.89,51.23 119.49,51.23 119.43,51.29 119.43,51.36 119.22,51.57 118.57,51.57 118.37,51.37 118.37,51.31 118.29,51.23 117.35,51.23 117.28,51.3 117.28,51.39 117.09,51.58 115.61,51.58 115.41,51.38 115.41,51.09 v2(115.26,50.94)
  BOTTOM w0.102: v2(115.26,50.94) 115.42,51.1 115.42,51.59 115.69,51.86 115.86,51.86 115.97,51.97 115.97,52.21 116.25,52.48 116.65,52.48 117.31,51.82 117.31,51.48 117.24,51.4 117.24,51.28 117.33,51.19 117.33,50.68 117.15,50.5 117.15,50.29 117.22,50.22 117.34,50.22 117.76,49.81 117.85,49.81 117.97,49.92 JDIMM4.140
DDR_B_CLK#2: length 78.9
  TOP w0.089: CPU1.AM10 v2(177.87,42.39)
  TOP w0.102: JDIMM3.139 119.82,49.68 119.97,49.53 120.49,49.53 120.73,49.28 120.73,49.17 120.86,49.04 121.24,49.04 121.37,49.17 121.37,49.29 121.63,49.55 122.23,49.55 122.36,49.68 122.36,49.88 122.23,50.01 121.39,50.01 121.12,50.27 121.12,50.65 121.39,50.91 122.34,50.91 122.41,50.98 122.41,51.11 122.39,51.13 v2(122.39,51.4)
  IN4 w0.089: v2(177.87,42.39) 178.04,42.39 178.16,42.52 178.16,42.67 178.08,42.76 176.96,42.76 176.5,43.22 175.77,43.22 175.08,43.91 171.78,43.91 171.71,43.85 171.71,43.64 171.52,43.44 165.88,43.44 165.65,43.67 165.35,43.67 165.34,43.66 165.33,43.66
  IN4 w0.109: 165.33,43.66 163.76,43.66 163.6,43.82 150.76,43.82 150.13,44.46 149.93,44.46 149.41,43.94 149.04,43.94 148.58,44.4 148.58,44.77 149.11,45.3 149.11,45.47 148.91,45.68 148.73,45.68 148.19,45.14 147.82,45.14 147.48,45.48 147.48,45.85 148.01,46.39 148.01,46.57 147.8,46.77 147.62,46.77 147.08,46.23 146.71,46.23 146.37,46.57 146.37,46.94 146.91,47.48 146.91,47.66 146.71,47.87 146.53,47.87 145.98,47.32 145.61,47.32 145.27,47.66 145.27,48.03 145.75,48.52 145.75,48.7 145.55,48.9 145.37,48.9 144.88,48.41 144.53,48.41 144.06,48.89 138.89,48.89 137,50.77 136.64,51.14 136.19,51.14 135.88,50.83 135.39,50.83 135.08,51.14 134.3,51.14 134.17,51.01 134.17,50.85 133.88,50.57 133.45,50.57 133.17,50.85 133.17,51.01 133.04,51.14 132.64,51.14 132.52,51.01 132.52,50.75 132.26,50.49 131.6,50.49 131.34,50.75 131.34,51.09 131.21,51.21 126.53,51.21 126.41,51.09 126.41,50.97 126.18,50.74 125.59,50.74 125.3,51.04 122.75,51.04 v2(122.39,51.4)
DDR_B_CLK#3: length 80.4
  TOP w0.089: CPU1.AJ11 v2(178.52,44.22)
  TOP w0.102: v2(114.07,50.94) 113.93,51.08 113.93,51.46 113.64,51.74 112.51,51.74 112.17,51.41 112.17,50.72 111.84,50.39 111.84,49.87 111.73,49.77 111.61,49.77 111.45,49.92 JDIMM3.140
  IN4 w0.089: v2(178.52,44.22) 178.4,44.1 178.4,43.86 178.22,43.68 175.86,43.68 175.23,44.3 171.46,44.3 171.28,44.49 165.76,44.49 165.59,44.32 164.3,44.32 164.29,44.31 164.28,44.31
  IN4 w0.109: 164.28,44.31 163.95,44.31 163.68,44.58 151.08,44.58 146.01,49.65 139.18,49.65 136.94,51.89 131.63,51.89 131.55,51.96 126.21,51.96 126.11,51.86 119.68,51.86 119.44,52.1 115.07,52.1 114.9,52.28 111.85,52.28 111.73,52.15 111.73,51.86 111.85,51.73 113.65,51.73 113.92,51.46 113.92,51.09 v2(114.07,50.94)
DDR_B_CS#0: length 75.9
  TOP w0.089: CPU1.AF11 v2(178.52,46.97)
  IN4 w0.089: v2(178.52,46.97) 177.98,46.42 176.5,46.42 176.33,46.25 175.56,46.25 175.3,46.5 171.76,46.5 171.32,46.94 165.88,46.94 163.13,49.69 162.19,49.69
  IN4 w0.178: v2(114.01,54.71) 114.01,55.75 115.19,56.94 120.38,56.94 120.84,57.4 124.91,57.4 125.58,58.07 133.77,58.07 134.71,57.13 138.46,57.13 140.48,55.12 148.9,55.12 154.32,49.69 162.19,49.69
  BOTTOM w0.165: v2(114.01,54.71) 113.47,54.17 JDIMM4.149
DDR_B_CS#1: length 79.1
  TOP w0.089: v2(175.99,47.88) 175.65,47.42 CPU1.AE7
  IN4 w0.089: 164.57,50.56 167.04,48.09 171.98,48.09 172.29,47.78 172.41,47.66 175.61,47.66 175.83,47.88 v2(175.99,47.88)
  IN4 w0.178: v2(114.92,59.01) 114.71,59.22 114.71,59.42 114.85,59.56 117.11,59.56 117.24,59.69 117.24,60.22 117.44,60.42 117.76,60.42 117.96,60.22 117.96,59.65 118.09,59.52 118.72,59.52 119.1,59.91 119.1,60.15 118.99,60.27 118.99,60.46 119.46,60.92 119.73,60.92 119.99,60.66 120.43,60.66 120.69,60.92 123.74,60.92 124.45,61.63 125.14,61.63 125.35,61.84 125.35,62.53 125.85,63.04 126.27,63.04 126.68,62.63 137.67,62.63 138.38,61.92 138.38,61.27 138.62,61.03 139.27,61.03 142.08,58.22 150.84,58.22 156.27,52.8 162.33,52.8 164.57,50.56
  BOTTOM w0.165: JDIMM4.157 111.7,56.17 111.97,56.45 111.97,57.08 112.89,58 113.91,58 v2(114.92,59.01)
DDR_B_CS#2: length 79.7
  TOP w0.089: CPU1.AF10 v2(177.87,46.97)
  TOP w0.165: JDIMM3.149 117.59,54.17 117.24,54.53 117.24,54.84 116.83,55.25 114.35,55.25 114.27,55.17 113.8,55.17 113.38,54.76 v2(113.38,54.71)
  IN4 w0.089: 163.19,49.97 166,47.16 171.61,47.16 172.03,46.74 175.31,46.74 175.63,46.43 176.25,46.43 176.43,46.6 177.5,46.6 v2(177.87,46.97)
  IN4 w0.178: 163.19,49.97 162.98,50.17 154.52,50.17 149.1,55.6 140.68,55.6 138.66,57.62 137,57.62 136.58,58.03 134.67,58.03 134.15,58.56 125.38,58.56 124.72,57.89 120.65,57.89 120.18,57.42 114.99,57.42 113.91,56.33 113.25,56.33 113.01,56.09 113.01,54.82 113.12,54.71 v2(113.38,54.71)
DDR_B_CS#3: length 81.4
  TOP w0.089: CPU1.AE10 v2(177.87,47.88)
  TOP w0.102: 121.5,57.24 121.5,57.54 121.51,57.55 121.51,58.43 121.37,58.57 121.37,59.13 121.68,59.44 121.68,60.06 121.61,60.14 v2(121.61,60.41)
  TOP w0.165: JDIMM3.157 121.31,56.17 121.5,56.36 121.5,57.24
  IN4 w0.089: 164.3,50.45 166.84,47.91 171.91,47.91 172.11,47.7 172.34,47.48 175.7,47.48 175.73,47.52 177.15,47.52 177.34,47.33 177.97,47.33 178.17,47.53 178.17,47.72 178.02,47.88 v2(177.87,47.88)
  IN4 w0.178: 164.3,50.45 162.44,52.32 156.07,52.32 155.84,52.55 155.66,52.55 155.51,52.41 155.32,52.41 155,52.73 155,52.91 155.15,53.06 155.15,53.24 153.42,54.97 152.82,54.97 152.55,55.23 152.55,55.84 150.64,57.74 141.52,57.74 141.1,58.16 141.1,58.52 140.74,58.88 140.38,58.88 139.98,59.27 139.98,59.63 139.59,60.03 137.62,60.03 137.47,60.18 137.24,60.18 137.08,60.35 137.08,60.83 137.23,60.98 137.74,60.98 137.9,61.15 137.9,61.48 137.74,61.64 137.23,61.64 137.1,61.77 137.1,62.02 136.97,62.15 136.44,62.15 136.31,62.02 136.31,61.07 136.07,60.83 135.69,60.83 135.56,60.95 135.56,61.49 135.44,61.62 134.66,61.62 134.54,61.74 134.54,62.02 134.41,62.15 134.04,62.15 133.91,62.02 133.91,61.3 133.79,61.17 133.34,61.17 133.21,61.3 133.21,62.02 133.09,62.15 132.46,62.15 132.33,62.02 132.33,61.82 132.2,61.69 131.75,61.69 131.63,61.82 131.63,62.02 131.5,62.15 131.02,62.15 130.89,62.02 130.89,61.82 130.76,61.69 127.37,61.69 127.25,61.82 127.25,62.02 127.12,62.15 126.61,62.15 126.48,62.02 126.48,61.82 126.36,61.69 125.87,61.69 125.75,61.57 125.75,60.87 125.62,60.74 125.26,60.74 125.14,60.87 125.14,60.98 125.01,61.11 124.63,61.11 124.5,60.98 124.5,60.78 124.38,60.65 124.15,60.65 123.94,60.44 121.64,60.44 v2(121.61,60.41)
DDR_B_D0: length 86.1
  TOP w0.089: CPU1.BT11 178.14,23.42 178.03,23.31 178.03,23.06 177.28,22.32 177.28,21.91 177.5,21.69 v2(177.68,21.52)
  TOP w0.14: JDIMM3.8 112.82,16.93 v2(113.31,16.43)
  IN4 w0.147: v2(113.31,16.43) 113.77,15.97 115.18,15.97 115.91,15.24 119.16,15.24 120.37,14.03 125.81,14.03 127.53,12.31 130.97,12.31 131.28,12.62 131.55,12.62 131.86,12.31 132.23,12.31 132.54,12.62 132.8,12.62 133.11,12.31 133.34,12.31 133.65,12.62 133.92,12.62 134.23,12.31 134.51,12.31 134.66,12.46 134.82,12.62 135.11,12.62 135.42,12.31 135.69,12.31 136,12.62 136.34,12.62 136.65,12.31 136.97,12.31 137.28,12.62 137.67,12.62 137.98,12.31 138.52,12.31 138.83,12.62 139.53,12.62 139.84,12.31 140.63,12.31 140.94,12.62 141.44,12.62 141.75,12.31 142.2,12.31 142.54,12.64 154.26,12.64 155.07,11.84 162.73,11.84 164.42,10.15 171.37,10.15 175.09,13.87 175.09,18.93 177.68,21.52 v2(177.68,21.52)
  BOTTOM w0.14: JDIMM4.7 111.58,16.68 111.83,16.93 113.07,16.93 113.31,16.69 v2(113.31,16.43)
DDR_B_D1: length 87.1
  TOP w0.089: CPU1.BR11 178.14,24.5 177.98,24.35 177.98,24.35 177.85,24.21 177.85,23.16 177.07,22.38 177.07,21.48 177.27,21.28
  TOP w0.14: 177.27,21.28 v2(177.68,20.88) ; v2(116.33,14.77) 117.56,16 117.56,16.53 117.71,16.68 JDIMM3.7
  IN4 w0.147: v2(177.68,20.88) 177.67,20.88 175.46,18.68 175.46,13.72 171.52,9.77 164.27,9.77 162.63,11.41 154.68,11.41 154.54,11.56 154.54,11.84 154.41,11.97 154.07,11.97 153.95,11.84 153.95,11.51 153.82,11.38 153.48,11.38 153.36,11.51 153.36,11.66 153.23,11.79 152.89,11.79 152.77,11.66 152.77,11.58 152.64,11.45 151.89,11.45 151.76,11.58 151.76,12.14 151.63,12.27 151.3,12.27 151.17,12.14 151.17,11.6 151.04,11.48 150.48,11.48 150.35,11.6 150.35,11.74 149.88,12.21 149.37,12.21 149.09,11.93 148.56,11.93 148.41,12.08 148.41,12.1 148.27,12.25 147.97,12.25 147.83,12.1 147.83,12.08 147.68,11.93 147.38,11.93 147.24,12.08 147.24,12.1 147.09,12.25 146.79,12.25 146.65,12.1 146.65,12.08 146.5,11.93 146.2,11.93 146.06,12.08 146.06,12.1 145.91,12.25 145.62,12.25 145.47,12.1 145.47,12.08 145.32,11.93 145.03,11.93 144.88,12.08 144.88,12.1 144.73,12.25 144.44,12.25 144.29,12.1 144.29,12.08 144.14,11.93 143.85,11.93 143.7,12.08 143.7,12.1 143.55,12.25 143.26,12.25 143.11,12.1 143.11,12.08 142.96,11.93 127.38,11.93 126.4,12.91 122.82,12.91 122.08,13.65 120.22,13.65 119.01,14.87 116.43,14.87 v2(116.33,14.77)
  BOTTOM w0.14: v2(116.33,14.77) 116.8,15.23 116.8,15.69 118.03,16.93 JDIMM4.8
DDR_B_D2: length 86.8
  TOP w0.089: 175.54,21.28 175.54,22.16 176.33,22.95 CPU1.BT8
  TOP w0.14: v2(113.4,17.89) 113.4,18.34 112.82,18.93 JDIMM3.16 ; 175.54,21.28 v2(175.54,21.19)
  IN4 w0.147: v2(175.54,21.19) 175.13,21.19 173.93,20 173.93,14.46 170.78,11.31 165.88,11.31 163.38,13.8 139.14,13.8 139,13.95 139,14.29 138.87,14.42 138.39,14.42 138.26,14.29 138.26,13.95 138.11,13.8 136.17,13.8 136.02,13.95 136.02,14.22 135.89,14.35 135.41,14.35 135.28,14.22 135.28,13.95 135.14,13.8 134,13.8 133.85,13.95 133.85,14.41 133.7,14.56 133.26,14.56 133.11,14.41 133.11,13.95 132.97,13.8 132.52,13.8 132.38,13.95 132.38,14.41 132.23,14.56 131.79,14.56 131.64,14.41 131.64,13.95 131.49,13.8 130.73,13.8 129.72,14.8 129.25,15.28 127.82,15.28 127.73,15.19 120.85,15.19 119.17,16.87 116.23,16.87 116.04,17.07 114.22,17.07 v2(113.4,17.89)
  BOTTOM w0.14: v2(113.4,17.89) 113.4,18.59 112.82,19.17 JDIMM4.17
DDR_B_D3: length 88.5
  TOP w0.089: CPU1.BR8 176.56,24.36 176.63,24.3 176.63,23.96 176.56,23.9 176.56,22.92 175.93,22.29 v2(175.93,21.63)
  TOP w0.14: JDIMM3.21 117.03,20.17 v2(114.74,17.88)
  IN4 w0.147: v2(114.74,17.88) 115.17,17.45 116.99,17.45 117.19,17.25 119.32,17.25 121.01,15.56 127.58,15.56 127.7,15.69 131.34,15.69 131.98,15.06 132.24,15.06 132.39,15.2 132.39,15.54 132.54,15.69 132.83,15.69 132.98,15.54 132.98,15.2 133.13,15.06 133.42,15.06 133.57,15.2 133.57,15.54 133.71,15.69 134.01,15.69 134.16,15.54 134.16,15.2 134.3,15.06 134.6,15.06 134.97,15.43 135.35,15.43 135.5,15.29 135.5,14.87 135.65,14.73 135.94,14.73 136.09,14.87 136.09,15.29 136.24,15.43 136.53,15.43 136.68,15.29 136.68,14.87 136.82,14.73 137.12,14.73 137.44,15.04 139.23,15.04 140.1,14.18 163.54,14.18 166.03,11.69 170.53,11.69 173.55,14.71 173.55,20.15 175.03,21.63 v2(175.93,21.63)
  BOTTOM w0.14: JDIMM4.20 117.69,19.93 116.42,18.65 115.01,18.65 114.74,18.38 v2(114.74,17.88)
DDR_B_D4: length 85.8
  TOP w0.089: v2(178.12,22.6) 178.2,22.68 178.2,23.24 178.43,23.46 178.43,25.09 CPU1.BP11
  TOP w0.14: JDIMM3.3 117.87,15.68 117.4,15.21 v2(117.4,14.31)
  IN4 w0.147: v2(117.4,14.31) 117.56,14.46 118.88,14.46 120.06,13.28 121.92,13.28 122.67,12.53 126.24,12.53 127.45,11.33 142.48,11.33 142.8,11.01 143.11,11.01 143.26,11.15 143.26,11.3 143.4,11.45 143.7,11.45 143.85,11.3 143.85,11.15 143.99,11.01 144.29,11.01 144.44,11.15 144.44,11.3 144.58,11.45 144.88,11.45 145.02,11.3 145.02,11.15 145.17,11.01 145.47,11.01 145.61,11.15 145.61,11.3 145.76,11.45 146.06,11.45 146.2,11.3 146.2,11.15 146.35,11.01 146.64,11.01 146.79,11.15 146.79,11.3 146.94,11.45 147.23,11.45 147.38,11.3 147.38,11.15 147.53,11.01 147.82,11.01 147.97,11.15 147.97,11.3 148.12,11.45 148.41,11.45 148.56,11.3 148.56,11.15 148.71,11.01 149,11.01 149.15,11.15 149.15,11.4 149.28,11.53 149.61,11.53 149.74,11.4 149.74,11.15 149.89,11.01 162.5,11.01 163.12,10.39 163.12,10.18 162.75,9.82 162.75,9.64 162.98,9.4 163.16,9.4 163.53,9.77 163.74,9.77 164.11,9.4 171.68,9.4 172.46,10.18 175.84,13.56 175.84,18.53 176.77,19.45 177.45,19.45 178.12,20.13 v2(178.12,22.6)
  BOTTOM w0.14: JDIMM4.4 117.71,15.93 117.4,15.62 v2(117.4,14.31)
DDR_B_D5: length 86.2
  TOP w0.089: CPU1.BN11 178.14,25.8 178.62,25.31 178.62,22.48
  TOP w0.14: v2(112.64,15.69) 112.4,15.93 JDIMM3.4 ; v2(177.02,18.94) 177.02,19.07 178.08,20.13 178.08,21.23 178.62,21.77 178.62,22.48
  IN4 w0.147: v2(112.64,15.69) 112.76,15.56 114.93,15.56 116.89,13.6 119.21,13.6 119.91,12.9 121.77,12.9 122.51,12.16 126.09,12.16 127.3,10.95 142.31,10.95 142.73,10.53 157.74,10.53 159.25,9.02 171.83,9.02 176.22,13.41 176.22,18.14 v2(177.02,18.94)
  BOTTOM w0.14: JDIMM4.3 112.63,15.68 v2(112.64,15.69)
DDR_B_D6: length 86.5
  TOP w0.089: CPU1.BP8 176.85,25.09 176.85,23.24 176.76,23.14 176.76,22.58 v2(176.7,22.53)
  TOP w0.14: v2(116.11,17.88) 117.41,19.17 JDIMM3.17
  IN4 w0.147: v2(176.7,22.53) 176.61,22.62 175.49,22.62 173.18,20.31 173.18,20.02 173.03,19.87 172.74,19.87 172.62,19.75 172.62,19.41 172.74,19.29 173.03,19.29 173.18,19.14 173.18,18.76 173.03,18.61 172.6,18.61 172.47,18.49 172.47,18.15 172.6,18.02 173.03,18.02 173.18,17.88 173.18,14.9 170.34,12.06 166.19,12.06 164.55,13.7 164.55,14.41 164.4,14.55 145.89,14.55 145.74,14.7 145.74,15.18 145.59,15.32 145.3,15.32 145.15,15.18 145.15,14.7 145,14.55 142.98,14.55 142.83,14.7 142.83,15.24 142.69,15.39 142.39,15.39 142.25,15.24 142.25,14.7 142.1,14.55 141.8,14.55 141.66,14.7 141.66,15.24 141.51,15.39 141.21,15.39 141.07,15.24 141.07,14.7 140.92,14.55 140.63,14.55 139.37,15.81 134.8,15.81 134.54,16.07 124.19,16.07 123.8,16.45 120.65,16.45 119.48,17.63 117.35,17.63 117.09,17.88 v2(116.11,17.88)
  BOTTOM w0.14: JDIMM4.16 117.19,18.93 117.02,18.76 117.02,18.09 116.81,17.88 v2(116.11,17.88)
DDR_B_D7: length 85.4
  TOP w0.089: CPU1.BN8 176.56,25.94 177.06,25.44 177.06,23.38 177.15,23.29 v2(177.15,22.98)
  TOP w0.14: JDIMM3.20 112.46,19.93 v2(112.71,19.68)
  IN4 w0.147: v2(177.15,22.98) 175.31,22.98 172.18,19.84 171.97,19.84 171.91,19.91 171.73,19.91 171.49,19.68 171.49,19.5 171.56,19.43 171.56,19.22 171.28,18.94 166.6,18.94 164.27,16.61 164.27,15.49 163.72,14.94 160.75,14.94 160.6,15.09 160.6,15.37 160.45,15.51 160.01,15.51 159.86,15.37 159.86,15.09 159.72,14.94 159.27,14.94 159.13,15.09 159.13,15.51 159,15.64 158.52,15.64 158.39,15.51 158.39,15.09 158.24,14.94 153.75,14.94 153.6,15.09 153.6,15.63 153.46,15.78 153.01,15.78 152.87,15.63 152.87,15.09 152.72,14.94 150.85,14.94 150.71,15.09 150.71,15.53 150.56,15.68 150.12,15.68 149.97,15.53 149.97,15.09 149.82,14.94 149.38,14.94 149.23,15.09 149.23,15.53 149.08,15.68 148.64,15.68 148.5,15.53 148.5,15.09 148.35,14.94 146.55,14.94 146.18,15.31 146.18,15.72 146.05,15.85 144.36,15.85 144.21,15.7 144.21,15.34 144.07,15.2 143.62,15.2 143.48,15.34 143.48,15.7 143.33,15.85 140.45,15.85 140.1,16.2 136.24,16.2 135.48,16.96 123.22,16.96 123.09,16.83 120.81,16.83 119.63,18 117.5,18 117.07,18.44 113.95,18.44 v2(112.71,19.68)
  BOTTOM w0.14: v2(112.71,19.68) 112.02,19.68 111.52,20.17 JDIMM4.21
DDR_B_D8: length 81
  TOP w0.089: CPU1.BL12 178.86,27.34 v2(178.53,27.01)
  TOP w0.14: v2(113.98,19.7) 113.3,20.38 112.82,20.38 112.28,20.93 JDIMM3.24
  IN4 w0.089: 171.87,20.93 174.2,23.27 174.2,23.58 177.09,26.46 177.29,26.46 177.84,27.01 v2(178.53,27.01)
  IN4 w0.147: 171.87,20.93 170.33,19.39 165.54,19.39 165.07,18.92 165.07,18.74 165.26,18.55 165.26,18.37 164.92,18.03 164.74,18.03 164.61,18.16 164.43,18.16 164.09,17.81 164.09,17.63 164.12,17.61 164.12,17.4 163.56,16.84 161.41,16.84 160.88,16.3 140.75,16.3 140.39,16.66 136.55,16.66 135.8,17.42 123.35,17.42 122.85,17.91 120.49,17.91 119.94,18.45 117.69,18.45 117.25,18.89 114.78,18.89 v2(113.98,19.7)
  BOTTOM w0.14: v2(113.98,19.7) 113.98,20.55 113.81,20.72 113.39,20.72 112.99,20.32 112.56,20.32 112.37,20.51 112.37,20.8 112,21.17 JDIMM4.25
DDR_B_D9: length 82.9
  TOP w0.089: CPU1.BL11 v2(178.52,27.81)
  TOP w0.14: JDIMM3.29 117.59,22.17 116.38,20.97 115.88,20.97 v2(114.61,19.7)
  IN4 w0.089: 171.87,21.47 173.4,22.99 173.4,23.56 173.76,23.92 174.29,23.92 177.02,26.66 177.24,26.66 177.87,27.29 178,27.29 v2(178.52,27.81)
  IN4 w0.147: v2(114.61,19.7) 115.04,19.27 117.41,19.27 117.85,18.83 120.1,18.83 120.64,18.29 125.7,18.29 125.78,18.37 130.37,18.37 130.44,18.29 136.13,18.29 137.2,17.22 140.71,17.22 141.02,16.9 160.34,16.9 160.67,17.24 162.04,17.24 162.66,17.86 162.87,17.86 163,17.73 163.18,17.73 163.52,18.07 163.52,18.25 163.39,18.38 163.39,18.59 164.57,19.77 170.17,19.77 171.87,21.47
  BOTTOM w0.14: v2(114.61,19.7) 114.61,20.26 114.79,20.44 115.25,20.44 115.5,20.19 116.13,20.19 116.38,20.44 116.88,20.44 117.26,20.82 117.26,21.97 117.42,22.12 117.77,22.12 117.96,21.93 JDIMM4.28
DDR_B_D10: length 80.7
  TOP w0.089: CPU1.BL8 v2(176.96,27.01)
  TOP w0.14: v2(115.89,19.71) 117.35,21.17 JDIMM3.25
  IN4 w0.089: v2(176.96,27.01) 176.73,27.01 175.81,26.09 175.81,25.75 174.2,24.14 172.4,24.14 171.67,23.41
  IN4 w0.147: v2(115.89,19.71) 117.5,19.71 118,19.21 120.26,19.21 120.79,18.67 125.52,18.67 125.63,18.78 130.65,18.78 130.76,18.67 136.74,18.67 137.76,17.65 138.38,17.65 138.53,17.79 138.53,17.93 138.68,18.08 139.12,18.08 139.27,17.93 139.27,17.79 139.41,17.65 139.86,17.65 140,17.79 140,17.93 140.15,18.08 140.59,18.08 140.74,17.93 140.74,17.79 140.89,17.65 141.33,17.65 141.48,17.79 141.48,17.93 141.62,18.08 142.07,18.08 142.21,17.93 142.21,17.79 142.36,17.65 142.8,17.65 142.95,17.79 142.95,17.93 143.1,18.08 143.54,18.08 143.69,17.93 143.69,17.79 143.83,17.65 144.28,17.65 144.42,17.79 144.42,17.93 144.57,18.08 145.01,18.08 145.16,17.93 145.16,17.79 145.31,17.65 157.13,17.65 157.27,17.79 157.27,18.22 157.4,18.35 157.88,18.35 158.01,18.22 158.01,17.79 158.16,17.65 158.6,17.65 158.75,17.79 158.75,18.21 158.87,18.33 159.36,18.33 159.48,18.21 159.48,17.41 159.61,17.28 160.09,17.28 160.22,17.41 160.22,17.87 160.37,18.02 160.81,18.02 160.96,17.87 160.96,17.79 161.1,17.65 161.45,17.65 163.94,20.14 168.4,20.14 171.67,23.41
  BOTTOM w0.14: v2(115.89,19.71) 115.89,19.11 116.08,18.92 116.31,18.92 116.95,19.57 116.95,20.05 117.82,20.93 JDIMM4.24
DDR_B_D11: length 82.1
  TOP w0.089: CPU1.BJ8 v2(176.57,28.68)
  TOP w0.14: v2(114.29,23.07) 114.29,23.76 114.04,24.01 112.36,24.01 111.95,24.42 JDIMM3.38
  IN4 w0.089: 165.14,22.44 166.49,22.44 166.9,22.03 167.74,22.03 171.4,25.68 171.86,25.68 173.41,27.23 174.67,27.23 175.61,28.17 176.07,28.17 v2(176.57,28.68)
  IN4 w0.147: v2(114.29,23.07) 114.84,22.52 118.14,22.52 118.65,22.01 124.27,22.01 124.5,22.24 134.9,22.24 135.23,21.92 145.92,21.92 146.07,22.06 146.07,22.31 146.2,22.44 146.68,22.44 146.81,22.31 146.81,22.04 146.93,21.92 147.42,21.92 147.54,22.04 147.54,22.31 147.67,22.44 148.15,22.44 148.28,22.31 148.28,22.04 148.41,21.92 148.89,21.92 149.02,22.04 149.02,22.31 149.14,22.44 149.63,22.44 149.75,22.31 149.75,22.04 149.88,21.92 150.36,21.92 150.49,22.04 150.49,22.31 150.62,22.44 151.1,22.44 151.23,22.31 151.23,22.06 151.37,21.92 151.82,21.92 151.96,22.06 151.96,22.31 152.09,22.44 152.57,22.44 152.7,22.31 152.7,22.06 152.85,21.92 153.29,21.92 153.44,22.06 153.44,22.31 153.56,22.44 154.05,22.44 154.17,22.31 154.17,22.06 154.32,21.92 154.76,21.92 154.91,22.06 154.91,22.25 155.04,22.37 155.52,22.37 155.65,22.25 155.65,22.06 155.79,21.92 157.7,21.92 158.22,22.44 165.14,22.44
  BOTTOM w0.14: JDIMM4.37 114.81,24.17 114.95,24.03 114.95,23.66 114.83,23.54 114.45,23.54 114.29,23.38 v2(114.29,23.07)
DDR_B_D12: length 81.9
  TOP w0.089: CPU1.BJ11 v2(177.87,28.68)
  TOP w0.14: JDIMM3.37 117.17,24.17 116.79,23.79 116.79,22.05 v2(116.16,21.42)
  IN4 w0.089: 165.1,21.68 166.07,21.68 166.07,21.67 167.99,21.67 171.5,25.19 172.3,25.19 173.27,26.16 174.18,26.16 175.84,27.82 176.68,27.82 177.05,28.19 177.39,28.19 v2(177.87,28.68)
  IN4 w0.147: 165.1,21.68 159.77,21.68 159.12,21.03 149.94,21.03 149.79,20.88 149.79,20.58 149.56,20.35 149.18,20.35 149.05,20.48 149.05,20.88 148.9,21.03 148.46,21.03 148.32,20.88 148.32,20.45 148.19,20.33 147.71,20.33 147.58,20.45 147.58,20.88 147.43,21.03 146.99,21.03 146.84,20.88 146.84,20.52 146.72,20.39 146.23,20.39 146.11,20.52 146.11,20.88 145.96,21.03 145.52,21.03 145.37,20.88 145.37,20.82 145.22,20.67 144.78,20.67 144.63,20.82 144.63,20.88 144.49,21.03 144.04,21.03 143.9,20.88 143.9,20.82 143.75,20.67 143.31,20.67 143.16,20.82 143.16,20.88 143.01,21.03 142.57,21.03 142.42,20.88 142.42,20.82 142.28,20.67 141.83,20.67 141.69,20.82 141.69,20.88 141.54,21.03 141.1,21.03 140.95,20.88 140.95,20.82 140.8,20.67 140.36,20.67 140.21,20.82 140.21,20.88 140.07,21.03 139.62,21.03 139.48,20.88 139.48,20.82 139.33,20.67 138.89,20.67 138.74,20.82 138.74,20.88 138.59,21.03 138.15,21.03 138,20.88 138,20.82 137.86,20.67 137.41,20.67 137.27,20.82 137.27,20.88 137.12,21.03 136.34,21.03 136,20.68 134.25,20.68 134.08,20.85 126.29,20.85 126.18,20.74 118.7,20.74 118.02,21.42 v2(116.16,21.42)
  BOTTOM w0.14: v2(116.16,21.42) 116.16,21.73 116.04,21.86 115.44,21.86 115.29,22.01 115.29,22.23 115.44,22.39 116.04,22.39 118.08,24.42 JDIMM4.38
DDR_B_D13: length 85.3
  TOP w0.089: CPU1.BJ10 v2(177.22,28.68)
  TOP w0.14: JDIMM3.41 117.45,25.17 116.21,23.94 116.21,23.02 115.82,22.63 113.36,22.63 v2(112.91,23.08)
  IN4 w0.089: v2(177.22,28.68) 176.54,28 175.7,28 174.15,26.45 173.19,26.45 172.2,25.46 171.44,25.46 167.83,21.85 166.32,21.85 166.11,22.06 164.71,22.06
  IN4 w0.147: 164.71,22.06 158.99,22.06 158.47,21.54 134.41,21.54 134.09,21.87 124.76,21.87 124.53,21.64 118.46,21.64 118.09,22 113.98,22 v2(112.91,23.08)
  BOTTOM w0.14: JDIMM4.42 117.27,25.42 116.44,24.6 116.44,24.39 116.58,24.25 116.86,24.25 117,24.11 117,23.83 116.86,23.69 116.58,23.69 116.44,23.55 116.44,23.24 115.84,22.63 113.35,22.63 v2(112.91,23.08)
DDR_B_D14: length 79.2
  TOP w0.089: CPU1.BL7 v2(176.14,27.05)
  TOP w0.14: v2(112.78,21.32) 112.11,21.32 111.51,21.93 JDIMM3.28
  IN4 w0.089: v2(176.14,27.05) 175.62,26.54 175.62,25.98 174.04,24.4 172.13,24.4 171.47,23.74
  IN4 w0.147: v2(112.78,21.32) 113.97,20.14 117.6,20.14 118.16,19.58 120.41,19.58 120.95,19.04 125.23,19.04 125.34,19.16 130.8,19.16 130.92,19.04 139.17,19.04 139.42,18.79 145.49,18.79 145.64,18.64 145.64,18.47 145.79,18.32 146.23,18.32 146.38,18.47 146.38,18.64 146.52,18.79 146.97,18.79 147.11,18.64 147.11,18.47 147.26,18.32 147.7,18.32 147.85,18.47 147.85,18.64 148,18.79 148.44,18.79 148.59,18.64 148.59,18.47 148.73,18.32 149.17,18.32 149.32,18.47 149.32,18.64 149.47,18.79 149.91,18.79 150.06,18.64 150.06,18.47 150.21,18.32 150.65,18.32 150.8,18.47 150.8,18.64 150.94,18.79 151.38,18.79 151.53,18.64 151.53,18.47 151.68,18.32 152.12,18.32 152.27,18.47 152.27,18.64 152.42,18.79 152.86,18.79 153.01,18.64 153.01,18.47 153.15,18.32 153.59,18.32 153.74,18.47 153.74,18.64 153.89,18.79 154.33,18.79 154.48,18.64 154.48,18.47 154.63,18.32 155.07,18.32 155.22,18.47 155.22,18.64 155.36,18.79 155.8,18.79 155.95,18.64 155.95,18.59 156.08,18.46 156.56,18.46 156.69,18.59 156.69,18.64 156.84,18.79 159.23,18.79 160.96,20.52 168.25,20.52 168.59,20.86 168.59,20.86 171.47,23.74
  BOTTOM w0.14: v2(112.78,21.32) 112.78,22.29 112.4,22.68 111.88,22.68 111.38,22.17 JDIMM4.29
DDR_B_D15: length 83.4
  TOP w0.089: CPU1.BJ7 v2(175.92,28.68)
  TOP w0.14: JDIMM3.42 111.49,25.42 112.53,24.38 114.61,24.38 115.63,23.36 v2(115.63,23.13)
  IN4 w0.089: v2(175.92,28.68) 175.27,28.68 174.68,28.09 173.12,28.09 172.99,27.96 172.99,27.96 171.5,26.47 171.5,26.05 167.66,22.2 167.25,22.2 166.65,22.81 165.15,22.81
  IN4 w0.147: v2(115.63,23.13) 118.16,23.13 118.9,22.39 123.92,22.39 124.18,22.64 131.3,22.64 131.45,22.79 131.45,22.96 131.6,23.11 132.04,23.11 132.19,22.96 132.19,22.79 132.33,22.64 135.37,22.64 135.5,22.52 135.5,22.42 135.63,22.29 136.12,22.29 136.25,22.42 136.25,22.52 136.38,22.64 136.76,22.64 136.93,22.81 137.32,22.81 137.46,22.66 137.46,22.47 137.61,22.32 138.05,22.32 138.2,22.47 138.2,22.71 138.33,22.83 138.81,22.83 138.94,22.71 138.94,22.42 139.06,22.29 139.55,22.29 139.67,22.42 139.67,22.71 139.8,22.83 140.28,22.83 140.41,22.71 140.41,22.42 140.54,22.29 141.02,22.29 141.15,22.42 141.15,22.71 141.27,22.83 141.76,22.83 141.88,22.71 141.88,22.42 142.01,22.29 142.49,22.29 142.62,22.42 142.62,22.71 142.75,22.83 143.23,22.83 143.36,22.71 143.36,22.42 143.48,22.29 143.97,22.29 144.09,22.42 144.09,22.71 144.22,22.83 144.7,22.83 144.83,22.71 144.83,22.42 144.96,22.29 145.44,22.29 145.57,22.42 145.57,22.66 145.71,22.81 165.15,22.81
  BOTTOM w0.14: v2(115.63,23.13) 116.13,23.62 116.13,24.15 115.85,24.43 112.37,24.43 111.62,25.17 JDIMM4.41
DDR_B_D16: length 80.2
  TOP w0.089: CPU1.BG11 v2(178.51,30.51)
  TOP w0.14: v2(112.97,25.21) 112.97,26 111.54,27.42 JDIMM3.50
  IN4 w0.089: 170.98,26.76 172.36,28.14 172.88,28.14 173.64,28.9 175.44,28.9 176.5,29.96 177.96,29.96 v2(178.51,30.51)
  IN4 w0.147: 170.98,26.76 167.51,23.29 137.07,23.29 136.72,23.64 126.84,23.64 126.49,23.29 124,23.29 123.55,22.84 119.08,22.84 117.9,24.03 112.4,24.03 111.91,24.52 111.91,24.95 112.16,25.21 v2(112.97,25.21)
  BOTTOM w0.14: JDIMM4.49 111.54,27.17 112.97,25.75 v2(112.97,25.21)
DDR_B_D17: length 80.3
  TOP w0.089: CPU1.BG10 v2(177.87,30.51)
  TOP w0.14: JDIMM3.46 111.72,26.42 112.21,25.93 112.21,25.29 112.72,24.78 113.23,24.78 v2(113.65,25.21)
  IN4 w0.089: v2(177.87,30.51) 177.51,30.14 176.43,30.14 175.36,29.07 172.72,29.07 171.9,28.25 171.9,28.19 171.16,27.45 171.16,27.45
  IN4 w0.147: v2(113.65,25.21) 113.65,25.05 113.53,24.92 113.29,24.92 113.16,24.8 113.16,24.53 113.29,24.4 114.24,24.4 114.36,24.53 114.36,24.67 114.49,24.8 114.83,24.8 114.95,24.67 114.95,24.53 115.08,24.4 115.55,24.4 115.68,24.53 115.68,24.67 115.8,24.8 116.2,24.8 116.32,24.67 116.32,24.53 116.45,24.4 116.83,24.4 116.96,24.53 116.96,24.9 117.09,25.03 117.43,25.03 119.23,23.23 123.4,23.23 123.84,23.67 126.33,23.67 126.68,24.01 136.87,24.01 137.13,23.75 141.54,23.75 141.6,23.69 167.4,23.69 171.16,27.45
  BOTTOM w0.14: JDIMM4.45 111.84,26.17 112.28,25.74 112.28,25.17 112.72,24.72 113.17,24.72 v2(113.65,25.21)
DDR_B_D18: length 79
  TOP w0.089: CPU1.BG8 v2(176.57,30.51)
  TOP w0.14: JDIMM3.45 117.39,26.17 v2(116.42,25.21)
  IN4 w0.089: v2(176.57,30.51) 176.54,30.51 175.28,29.25 172.58,29.25 168.29,24.96
  IN4 w0.147: v2(116.42,25.21) 116.29,25.21 115.94,25.56 115.94,26 116.04,26.1 116.63,26.1 116.76,25.98 116.76,25.62 116.88,25.5 117.24,25.5 117.37,25.62 117.37,25.98 117.49,26.1 117.67,26.1 118.05,25.72 118.05,25.55 117.84,25.33 117.84,25.15 118.08,24.91 118.26,24.91 118.47,25.13 118.65,25.13 118.89,24.89 118.89,24.71 118.67,24.5 118.67,24.32 118.94,24.05 119.12,24.05 119.48,24.41 119.74,24.41 119.87,24.28 119.87,23.73 119.99,23.61 120.42,23.61 120.54,23.73 120.54,24.28 120.67,24.41 121.6,24.41 121.73,24.28 121.73,24.19 121.85,24.06 122.19,24.06 122.32,24.19 122.32,24.28 122.44,24.41 122.78,24.41 122.91,24.28 122.91,24.25 123.04,24.12 123.97,24.12 124.12,24.27 124.12,24.7 124.25,24.82 124.58,24.82 124.71,24.7 124.71,24.17 124.84,24.04 125.17,24.04 125.3,24.17 125.3,24.84 125.42,24.96 125.76,24.96 125.89,24.84 125.89,24.27 126.03,24.12 126.25,24.12 126.52,24.39 137.03,24.39 137.29,24.13 165.69,24.13 165.89,23.92 167.25,23.92 168.29,24.96
  BOTTOM w0.14: JDIMM4.46 117.36,26.42 116.8,25.87 116.8,25.59 v2(116.42,25.21)
DDR_B_D19: length 79.7
  TOP w0.089: CPU1.BF8 v2(176.57,31.42)
  TOP w0.14: v2(115.51,28.69) 116.49,29.68 JDIMM3.59
  IN4 w0.089: 170.91,30.2 174.17,30.2 175.75,31.79 176.1,31.79 176.47,31.42 v2(176.57,31.42)
  IN4 w0.147: 170.91,30.2 170.65,29.95 166.91,26.21 140.75,26.21 140.58,26.04 140.25,26.04 140.08,26.2 139.75,26.2 139.58,26.04 139.31,26.04 139.17,26.18 139.17,26.57 139.04,26.7 138.71,26.7 138.58,26.57 138.58,26.18 138.43,26.04 138.25,26.04 137.88,26.41 137.88,26.62 138.32,27.05 138.32,27.23 138.08,27.47 137.9,27.47 137.46,27.03 137.25,27.03 136.81,27.47 126.84,27.47 126.72,27.34 126.72,27 126.59,26.87 126.14,26.87 126.01,27 126.01,27.18 125.89,27.31 125.49,27.31 125.37,27.18 125.37,27 125.24,26.87 124.83,26.87 124.71,27 124.71,27.13 124.58,27.25 124.15,27.25 124.02,27.13 124.02,27 123.89,26.87 123.46,26.87 123.33,27 123.33,27.17 123.21,27.3 122.8,27.3 122.67,27.17 122.67,27 122.55,26.87 122.15,26.87 122.03,27 122.03,27.13 121.9,27.25 120.76,27.25 120.63,27.38 120.63,27.69 120.5,27.82 120.11,27.82 119.98,27.69 119.98,27.16 119.83,27.01 119.47,27.01 117.51,28.98 117.33,28.98 117.2,28.85 117.2,28.74 117.07,28.61 116.7,28.61 116.57,28.74 116.57,28.97 116.45,29.1 115.61,29.1 115.51,29 v2(115.51,28.69)
  BOTTOM w0.14: JDIMM4.58 116.24,29.42 v2(115.51,28.69)
