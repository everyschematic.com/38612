# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Nets (continued)
+VCC_GT: CPU1.AJ29 CPU1.AJ30 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AK31 CPU1.AK32 CPU1.AK33 CPU1.AK34 CPU1.AK35 CPU1.AK36 CPU1.AK37 CPU1.AK38 CPU1.AL13 CPU1.AL29 CPU1.AL30 CPU1.AL31 CPU1.AL32 CPU1.AL35 CPU1.AL36 CPU1.AL37 CPU1.AL38 CPU1.AM13 CPU1.AM14 CPU1.AM29 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AN13 CPU1.AN14 CPU1.AN31 CPU1.AN32 CPU1.AN33 CPU1.AN34 CPU1.AN35 CPU1.AN36 CPU1.AN37 CPU1.AN38 CPU1.AP13 CPU1.AP14 CPU1.AP29 CPU1.AP30 CPU1.AP31 CPU1.AP32 CPU1.AP35 CPU1.AP36 CPU1.AP37 CPU1.AP38 CPU1.AR29 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AT14 CPU1.AT31 CPU1.AT32 CPU1.AT33 CPU1.AT34 CPU1.AT35 CPU1.AT36 CPU1.AT37 CPU1.AT38 CPU1.AU14 CPU1.AU29 CPU1.AU30 CPU1.AU31 CPU1.AU32 CPU1.AU35 CPU1.AU36 CPU1.AU37 CPU1.AU38 CPU1.AV29 CPU1.AV30 CPU1.AV31 CPU1.AV32 CPU1.AV33 CPU1.AV34 CPU1.AV35 CPU1.AV36 CPU1.AW14 CPU1.AW31 CPU1.AW32 CPU1.AW33 CPU1.AW34 CPU1.AW35 CPU1.AW36 CPU1.AW37 CPU1.AW38 CPU1.AY29 CPU1.AY30 CPU1.AY31 CPU1.AY32 CPU1.AY35 CPU1.AY36 CPU1.AY37 CPU1.AY38 CPU1.BA13 CPU1.BA14 CPU1.BA29 CPU1.BA30 CPU1.BA31 CPU1.BA32 CPU1.BA33 CPU1.BA34 CPU1.BA35 CPU1.BA36 CPU1.BB13 CPU1.BB14 CPU1.BB31 CPU1.BB32 CPU1.BB33 CPU1.BB34 CPU1.BB35 CPU1.BB36 CPU1.BB37 CPU1.BB38 CPU1.BC29 CPU1.BC30 CPU1.BC31 CPU1.BC32 CPU1.BC35 CPU1.BC36 CPU1.BC37 CPU1.BC38 CPU1.BD13 CPU1.BD14 CPU1.BD29 CPU1.BD30 CPU1.BD31 CPU1.BD32 CPU1.BD33 CPU1.BD34 CPU1.BD35 CPU1.BD36 CPU1.BE31 CPU1.BE32 CPU1.BE33 CPU1.BE34 CPU1.BE35 CPU1.BE36 CPU1.BE37 CPU1.BE38 CPU1.BF13 CPU1.BF14 CPU1.BF29 CPU1.BF30 CPU1.BF31 CPU1.BF32 CPU1.BF35 CPU1.BF36 CPU1.BF37 CPU1.BF38 CPU1.BG29 CPU1.BG30 CPU1.BG31 CPU1.BG32 CPU1.BG33 CPU1.BG34 CPU1.BG35 CPU1.BG36 CPU1.BH33 CPU1.BH34 CPU1.BH35 CPU1.BH36 CPU1.BH37 CPU1.BH38 CPU1.BJ37 CPU1.BJ38 CPU1.BL36 CPU1.BL37 CPU1.BM36 CPU1.BM37 CPU1.BN36 CPU1.BN37 CPU1.BN38 CPU1.BP37 CPU1.BP38 CPU1.BR37 CPU1.BT37 PC1416.1 PC1417.1 PC1418.1 PC1419.1 PC1420.1 PC1421.1 PC1422.1 PC1423.1 PC1424.1 PC1425.1 PC1426.1 PC1427.1 PC1428.1 PC1429.1 PC1430.1 PC1431.1 PC1432.1 PC1435.1 PC1439.1 PC1440.1 PC1441.1 PC1442.1 PC1443.1 PC1444.1 PC1445.1 PC1446.1 PC1447.1 PC1448.1 PC1449.1 PC1450.1 PC1451.1 PC1452.1 PC1453.1 PC1454.1 PC1455.1 PC1456.1 PC1459.1 PC1460.1 PC1461.1 PC1462.1 PC1463.1 PC1464.1 PC1465.1 PC1466.1 PC1467.1 PC1468.1 PC1469.1 PC1470.1 PC1471.1 PC1472.1 PC1473.1 PC1474.1 PC1475.1 PC1476.1 PC1478.1 PC1479.1 PC1480.1 PC1481.1 PC1482.1 PC1483.1 PC1484.1 PC1485.1 PC1486.1 PC1487.1 PC1488.1 PC1489.1 PC1490.1 PC1491.1 PC1492.1 PC1493.1 PC1494.1 PC1495.1 PC1496.1 PC1497.1 PC1498.1 PC1499.1 PC1500.1 PC1501.1 PC1502.1 PC1503.1 PC1504.1 PC1505.1 PC1506.1 PC1507.1 PC1508.1 PC1509.1 PC1510.1 PC1511.1 PC1512.1 PC1513.1 PC1514.1 PC1515.1 PC1516.1 PC1517.1 PC1518.1 PC1519.1 PC1520.1 PC1521.1 PC1522.1 PC1523.1 PC1524.1 PC1525.1 PC1526.1 PC1527.1 PC1528.1 PC1529.1 PC1530.1 PC1531.1 PC1532.1 PC1533.1 PC1534.1 PC1535.1 PC1536.1 PC1537.1 PC1538.1 PC1539.1 PC1540.1 PC1541.1 PC1542.1 PC1543.1 PC1544.1 PC1545.1 PC1546.1 PC1547.1 PC1548.1 PC1549.1 PL1400.4 PL1401.4 PL1402.4 PR1124.2
+VCC_GTU: CPU1.AF29 CPU1.AF30 CPU1.AF31 CPU1.AF32 CPU1.AF33 CPU1.AF34 CPU1.AG13 CPU1.AG14 CPU1.AG31 CPU1.AG32 CPU1.AG33 CPU1.AG34 CPU1.AG35 CPU1.AG36 CPU1.AH13 CPU1.AH14 CPU1.AH29 CPU1.AH30 CPU1.AH31 CPU1.AH32 CPU1.AJ13 CPU1.AJ14 PC1615.1 PC1616.1 PC1617.1 PC1618.1 PC1619.1 PC1620.1 PC1621.1 PC1622.1 PC1623.1 PC1624.1 PC1625.1 PC1626.1 PC1628.1 PC1629.1 PC1630.1 PC1631.1 PC1632.1 PC1633.1 PC1634.1 PC1635.1 PC1636.1 PC1637.1 PC1638.1 PC1639.1 PC1641.1 PL1600.4 PR1621.1
+VCC_IO: CC187.1 CC188.1 CC189.1 CC272.1 CPU1.AG12 CPU1.G15 CPU1.G17 CPU1.G19 CPU1.G21 CPU1.H15 CPU1.H16 CPU1.H17 CPU1.H19 CPU1.H20 CPU1.H21 CPU1.H26 CPU1.H27 CPU1.J15 CPU1.J16 CPU1.J17 CPU1.J19 CPU1.J20 CPU1.J21 CPU1.J26 CPU1.J27 PJP300.2 Q370.1 R435.1 RC1.1 RC2.1 RC132.2
+VCC_IOP: PC304.1 PC305.1 PC306.1 PC307.1 PC308.1 PJP300.1 PL301.2 PR311.1
+VCC_SA: CC196.1 CC197.1 CC198.1 CC199.1 CC200.1 CC201.1 CC202.1 CC203.2 CC204.2 CC205.2 CC208.1 CC211.1 CC212.1 CC213.1 CPU1.J30 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.K33 CPU1.K34 CPU1.K35 CPU1.L31 CPU1.L32 CPU1.L35 CPU1.L36 CPU1.L37 CPU1.L38 CPU1.M29 CPU1.M30 CPU1.M31 CPU1.M32 CPU1.M33 CPU1.M34 CPU1.M35 CPU1.M36 PC1706.1 PL1700.4 PR1111.1
+VCC_SFR_OC: CC209.2 CC210.2 CPU1.BH13 CPU1.G11 CZ95.1 RC302.1 UZ30.6
+VCC_VDDQ_CLK: CC185.1 CPU1.Y12 RC220.1
+VCCAUSB_VCCAAZPLL_1P0: CH44.1 CH45.1 RH238.2 RH239.1 RH240.1
AGND: PC1106.1 PC1118.1 PC1120.2 PC1123.1 PC1126.2 PC1127.2 PC1128.1 PC1129.2 PC1130.2 PJP1100.2 PR1112.1 PR1120.2 PR1132.1 PR1135.2 PR1152.2 PR1153.2 PR1155.2 PR1156.2 PR1157.2 PR1158.2 PR1159.2 PU1100.53
GND: C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C90.2 C92.2 C94.2 C97.1 C98.1 C99.1 C100.1 C248.2 C249.1 C292.2 C293.2 C296.2 C298.2 C299.2 C300.2 C301.2 C310.2 C320.2 C327.2 C328.2 C330.2 C332.2 C357.2 C364.2 C370.2 C391.2 C392.2 C395.2 C396.2 C400.2 C401.2 C403.2 C404.2 C406.2 C436.1 C437.1 C450.2 C462.2 C463.2 C464.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C477.1 C478.2 C479.2 C480.2 C481.2 C483.2 C484.2 C485.1 C486.2 C494.2 C495.2 C496.2 C497.2 C499.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C507.2 C508.2 C509.2 C513.2 C514.2 C536.2 C538.1 C539.2 C541.2 C542.1 C543.1 C544.1 C547.1 C554.2 C603.2 C604.2 C605.2 C606.1 C607.1 C608.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C617.2 C618.2 C619.2 C621.2 C622.2 C623.2 C695.2 C696.2 C701.2 C702.2 C703.2 C704.2 C708.2 C709.2 C710.2 C713.2 C714.2 C716.2 C717.2 C718.2 C719.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C733.2 C734.2 C735.2 C736.2 C737.2 C739.2 C740.2 C741.2 C743.2 C744.2 C746.2 C747.2 C757.2 C759.2 C762.2 C763.2 C764.2 C766.2 C767.2 C774.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C1167.2 C1176.2 C1177.2 C1178.2 C1216.2 C1344.2 C1345.2 C1348.2 C1349.2 C1352.2 C1353.2 C1354.2 C1355.2 C1356.2 C1402.2 C1410.2 C1411.2 C1414.2 C1418.2 C1421.2 C1423.2 C1424.2 C1425.2 C1426.2 C1427.2 C1428.2 C1430.2 C1431.2 C1444.1 C1445.2 C1456.2 C1465.2 C1466.2 C1467.2 C1468.2 C1469.2 C1470.2 C1471.2 CC33.2 CC35.2 CC36.2 CC37.2 CC81.2 CC82.2 CC83.2 CC84.2 CC161.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC169.2 CC170.2 CC171.2 CC172.2 CC173.2 CC174.2 CC175.2 CC176.2 CC177.2 CC178.2 CC179.2 CC180.2 CC181.2 CC182.2 CC183.2 CC184.2 CC185.2 CC186.1 CC187.2 CC188.2 CC189.2 CC190.2 CC191.1 CC192.1 CC193.1 CC194.1 CC195.1 CC196.2 CC197.2 CC198.2 CC199.2 CC200.2 CC201.2 CC202.2 CC203.1 CC204.1 CC205.1 CC208.2 CC209.1 CC210.1 CC211.2 CC212.2 CC213.2 CC269.2 CC272.2 CC273.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD110.2 CD111.2 CD112.2 CD113.2 CD114.2 CD115.2 CD116.2 CD117.2 CD118.2 CD119.2 CD120.2 CD121.2 CD122.2 CD123.2 CD124.2 CD128.2 CD129.2 CD137.2 CD138.2 CD139.2 CD140.2 CD142.2 CD143.2 CD144.2 CE1.2 CE6.2 CE8.2 CE9.2 CH4.1 CH5.1 CH10.2 CH13.2 CH14.2 CH17.2 CH29.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH40.1 CH41.1 CH42.2 CH44.2 CH45.2 CH46.2 CH47.2 CH49.2 CH50.2 CH51.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH266.2 CH267.2 CH268.1 CH269.2 CMOS1.1 CN67.2 CN71.2 CN73.2 CN75.2 CPU1.A3 CPU1.A4 CPU1.A6 CPU1.A9 CPU1.A10 CPU1.A12 CPU1.A14 CPU1.A16 CPU1.A18 CPU1.A20 CPU1.A22 CPU1.A24 CPU1.A26 CPU1.A28 CPU1.A30 CPU1.A34 CPU1.A36 CPU1.A37 CPU1.AA12 CPU1.AA29 CPU1.AA30 CPU1.AB6 CPU1.AB33 CPU1.AB34 CPU1.AC1 CPU1.AC2 CPU1.AC3 CPU1.AC4 CPU1.AC5 CPU1.AC6 CPU1.AC12 CPU1.AC37 CPU1.AC38 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD9 CPU1.AD10 CPU1.AD11 CPU1.AD12 CPU1.AD29 CPU1.AD30 CPU1.AE6 CPU1.AE33 CPU1.AE34 CPU1.AF1 CPU1.AF2 CPU1.AF3 CPU1.AF4 CPU1.AF12 CPU1.AF13 CPU1.AF14 CPU1.AG6 CPU1.AG7 CPU1.AG8 CPU1.AG10 CPU1.AG11 CPU1.AG29 CPU1.AG30 CPU1.AH6 CPU1.AH12 CPU1.AH33 CPU1.AH34 CPU1.AJ1 CPU1.AJ2 CPU1.AJ3 CPU1.AJ4 CPU1.AJ5 CPU1.AJ6 CPU1.AJ37 CPU1.AJ38 CPU1.AK4 CPU1.AK29 CPU1.AK30 CPU1.AL4 CPU1.AL7 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AL12 CPU1.AL14 CPU1.AL33 CPU1.AL34 CPU1.AM1 CPU1.AM2 CPU1.AM3 CPU1.AM4 CPU1.AM5 CPU1.AM12 CPU1.AM37 CPU1.AM38 CPU1.AN5 CPU1.AN6 CPU1.AN12 CPU1.AN29 CPU1.AN30 CPU1.AP8 CPU1.AP9 CPU1.AP10 CPU1.AP11 CPU1.AP12 CPU1.AP33 CPU1.AP34 CPU1.AR1 CPU1.AR2 CPU1.AR3 CPU1.AR4 CPU1.AR5 CPU1.AR13 CPU1.AR14 CPU1.AR37 CPU1.AR38 CPU1.AT6 CPU1.AT29 CPU1.AT30 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU10 CPU1.AU11 CPU1.AU12 CPU1.AU33 CPU1.AU34 CPU1.AV37 CPU1.AV38 CPU1.AW1 CPU1.AW2 CPU1.AW3 CPU1.AW4 CPU1.AW5 CPU1.AW12 CPU1.AW29 CPU1.AW30 CPU1.AY12 CPU1.AY14 CPU1.AY33 CPU1.AY34 CPU1.B3 CPU1.B9 CPU1.B37 CPU1.BA6 CPU1.BA7 CPU1.BA8 CPU1.BA9 CPU1.BA10 CPU1.BA11 CPU1.BA12 CPU1.BA37 CPU1.BA38 CPU1.BB1 CPU1.BB2 CPU1.BB3 CPU1.BB4 CPU1.BB5 CPU1.BB6 CPU1.BB12 CPU1.BB29 CPU1.BB30 CPU1.BC6 CPU1.BC12 CPU1.BC13 CPU1.BC14 CPU1.BC33 CPU1.BC34 CPU1.BD6 CPU1.BD7 CPU1.BD8 CPU1.BD9 CPU1.BD10 CPU1.BD11 CPU1.BD12 CPU1.BD37 CPU1.BD38 CPU1.BE1 CPU1.BE2 CPU1.BE3 CPU1.BE4 CPU1.BE5 CPU1.BE6 CPU1.BE29 CPU1.BE30 CPU1.BF6 CPU1.BF12 CPU1.BF33 CPU1.BF34 CPU1.BG6 CPU1.BG12 CPU1.BG13 CPU1.BG14 CPU1.BG37 CPU1.BG38 CPU1.BH1 CPU1.BH2 CPU1.BH3 CPU1.BH4 CPU1.BH5 CPU1.BH6 CPU1.BH7 CPU1.BH8 CPU1.BH9 CPU1.BH10 CPU1.BH11 CPU1.BH12 CPU1.BH14 CPU1.BJ12 CPU1.BJ15 CPU1.BJ18 CPU1.BJ22 CPU1.BJ25 CPU1.BJ29 CPU1.BJ30 CPU1.BJ31 CPU1.BJ32 CPU1.BK6 CPU1.BK13 CPU1.BK14 CPU1.BK15 CPU1.BK18 CPU1.BK22 CPU1.BK25 CPU1.BK29 CPU1.BL6 CPU1.BL13 CPU1.BL29 CPU1.BL35 CPU1.BL38 CPU1.BM2 CPU1.BM3 CPU1.BM5 CPU1.BM6 CPU1.BM7 CPU1.BM8 CPU1.BM9 CPU1.BM11 CPU1.BM12 CPU1.BM13 CPU1.BM18 CPU1.BM21 CPU1.BM23 CPU1.BM25 CPU1.BM26 CPU1.BM27 CPU1.BM28 CPU1.BM29 CPU1.BM35 CPU1.BM38 CPU1.BN2 CPU1.BN4 CPU1.BN7 CPU1.BN9 CPU1.BN12 CPU1.BN14 CPU1.BN18 CPU1.BN19 CPU1.BN20 CPU1.BN21 CPU1.BN24 CPU1.BN29 CPU1.BN30 CPU1.BN31 CPU1.BN34 CPU1.BP7 CPU1.BP12 CPU1.BP14 CPU1.BP18 CPU1.BP21 CPU1.BP24 CPU1.BP26 CPU1.BP29 CPU1.BP33 CPU1.BP34 CPU1.BR7 CPU1.BR12 CPU1.BR14 CPU1.BR18 CPU1.BR21 CPU1.BR24 CPU1.BR26 CPU1.BR29 CPU1.BR34 CPU1.BR36 CPU1.BR38 CPU1.BT3 CPU1.BT4 CPU1.BT5 CPU1.BT9 CPU1.BT12 CPU1.BT14 CPU1.BT18 CPU1.BT21 CPU1.BT24 CPU1.BT26 CPU1.BT32 CPU1.BT35 CPU1.BT36 CPU1.C2 CPU1.C5 CPU1.C8 CPU1.C9 CPU1.C11 CPU1.C13 CPU1.C15 CPU1.C17 CPU1.C19 CPU1.C21 CPU1.C23 CPU1.C25 CPU1.C27 CPU1.C29 CPU1.C31 CPU1.C37 CPU1.D3 CPU1.D6 CPU1.D9 CPU1.D10 CPU1.D12 CPU1.D14 CPU1.D16 CPU1.D18 CPU1.D20 CPU1.D22 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D33 CPU1.D38 CPU1.E4 CPU1.E9 CPU1.E34 CPU1.E35 CPU1.E38 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F5 CPU1.F8 CPU1.F9 CPU1.F11 CPU1.F13 CPU1.F15 CPU1.F17 CPU1.F19 CPU1.F21 CPU1.F23 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F36 CPU1.G4 CPU1.G5 CPU1.G6 CPU1.G8 CPU1.G9 CPU1.G10 CPU1.G12 CPU1.G14 CPU1.G16 CPU1.G18 CPU1.G20 CPU1.G22 CPU1.G23 CPU1.G24 CPU1.G26 CPU1.G28 CPU1.H11 CPU1.H12 CPU1.H18 CPU1.H22 CPU1.H25 CPU1.H32 CPU1.H35 CPU1.J4 CPU1.J7 CPU1.J10 CPU1.J18 CPU1.J22 CPU1.J25 CPU1.J32 CPU1.J33 CPU1.J36 CPU1.K1 CPU1.K2 CPU1.K3 CPU1.K4 CPU1.K5 CPU1.K7 CPU1.K8 CPU1.K9 CPU1.K10 CPU1.K11 CPU1.K38 CPU1.L29 CPU1.L30 CPU1.L33 CPU1.L34 CPU1.M6 CPU1.M12 CPU1.M13 CPU1.M14 CPU1.N1 CPU1.N2 CPU1.N3 CPU1.N4 CPU1.N5 CPU1.N6 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.N11 CPU1.N12 CPU1.N33 CPU1.N34 CPU1.P6 CPU1.P12 CPU1.P37 CPU1.P38 CPU1.R12 CPU1.R29 CPU1.R30 CPU1.T1 CPU1.T2 CPU1.T3 CPU1.T4 CPU1.T5 CPU1.T7 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.T11 CPU1.T12 CPU1.T13 CPU1.T14 CPU1.T33 CPU1.T34 CPU1.U6 CPU1.U37 CPU1.U38 CPU1.V6 CPU1.V12 CPU1.V29 CPU1.V30 CPU1.W1 CPU1.W2 CPU1.W3 CPU1.W4 CPU1.W5 CPU1.W12 CPU1.W33 CPU1.W34 CPU1.Y7 CPU1.Y8 CPU1.Y9 CPU1.Y10 CPU1.Y11 CPU1.Y13 CPU1.Y14 CPU1.Y37 CPU1.Y38 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV42.2 CZ4.2 CZ5.2 CZ6.2 CZ7.2 CZ8.2 CZ9.2 CZ10.2 CZ11.2 CZ12.2 CZ15.2 CZ30.2 CZ31.2 CZ57.2 CZ63.2 CZ65.2 CZ66.2 CZ67.2 CZ82.2 CZ86.2 CZ88.2 CZ89.2 CZ90.2 CZ93.2 CZ94.2 CZ95.2 CZ96.2 CZ97.2 D20.1 D21.1 D22.1 D33.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H9.1(TP-1) H10.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H22.1(TP-1) H23.1(TP-1) H27.1(TP-1) H29.1(TP-1) H30.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JDEG2.10 JDEG2.11 JDEG2.12 JDEG3.2 JDEG3.7 JDEG3.8 JDIMM1.1 JDIMM1.2 JDIMM1.5 JDIMM1.6 JDIMM1.9 JDIMM1.10 JDIMM1.14 JDIMM1.15 JDIMM1.18 JDIMM1.19 JDIMM1.22 JDIMM1.23 JDIMM1.26 JDIMM1.27 JDIMM1.30 JDIMM1.31 JDIMM1.35 JDIMM1.36 JDIMM1.39 JDIMM1.40 JDIMM1.43 JDIMM1.44 JDIMM1.47 JDIMM1.48 JDIMM1.51 JDIMM1.52 JDIMM1.56 JDIMM1.57 JDIMM1.60 JDIMM1.61 JDIMM1.64 JDIMM1.65 JDIMM1.68 JDIMM1.69 JDIMM1.72 JDIMM1.73 JDIMM1.77 JDIMM1.78 JDIMM1.81 JDIMM1.82 JDIMM1.85 JDIMM1.86 JDIMM1.89 JDIMM1.90 JDIMM1.93 JDIMM1.94 JDIMM1.98 JDIMM1.99 JDIMM1.102 JDIMM1.103 JDIMM1.106 JDIMM1.107 JDIMM1.167 JDIMM1.168 JDIMM1.171 JDIMM1.172 JDIMM1.175 JDIMM1.176 JDIMM1.180 JDIMM1.181 JDIMM1.184 JDIMM1.185 JDIMM1.188 JDIMM1.189 JDIMM1.192 JDIMM1.193 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.202 JDIMM1.205 JDIMM1.206 JDIMM1.209 JDIMM1.210 JDIMM1.213 JDIMM1.214 JDIMM1.217 JDIMM1.218 JDIMM1.222 JDIMM1.223 JDIMM1.226 JDIMM1.227 JDIMM1.230 JDIMM1.231 JDIMM1.234 JDIMM1.235 JDIMM1.238 JDIMM1.239 JDIMM1.243 JDIMM1.244 JDIMM1.247 JDIMM1.248 JDIMM1.251 JDIMM1.252 JDIMM1.261 JDIMM1.262 JDIMM2.1 JDIMM2.2 JDIMM2.5 JDIMM2.6 JDIMM2.9 JDIMM2.10 JDIMM2.14 JDIMM2.15 JDIMM2.18 JDIMM2.19 JDIMM2.22 JDIMM2.23 JDIMM2.26 JDIMM2.27 JDIMM2.30 JDIMM2.31 JDIMM2.35 JDIMM2.36 JDIMM2.39 JDIMM2.40 JDIMM2.43 JDIMM2.44 JDIMM2.47 JDIMM2.48 JDIMM2.51 JDIMM2.52 JDIMM2.56 JDIMM2.57 JDIMM2.60 JDIMM2.61 JDIMM2.64 JDIMM2.65 JDIMM2.68 JDIMM2.69 JDIMM2.72 JDIMM2.73 JDIMM2.77 JDIMM2.78 JDIMM2.81 JDIMM2.82 JDIMM2.85 JDIMM2.86 JDIMM2.89 JDIMM2.90 JDIMM2.93 JDIMM2.94 JDIMM2.98 JDIMM2.99 JDIMM2.102 JDIMM2.103 JDIMM2.106 JDIMM2.107 JDIMM2.167 JDIMM2.168 JDIMM2.171 JDIMM2.172 JDIMM2.175 JDIMM2.176 JDIMM2.180 JDIMM2.181 JDIMM2.184 JDIMM2.185 JDIMM2.188 JDIMM2.189 JDIMM2.192 JDIMM2.193 JDIMM2.196 JDIMM2.197 JDIMM2.201 JDIMM2.202 JDIMM2.205 JDIMM2.206 JDIMM2.209 JDIMM2.210 JDIMM2.213 JDIMM2.214 JDIMM2.217 JDIMM2.218 JDIMM2.222 JDIMM2.223 JDIMM2.226 JDIMM2.227 JDIMM2.230 JDIMM2.231 JDIMM2.234 JDIMM2.235 JDIMM2.238 JDIMM2.239 JDIMM2.243 JDIMM2.244 JDIMM2.247 JDIMM2.248 JDIMM2.251 JDIMM2.252 JDIMM2.261 JDIMM2.262 JDIMM3.1 JDIMM3.2 JDIMM3.5 JDIMM3.6 JDIMM3.9 JDIMM3.10 JDIMM3.14 JDIMM3.15 JDIMM3.18 JDIMM3.19 JDIMM3.22 JDIMM3.23 JDIMM3.26 JDIMM3.27 JDIMM3.30 JDIMM3.31 JDIMM3.35 JDIMM3.36 JDIMM3.39 JDIMM3.40 JDIMM3.43 JDIMM3.44 JDIMM3.47 JDIMM3.48 JDIMM3.51 JDIMM3.52 JDIMM3.56 JDIMM3.57 JDIMM3.60 JDIMM3.61 JDIMM3.64 JDIMM3.65 JDIMM3.68 JDIMM3.69 JDIMM3.72 JDIMM3.73 JDIMM3.77 JDIMM3.78 JDIMM3.81 JDIMM3.82 JDIMM3.85 JDIMM3.86 JDIMM3.89 JDIMM3.90 JDIMM3.93 JDIMM3.94 JDIMM3.98 JDIMM3.99 JDIMM3.102 JDIMM3.103 JDIMM3.106 JDIMM3.107 JDIMM3.167 JDIMM3.168 JDIMM3.171 JDIMM3.172 JDIMM3.175 JDIMM3.176 JDIMM3.180 JDIMM3.181 JDIMM3.184 JDIMM3.185 JDIMM3.188 JDIMM3.189 JDIMM3.192 JDIMM3.193 JDIMM3.196 JDIMM3.197 JDIMM3.201 JDIMM3.202 JDIMM3.205 JDIMM3.206 JDIMM3.209 JDIMM3.210 JDIMM3.213 JDIMM3.214 JDIMM3.217 JDIMM3.218 JDIMM3.222 JDIMM3.223 JDIMM3.226 JDIMM3.227 JDIMM3.230 JDIMM3.231 JDIMM3.234 JDIMM3.235 JDIMM3.238 JDIMM3.239 JDIMM3.243 JDIMM3.244 JDIMM3.247 JDIMM3.248 JDIMM3.251 JDIMM3.252 JDIMM3.261 JDIMM3.262 JDIMM4.1 JDIMM4.2 JDIMM4.5 JDIMM4.6 JDIMM4.9 JDIMM4.10 JDIMM4.14 JDIMM4.15 JDIMM4.18 JDIMM4.19 JDIMM4.22 JDIMM4.23 JDIMM4.26 JDIMM4.27 JDIMM4.30 JDIMM4.31 JDIMM4.35 JDIMM4.36 JDIMM4.39 JDIMM4.40 JDIMM4.43 JDIMM4.44 JDIMM4.47 JDIMM4.48 JDIMM4.51 JDIMM4.52 JDIMM4.56 JDIMM4.57 JDIMM4.60 JDIMM4.61 JDIMM4.64 JDIMM4.65 JDIMM4.68 JDIMM4.69 JDIMM4.72 JDIMM4.73 JDIMM4.77 JDIMM4.78 JDIMM4.81 JDIMM4.82 JDIMM4.85 JDIMM4.86 JDIMM4.89 JDIMM4.90 JDIMM4.93 JDIMM4.94 JDIMM4.98 JDIMM4.99 JDIMM4.102 JDIMM4.103 JDIMM4.106 JDIMM4.107 JDIMM4.167 JDIMM4.168 JDIMM4.171 JDIMM4.172 JDIMM4.175 JDIMM4.176 JDIMM4.180 JDIMM4.181 JDIMM4.184 JDIMM4.185 JDIMM4.188 JDIMM4.189 JDIMM4.192 JDIMM4.193 JDIMM4.196 JDIMM4.197 JDIMM4.201 JDIMM4.202 JDIMM4.205 JDIMM4.206 JDIMM4.209 JDIMM4.210 JDIMM4.213 JDIMM4.214 JDIMM4.217 JDIMM4.218 JDIMM4.222 JDIMM4.223 JDIMM4.226 JDIMM4.227 JDIMM4.230 JDIMM4.231 JDIMM4.234 JDIMM4.235 JDIMM4.238 JDIMM4.239 JDIMM4.243 JDIMM4.244 JDIMM4.247 JDIMM4.248 JDIMM4.251 JDIMM4.252 JDIMM4.261 JDIMM4.262 JDOCK1.1 JDOCK1.7 JDOCK1.8 JDOCK1.13 JDOCK1.14 JDOCK1.19 JDOCK1.20 JDOCK1.25 JDOCK1.26 JDOCK1.31 JDOCK1.32 JDOCK1.37 JDOCK1.38 JDOCK1.43 JDOCK1.44 JDOCK1.47 JDOCK1.49 JDOCK1.50 JDOCK1.51 JDOCK1.52 JDOCK1.55 JDOCK1.57 JDOCK1.58 JDOCK1.61 JDOCK1.63 JDOCK1.64 JDOCK1.69 JDOCK1.70 JDOCK1.75 JDOCK1.76 JDOCK1.81 JDOCK1.82 JDOCK1.87 JDOCK1.88 JDOCK1.91 JDOCK1.93 JDOCK1.94 JDOCK1.95 JDOCK1.96 JDOCK1.101 JDOCK1.102 JDOCK1.107 JDOCK1.108 JDOCK1.113 JDOCK1.114 JDOCK1.119 JDOCK1.120 JDOCK1.123 JDOCK1.125 JDOCK1.126 JDOCK1.131 JDOCK1.132 JDOCK1.137 JDOCK1.138 JDOCK1.145 JDOCK1.148 JDOCK1.151 JDOCK1.152 JDOCK1.153 JDOCK1.154 JDOCK1.155 JDOCK1.156 JDOCK1.157 JDOCK1.158 JDOCK1.159 JDOCK1.160 JDOCK1.161 JDOCK1.162 JEDP1.12 JEDP1.14 JEDP1.21 JEDP1.22 JEDP1.23 JEDP1.30 JEDP1.31 JEDP1.40 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JFAN1.4 JFAN1.5 JFAN1.6 JFAN2.4 JFAN2.5 JFAN2.6 JIO1.1 JIO1.2 JIO1.7 JIO1.8 JIO1.13 JIO1.14 JIO1.20 JIO1.23 JIO1.26 JIO1.29 JIO1.32 JIO1.35 JIO1.38 JIO1.44 JIO1.57 JIO1.58 JIO1.63 JIO1.74 JIO1.76 JIO1.91 JIO1.93 JIO1.101 JIO1.102 JIO2.23 JIO2.25 JIO2.27 JIO2.28 JIO2.29 JIO2.30 JIO2.31 JIO2.32 JIO2.33 JIO2.81 JIO2.87 JIO2.93 JIO2.99 JIO2.105 JIO2.106 JIO2.111 JIO2.112 JIO2.117 JIO2.118 JIO2.123 JIO2.124 JIO2.129 JIO2.130 JIO2.135 JIO2.136 JIO2.141 JIO2.142 JIO2.147 JIO2.148 JIO2.153 JIO2.154 JIO2.159 JIO2.160 JIO2.161 JIO2.162 JKBTP1.1 JKBTP1.4 JKBTP1.6 JKBTP1.12 JKBTP1.18 JKBTP1.19 JKBTP1.21 JKBTP1.22 JKBTP1.23 JKBTP1.24 JLED1.6 JLED1.7 JLED1.8 JLED1.9 JLED1.10 JLOM1.14 JLOM1.15 JLPDE1.9 JLPDE1.11 JLPDE1.12 JMXM1.19 JMXM1.20 JMXM1.21 JMXM1.22 JMXM1.23 JMXM1.24 JMXM1.25 JMXM1.26 JMXM1.27 JMXM1.28 JMXM1.29 JMXM1.30 JMXM1.31 JMXM1.32 JMXM1.33 JMXM1.34 JMXM1.35 JMXM1.36 JMXM1.47 JMXM1.49 JMXM1.51 JMXM1.53 JMXM1.72 JMXM1.73 JMXM1.82 JMXM1.83 JMXM1.88 JMXM1.89 JMXM1.94 JMXM1.95 JMXM1.100 JMXM1.101 JMXM1.106 JMXM1.107 JMXM1.112 JMXM1.113 JMXM1.118 JMXM1.119 JMXM1.124 JMXM1.125 JMXM1.130 JMXM1.131 JMXM1.136 JMXM1.137 JMXM1.142 JMXM1.143 JMXM1.148 JMXM1.149 JMXM1.154 JMXM1.155 JMXM1.160 JMXM1.161 JMXM1.162 JMXM1.163 JMXM1.168 JMXM1.169 JMXM1.174 JMXM1.175 JMXM1.180 JMXM1.181 JMXM1.187 JMXM1.194 JMXM1.202 JMXM1.203 JMXM1.208 JMXM1.209 JMXM1.214 JMXM1.215 JMXM1.220 JMXM1.221 JMXM1.226 JMXM1.227 JMXM1.232 JMXM1.233 JMXM1.238 JMXM1.239 JMXM1.244 JMXM1.245 JMXM1.250 JMXM1.251 JMXM1.256 JMXM1.272 JMXM1.278 JMXM1.281 JMXM1.284 JMXM1.287 JMXM1.290 JMXM1.293 JMXM1.296 JMXM1.299 JMXM1.305 JMXM1.311 JMXM1.312 JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68 JNGFF1.69 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.19 JNGFF2.25 JNGFF2.31 JNGFF2.37 JNGFF2.43 JNGFF2.49 JNGFF2.63 JNGFF2.65 JNGFF2.68 JNGFF2.69 JNGFF3.1 JNGFF3.3 JNGFF3.9 JNGFF3.15 JNGFF3.21 JNGFF3.27 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.63 JNGFF3.65 JNGFF3.67 JNGFF3.68 JNGFF3.69 JPB1.6 JPB1.7 JPB1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSATA2.1 JSATA2.4 JSATA2.7 JSATA2.10 JSATA2.13 JSATA2.21 JSATA2.31 JSATA2.32 JSATA2.33 JSATA2.34 JSIM1.8 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSIM1.18 JSPI1.17 JSPI1.18 JSPI1.19 JSPI1.20 JSPI1.21 JSPI1.22 JTAG1.2 JTS1.1 JTS1.7 JTS1.8 JUART1.4 JUART1.5 JUART1.6 JUSH1.2 JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.27 JUSH1.28 JUSH1.29 JUSH1.30 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 LED5.1 PBATT1.1 PBATT1.2 PBATT1.4 PBATT1.10 PBATT1.11 PC1.2 PC2.2 PC4.2 PC5.2 PC11.2 PC14.2 PC15.2 PC30.2 PC31.2 PC100.1 PC101.2 PC102.2 PC103.2 PC105.2 PC111.2 PC114.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC151.1 PC201.2 PC202.2 PC203.2 PC204.2 PC205.2 PC207.2 PC209.2 PC210.2 PC212.2 PC213.2 PC214.2 PC215.2 PC300.2 PC301.2 PC303.2 PC305.2 PC306.2 PC307.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC400.2 PC401.2 PC403.2 PC404.2 PC405.2 PC501.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC702.1 PC704.2 PC705.2 PC706.2 PC707.2 PC708.2 PC709.2 PC714.2 PC715.2 PC717.2 PC718.2 PC719.2 PC737.2 PC741.1 PC800.2 PC801.2 PC802.2 PC803.2 PC805.2 PC806.2 PC807.2 PC900.2 PC901.2 PC902.2 PC904.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1100.1 PC1101.1 PC1108.1 PC1141.2 PC1142.2 PC1200.2 PC1201.2 PC1202.2 PC1203.2 PC1204.2 PC1205.2 PC1206.2 PC1207.2 PC1209.2 PC1211.2 PC1212.2 PC1213.2 PC1216.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1225.2 PC1226.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1233.2 PC1234.2 PC1235.2 PC1236.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1243.2 PC1244.2 PC1245.2 PC1246.2 PC1247.2 PC1248.2 PC1249.2 PC1251.2 PC1252.2 PC1253.2 PC1254.2 PC1255.2 PC1256.2 PC1257.2 PC1258.2 PC1259.2 PC1260.2 PC1261.2 PC1262.2 PC1263.2 PC1264.2 PC1265.2 PC1266.2 PC1267.2 PC1268.2 PC1270.2 PC1271.2 PC1272.2 PC1273.2 PC1274.2 PC1275.2 PC1276.2 PC1277.2 PC1278.2 PC1279.2 PC1280.2 PC1281.2 PC1282.2 PC1283.2 PC1284.2 PC1285.2 PC1286.2 PC1287.2 PC1288.2 PC1289.2 PC1290.2 PC1291.2 PC1292.2 PC1293.2 PC1294.2 PC1295.2 PC1296.2 PC1297.2 PC1298.2 PC1299.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1400.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1409.2 PC1411.2 PC1412.2 PC1413.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1420.2 PC1421.2 PC1422.2 PC1423.2 PC1424.2 PC1425.2 PC1426.2 PC1427.2 PC1428.2 PC1429.2 PC1430.2 PC1431.2 PC1432.2 PC1433.2 PC1434.2 PC1435.2 PC1436.2 PC1437.2 PC1439.2 PC1440.2 PC1441.2 PC1442.2 PC1443.2 PC1444.2 PC1445.2 PC1446.2 PC1447.2 PC1448.2 PC1449.2 PC1450.2 PC1451.2 PC1452.2 PC1453.2 PC1454.2 PC1455.2 PC1456.2 PC1457.2 PC1458.2 PC1459.2 PC1460.2 PC1461.2 PC1462.2 PC1463.2 PC1464.2 PC1465.2 PC1466.2 PC1467.2 PC1468.2 PC1469.2 PC1470.2 PC1471.2 PC1472.2 PC1473.2 PC1474.2 PC1475.2 PC1476.2 PC1478.2 PC1479.2 PC1480.2 PC1481.2 PC1482.2 PC1483.2 PC1484.2 PC1485.2 PC1486.2 PC1487.2 PC1488.2 PC1489.2 PC1490.2 PC1491.2 PC1492.2 PC1493.2 PC1494.2 PC1495.2 PC1496.2 PC1497.2 PC1498.2 PC1499.2 PC1500.2 PC1501.2 PC1502.2 PC1503.2 PC1504.2 PC1505.2 PC1506.2 PC1507.2 PC1508.2 PC1509.2 PC1510.2 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1519.2 PC1520.2 PC1521.2 PC1522.2 PC1523.2 PC1524.2 PC1525.2 PC1526.2 PC1527.2 PC1528.2 PC1529.2 PC1530.2 PC1531.2 PC1532.2 PC1533.2 PC1534.2 PC1535.2 PC1536.2 PC1537.2 PC1538.2 PC1539.2 PC1540.2 PC1541.2 PC1542.2 PC1543.2 PC1544.2 PC1545.2 PC1546.2 PC1547.2 PC1548.2 PC1549.2 PC1550.2 PC1551.2 PC1552.2 PC1553.2 PC1554.2 PC1555.2 PC1600.1 PC1601.2 PC1602.2 PC1604.2 PC1605.2 PC1606.1 PC1607.2 PC1609.2 PC1611.2 PC1612.1 PC1615.2 PC1616.2 PC1617.2 PC1618.2 PC1619.2 PC1620.2 PC1621.2 PC1622.2 PC1623.2 PC1624.2 PC1625.2 PC1626.2 PC1628.2 PC1629.2 PC1630.2 PC1631.2 PC1632.2 PC1633.2 PC1634.2 PC1635.2 PC1636.2 PC1637.2 PC1638.2 PC1639.2 PC1641.2 PC1642.2 PC1643.2 PC1644.2 PC1700.2 PC1701.2 PC1702.2 PC1704.2 PC1706.2 PC1707.2 PC1708.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1806.2 PC1807.2 PC1808.2 PC1809.2 PC1810.2 PD2.1 PD3.1 PD4.1 PD6.1 PD8.2 PD703.2 PH1103.2 PH1104.2 PH1601.1 PJP700.2 PJP1100.1 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.11 PQ3.3 PQ8.6 PQ102.1 PQ102.2 PQ102.3 PQ103.1 PQ103.2 PQ103.3 PQ202.1 PQ202.2 PQ202.3 PQ705.1 PQ705.2 PQ705.3 PQ708.1 PQ801.1 PQ801.2 PQ801.3 PQ1005.1 PQ1011.3 PQ1073.4 PQ1074.1 PQ1074.4 PR12.1 PR18.2 PR19.2 PR22.2 PR102.1 PR104.2 PR105.1 PR106.1 PR114.2 PR207.2 PR303.2 PR308.2 PR310.2 PR316.1 PR402.2 PR405.2 PR502.1 PR508.2 PR510.2 PR513.1 PR514.2 PR745.2 PR764.2 PR767.2 PR770.2 PR802.1 PR806.2 PR808.2 PR901.2 PR903.2 PR1001.2 PR1003.2 PR1018.2 PR1028.2 PR1031.1 PR1035.2 PR1037.2 PR1100.1 PR1116.1 PR1118.1 PR1125.1 PR1129.2 PR1167.2 PR1168.2 PR1206.2 PR1207.2 PR1211.2 PR1406.2 PR1407.2 PR1411.2 PR1600.1 PR1604.2 PR1605.2 PR1610.2 PR1612.2 PR1614.2 PR1616.2 PR1620.1 PR1702.2 PR1802.1 PR1808.2 PR1809.2 PR1813.1 PR1814.2 PU1.2 PU101.21 PU105.3 PU200.1 PU200.3 PU200.14 PU200.21 PU300.9 PU400.4 PU400.8 PU400.9 PU500.2 PU500.11 PU700.22 PU800.11 PU900.1 PU1001.5 PU1001.14 PU1001.23 PU1001.32 PU1001.37 PU1200.5 PU1200.19 PU1200.26 PU1201.5 PU1201.19 PU1201.26 PU1202.5 PU1202.19 PU1202.26 PU1400.5 PU1400.19 PU1400.26 PU1401.5 PU1401.19 PU1401.26 PU1402.5 PU1402.19 PU1402.26 PU1600.5 PU1600.15 PU1600.16 PU1600.17 PU1600.18 PU1600.19 PU1600.20 PU1600.26 PU1600.41 PU1600.43 PU1700.3 PU1700.5 PU1700.19 PU1700.26 PU1800.2 PU1800.11 PWRSW1.2 Q22.3 Q29.1 Q29.4 Q87.3 Q347.1 Q347.4 Q353.1 Q353.4 Q367.1 Q367.4 QE2.1 QE2.4 QH3.3 QN5.3 QV1.3 R51.2 R60.2 R96.1 R97.1 R101.1 R106.1 R115.2 R116.2 R121.2 R122.2 R123.2 R128.2 R135.2 R136.2 R137.2 R138.2 R139.2 R141.2 R146.2 R147.2 R148.2 R150.2 R155.2 R156.2 R157.2 R158.2 R160.2 R222.1 R317.2 R336.1 R411.1 R416.2 R425.2 R432.1 R492.1 R519.1 R557.2 R558.2 R561.2 R562.2 R720.2 R723.2 R757.2 R758.2 R775.1 R803.2 R804.2 R836.2 R843.1 R869.1 R876.2 R879.1 R892.1 R935.2 R1069.2 R1137.2 R1138.2 R1970.1 R2160.2 R3722.2 R3727.2 R3730.1 R3741.2 R3750.2 RC122.2 RC171.1 RC173.2 RC174.1 RC175.1 RC176.1 RC178.2 RC179.2 RC181.2 RC222.2 RC223.1 RC224.1 RC227.1 RC228.1 RC229.1 RC306.1 RC318.2 RC319.1 RC321.2 RC322.2 RC323.2 RC324.2 RC325.2 RC328.1 RD10.2 RD16.2 RD18.1 RD21.1 RD22.1 RD28.2 RD29.2 RD30.2 RD31.2 RD34.2 RD35.2 RD36.2 RD39.2 RD40.2 RD42.2 RD44.2 RD47.2 RD54.2 RD55.2 RD56.2 RH70.2 RH74.2 RH83.1 RH193.2 RH196.2 RH214.2 RH308.2 RH313.1 RH322.1 RH323.1 RH324.1 RH325.1 RH326.1 RH334.2 RH356.2 RH357.2 RH358.2 RN51.2 RN53.2 RN55.2 RN57.2 RN58.2 RN60.2 RN100.2 RN101.2 RN102.2 RN103.2 RN105.2 RN106.2 RN107.2 RN111.2 RN117.2 RN118.2 RN119.2 RN120.2 RN124.2 RN125.2 RN126.2 RN128.2 RP4.5 RP4.6 RP4.7 RP4.8 RP7.1 RP7.2 RP7.3 RP7.4 RV28.1 RV35.2 RV36.2 RV37.2 RV38.2 RV39.2 RV40.2 RV41.2 RV45.1 RV48.2 RZ10.1 RZ20.2 RZ82.2 SW1.1 SW1.3 SW2.4 SW2.5 U3.3 U6.3 U8.1 U8.10 U8.36 U9.3 U14.3 U15.3 U16.3 U17.3 U25.3 U27.3 U31.49 U32.43 U33.2 U46.B27 U46.C1 U51.B11 U51.B18 U51.B54 U51.B60 U51.B66 U51.C1 U52.4 U53.4 U58.3 U88.5 U88.6 U88.7 U88.8 U629.8 U629.18 U629.33 U629.41 U629.57 U629.61 U630.8 U630.18 U630.33 U630.41 U630.57 U630.61 U631.8 U631.18 U631.33 U631.41 U631.57 U631.61 U636.8 U636.18 U636.33 U636.41 U636.57 U636.61 U637.9 U637.16 U637.23 U637.32 U637.33 U638.3 U639.2 UC1.3 UC3.3 UC4.3 UC5.3 UC6.3 UC7.3 UD1.3 UH1.A2 UH1.A3 UH1.A4 UH1.A18 UH1.A25 UH1.A32 UH1.A37 UH1.A42 UH1.A44 UH1.AA4 UH1.AA17 UH1.AA18 UH1.AA20 UH1.AA21 UH1.AA25 UH1.AA29 UH1.AA42 UH1.AB4 UH1.AB5 UH1.AB7 UH1.AB8 UH1.AB10 UH1.AB11 UH1.AB14 UH1.AB15 UH1.AB31 UH1.AB32 UH1.AB38 UH1.AC1 UH1.AC18 UH1.AC20 UH1.AC21 UH1.AC25 UH1.AC29 UH1.AC45 UH1.AD4 UH1.AD8 UH1.AD11 UH1.AD14 UH1.AD32 UH1.AD33 UH1.AD36 UH1.AE4 UH1.AE18 UH1.AE20 UH1.AE21 UH1.AE25 UH1.AE28 UH1.AE29 UH1.AE42 UH1.AF18 UH1.AF20 UH1.AF21 UH1.AF23 UH1.AF25 UH1.AF26 UH1.AF28 UH1.AF29 UH1.AG4 UH1.AG11 UH1.AG13 UH1.AG31 UH1.AG32 UH1.AG33 UH1.AG38 UH1.AH1 UH1.AH17 UH1.AH18 UH1.AH20 UH1.AH21 UH1.AH23 UH1.AH25 UH1.AH26 UH1.AH28 UH1.AH29 UH1.AH45 UH1.AJ10 UH1.AJ14 UH1.AJ15 UH1.AJ17 UH1.AJ18 UH1.AJ26 UH1.AJ28 UH1.AJ29 UH1.AJ31 UH1.AJ32 UH1.AJ36 UH1.AK4 UH1.AK42 UH1.AL4 UH1.AL10 UH1.AL11 UH1.AL13 UH1.AL17 UH1.AL19 UH1.AL24 UH1.AL29 UH1.AL32 UH1.AL33 UH1.AL38 UH1.AM15 UH1.AM17 UH1.AM19 UH1.AM22 UH1.AM24 UH1.AM27 UH1.AM29 UH1.AM45 UH1.AN4 UH1.AN7 UH1.AN8 UH1.AN10 UH1.AN11 UH1.AN22 UH1.AN27 UH1.AN31 UH1.AN39 UH1.AP4 UH1.AP11 UH1.AR5 UH1.AR7 UH1.AR9 UH1.AR33 UH1.AR34 UH1.AR42 UH1.AT9 UH1.AT10 UH1.AT15 UH1.AT36 UH1.AU1 UH1.AU7 UH1.AU35 UH1.AU36 UH1.AU39 UH1.AU45 UH1.AV6 UH1.AV17 UH1.AV24 UH1.AV27 UH1.AV31 UH1.AV33 UH1.AW9 UH1.AW13 UH1.AW19 UH1.AW29 UH1.AW37 UH1.AY38 UH1.AY45 UH1.B1 UH1.B2 UH1.B3 UH1.B6 UH1.B25 UH1.B37 UH1.B40 UH1.B44 UH1.B45 UH1.BA1 UH1.BB1 UH1.BB11 UH1.BB16 UH1.BB21 UH1.BB25 UH1.BB30 UH1.BB34 UH1.BC1 UH1.BC2 UH1.BD2 UH1.BD43 UH1.BD44 UH1.BD45 UH1.BE9 UH1.BE14 UH1.BE18 UH1.BE23 UH1.BE28 UH1.BE32 UH1.BE37 UH1.BE40 UH1.BE44 UH1.C1 UH1.C2 UH1.C4 UH1.C10 UH1.C28 UH1.C37 UH1.C42 UH1.D1 UH1.D10 UH1.D12 UH1.D15 UH1.D16 UH1.D17 UH1.D19 UH1.D21 UH1.D24 UH1.D25 UH1.D27 UH1.D29 UH1.D30 UH1.D31 UH1.D33 UH1.D35 UH1.D36 UH1.D45 UH1.E13 UH1.E15 UH1.E31 UH1.E33 UH1.F8 UH1.F44 UH1.G9 UH1.G42 UH1.H3 UH1.H17 UH1.H19 UH1.H22 UH1.H24 UH1.H27 UH1.H29 UH1.H35 UH1.J3 UH1.J5 UH1.J7 UH1.J10 UH1.J11 UH1.J39 UH1.K4 UH1.K10 UH1.K27 UH1.K33 UH1.K36 UH1.K42 UH1.K43 UH1.L4 UH1.L8 UH1.L12 UH1.L13 UH1.L15 UH1.L41 UH1.M35 UH1.M42 UH1.N4 UH1.N5 UH1.N10 UH1.N15 UH1.N19 UH1.N22 UH1.N24 UH1.N35 UH1.N36 UH1.N41 UH1.P17 UH1.P19 UH1.P22 UH1.P45 UH1.R5 UH1.R10 UH1.R14 UH1.R22 UH1.R29 UH1.R33 UH1.R38 UH1.T1 UH1.T2 UH1.T4 UH1.T42 UH1.U4 UH1.U8 UH1.U10 UH1.U11 UH1.U14 UH1.U15 UH1.U17 UH1.U18 UH1.U28 UH1.U29 UH1.U31 UH1.U32 UH1.U33 UH1.U38 UH1.V3 UH1.V18 UH1.V20 UH1.V21 UH1.V23 UH1.V25 UH1.V29 UH1.V45 UH1.W4 UH1.W8 UH1.W14 UH1.W31 UH1.W32 UH1.W33 UH1.W38 UH1.Y17 UH1.Y18 UH1.Y20 UH1.Y21 UH1.Y26 UH1.Y28 UH1.Y29 UN8.7 UN8.25 UN9.7 UN9.25 UV2.11 UV2.19 UV2.52 UV2.61 UZ18.5 UZ19.5 UZ20.11 UZ20.15 UZ21.5 UZ21.9 UZ22.5 UZ22.9 UZ23.5 UZ23.9 UZ24.5 UZ24.9 UZ25.11 UZ25.15 UZ26.11 UZ26.15 UZ27.5 UZ27.9 UZ28.5 UZ28.9 UZ29.2 UZ29.5 UZ29.11 UZ29.20 UZ29.21 UZ30.5 Y3.2 Y3.4
GND_CHASSIS: C485.2 R571.2 R572.2 R573.2 R574.2
GNDA_CHG: PC711.2 PC712.1 PC713.2 PC720.1 PC721.1 PJP700.1 PR718.2 PR720.2 PR744.2 PU700.29
VCC_EDRAM_SENSE: CPU1.BL15 PR506.1
VCC_EDRAM_SENSE_ED2: CPU1.BL22 RC174.2
VCC_EOPIO_SENSE: CPU1.BN15 PR1806.1
VCC_EOPIO_SENSE_ED3: CPU1.BP17 RC176.2
VCC_IO_SENSE: CPU1.H14 PR314.2
VCC_SA_SENSE: CPU1.M38 PR1108.1 PR1111.2
VCC_SENSE: CPU1.AG37 PR1119.2 PR1121.1 RC221.2
VCCGT_SENSE: CPU1.AH38 PR1124.1 PR1126.2
VCCGTX_SENSE: CPU1.AH36 PC1627.2 PC1640.1 PR1618.1 PR1621.2
VCCST_PWRGD: R43.2 RC159.1 RC164.1 UC6.4
VCCST_PWRGD_CPU: CPU1.H13 RC159.2
VCCST_PWRGD_EC: R43.1 U51.A44
VDD_1.2V: PC210.1 PR201.1 PR203.2 PU200.11
VDDP_1.2V: PC213.1 PR210.1 PU200.12
VIN_EDRAMP: PC505.1 PC508.1 PC509.1 PC510.1 PL500.2 PU500.1
VIN_EOPIOP: PC1805.1 PC1808.1 PC1809.1 PC1810.1 PL1800.2 PU1800.1
VSS_EDRAM_SENSE: CPU1.BM16 PR508.1
VSS_EDRAM_SENSE_ED2: CPU1.BM22 RC223.2
VSS_EOPIO_SENSE: CPU1.BM15 PR1808.1
VSS_EOPIO_SENSE_ED3: CPU1.BN16 RC224.2
VSS_IO_SENSE: CPU1.J14 PR316.2
VSS_SA_SENSE: CPU1.M37 PR1100.2 PR1106.1
VSS_SENSE: CPU1.AG38 PR1122.1 PR1125.2 RC221.1
VSSGT_SENSE: CPU1.AH37 PR1128.2 PR1129.1
VSSGTX_SENSE: CPU1.AH35 PC1614.1 PC1627.1 PR1617.1 PR1620.2
3301_ACAV_IN_NB: PR1019.1 PU1001.24
3301_DC_IN_SS: PR1010.2 PR1026.2 PU1001.34
3301_PWRSRC: PR1029.1 PU1001.15
81205_ALERT: PR1115.2 PU1100.41
81205_SCLK: PR1117.1 PU1100.42
81205_SDIO: PR1113.1 PU1100.40
81205_VR_HOT: PR1110.1 PU1100.39
81210_ADDR/VBOOT: PR1610.1 PU1600.30
81210_COMP: PC1608.1 PC1609.1 PU1600.34
81210_ILIM: PC1607.1 PR1604.1 PU1600.35
81210_IMAX: PR1612.1 PU1600.28
81210_SENSE_RETURN: PC1603.2 PC1690.2 PH1600.2 PL1600.3 PU1600.36
81210_SW1: PC1610.1 PL1600.1 PU1600.21 PU1600.22 PU1600.23
81210_SWN: PL1600.2 PR1601.2
81210_TSENSE: PC1612.2 PR1613.2 PU1600.29
81210_VSN: PC1614.2 PR1617.2 PU1600.33
81210_VSP: PR1618.2 PR1619.2 PU1600.32
+BL_PWR_SRC: C249.2 C296.1 JEDP1.1 JEDP1.2 JEDP1.3 JEDP1.4 Q21.1 Q21.2 Q21.5 Q21.6
+CAMERA_VDD: C299.1 C300.1 JEDP1.9 Q24.1
+CAP_LDO: C714.1 U46.B46
+CHAGER_SRC: PC705.1 PC706.1 PC707.1 PC708.1 PL700.1 PQ704.5
+COINCELL: JRTC1.1 PR1.1
+CPU_B+: PC1141.1 PC1142.1 PC1200.1 PC1201.1 PC1202.1 PC1203.1 PC1204.1 PC1205.1 PC1206.1 PC1207.1 PC1216.1 PC1217.1 PC1218.1 PC1219.1 PC1333.1 PC1334.1 PC1335.1 PC1336.1 PC1337.1 PC1338.1 PC1400.1 PC1401.1 PC1402.1 PC1403.1 PC1404.1 PC1405.1 PC1406.1 PC1407.1 PC1433.1 PC1434.1 PC1436.1 PC1437.1 PC1550.1 PC1551.1 PC1552.1 PC1553.1 PC1554.1 PC1555.1 PC1601.1 PC1602.1 PC1604.1 PC1605.1 PC1642.1 PC1643.1 PC1644.1 PC1700.1 PC1701.1 PC1707.1 PC1708.1 PL1100.1 PL1101.1 PR1150.1 PU1200.20 PU1200.21 PU1200.22 PU1200.23 PU1200.24 PU1200.25 PU1201.20 PU1201.21 PU1201.22 PU1201.23 PU1201.24 PU1201.25 PU1202.20 PU1202.21 PU1202.22 PU1202.23 PU1202.24 PU1202.25 PU1400.20 PU1400.21 PU1400.22 PU1400.23 PU1400.24 PU1400.25 PU1401.20 PU1401.21 PU1401.22 PU1401.23 PU1401.24 PU1401.25 PU1402.20 PU1402.21 PU1402.22 PU1402.23 PU1402.24 PU1402.25 PU1600.7 PU1600.11 PU1600.12 PU1600.13 PU1600.14 PU1600.42 PU1700.20 PU1700.21 PU1700.22 PU1700.23 PU1700.24 PU1700.25
+DC1_PWR_SRC: PC101.1 PC102.1 PC103.1 PC105.1 PC117.1 PL100.2 PQ100.5 PQ101.5 PU101.12
+DC_IN: PC9.2 PC15.1 PL4.2 PL5.2 PQ5.1 PQ5.2 PQ5.3 PQ8.3 PR16.1 PR19.1 PR737.1 PR1011.1
+DC_IN_SS: JIO2.19 PC14.1 PD700.2 PD701.3 PD1102.2 PQ5.5 PQ701.5 PR18.1
+DCIN: PC709.1 PR717.2 PU700.28
+DCIN_JACK: PC11.1 PD8.1 PJPDC1.7 PJPDC1.8 PJPDC1.9 PJPDC1.10 PL4.1 PL5.1
+DCPRTC: CH68.1 UH1.BA26
+DDR_VREF_B_DQ: CD136.1 CPU1.BR13 RD41.1
+DDR_VREF_CA: CD127.1 CPU1.BN13 RD23.1 RD45.1
+DIMM_DQ_R_VREF_B: CD137.1 CD138.1 CD140.1 RD11.1 RD41.2 RD43.2 RD44.1
+DOCK_PWR_BAR: C702.1 C703.1 CE6.1 D33.2 D33.3 JDOCK1.146 JDOCK1.147 JDOCK1.149 JDOCK1.150 PD701.2 PD1001.2 PD1001.3 PQ1001.5 PR1001.1 PR1007.1
+LCDVDD: C298.1 JEDP1.6 JEDP1.7 JEDP1.8 PJP26.1 R103.1
+LCDVDD_R: C396.1 PJP26.2 R42.1 U33.1
+LOM_VCT: C701.1 JDOCK1.116 JDOCK1.118
+MXM_PWR: PJP17.1 PJP18.1 Q186.5 Q186.6 Q186.7 Q186.8
+MXM_PWR_SRC: C1.1 C2.1 C3.1 C4.1 C776.1 JMXM1.1 JMXM1.2 JMXM1.3 JMXM1.4 JMXM1.5 JMXM1.6 JMXM1.7 JMXM1.8 JMXM1.9 JMXM1.10 JMXM1.11 JMXM1.12 JMXM1.13 JMXM1.14 JMXM1.15 JMXM1.16 JMXM1.17 JMXM1.18 PJP17.2 PJP18.2 R935.1
+MXM_SRC_EN#: C774.1 Q186.4 R940.2 R944.1
+NBDOCK_DC_IN_SS: C1425.1 JDOCK1.41 JIO2.21 PR1024.2
+PECI_VREF: C740.1 R866.1 U51.B51
+PWR_SRC: C297.1 C1426.1 C1427.1 JIO2.1 JIO2.3 JIO2.5 JIO2.7 JIO2.9 JIO2.11 JIO2.13 JIO2.15 PC1001.1 PC1002.1 PC1003.1 PD1001.1 PD1002.1 PJP200.1 PJP301.1 PJP800.1 PL1.1 PL100.1 PL500.1 PL700.2 PL1100.2 PL1101.2 PL1800.1 PQ1001.1 PQ1001.2 PQ1001.3 PQ1004.1 PQ1004.2 PQ1004.3 PR701.4 PR1029.2 Q21.4 R422.1 RZ73.1
+PWR_SRC_MXM: PC1.1 PC30.1 PC31.1 PL1.2 Q186.1 Q186.2 Q186.3 R940.1
+PWR_SRC_R: JUSH1.26 RZ73.2
+REGCTL_PNP10: L29.1 U31.7
+RSVD_VCC3P3_2: R554.2 U31.1
+RTC_CELL: JIO1.60 PC2.1 PD1.1 R810.1 R819.1 R870.1 R880.1 R1985.1 RH198.1 RH200.1 RH201.1 RH297.1
+RTC_CELL_VBAT: C1353.1 R1985.2 U51.B64
+SDC_IN: C1428.1 C1456.1 PC700.1 PD700.1 PJP1.2 PQ701.1 PQ701.2 PQ701.3 PR701.1 PR706.1 PR719.2 PR769.1 PR1015.1 PR1036.1
+SDC_IN_J: JIO2.2 JIO2.4 JIO2.6 JIO2.8 JIO2.10 JIO2.12 JIO2.14 JIO2.16 JIO2.18 JIO2.20 JIO2.22 JIO2.24 JIO2.26 PJP1.1
+SIM_PWR: C1356.1 JNGFF2.28 JSIM1.9
+TRM_CT1: C479.1 T156.3
+TRM_CT2: C480.1 T156.4
+TRM_CT3: C484.1 T156.9
+TRM_CT4: C486.1 T156.10
+U637_TPM: CZ5.1 RZ78.2 RZ79.2 U637.8
+U638_PWR: RH349.2 RH350.2 U638.5
+V_DDR_REF: PC209.1 PU200.4
+V_DDR_REFCA_A: CD75.1 CD76.1 CD77.1 CD78.1 CD128.1 JDIMM1.164 JDIMM2.164 RD9.2 RD10.1 RD23.2
+V_DDR_REFCA_B: CD79.1 CD80.1 CD81.1 CD82.1 CD143.1 JDIMM3.164 JDIMM4.164 RD11.2 RD14.1 RD45.2
+VCHGR: PC715.1 PC718.1 PC719.1 PQ1002.5 PQ1002.6 PQ1002.7 PQ1002.8 PR723.4
+VR_CAP: C779.1 U51.B12
+VTR_ADC: C736.1 C757.1 R845.2 U51.A58
A_ON: R432.2 R878.1 U51.A4
A_ON_R: R877.2 R878.2 UZ28.3
AAC_SMBCLK: R39.1 R41.1 R3738.2 T210.1(TP-1) U8.20
AAC_SMBDAT: R38.1 R40.1 R3739.2 T209.1(TP-1) U8.21
AAEN: U8.18 U46.B6
AC_DIS: PQ8.5 PR1030.2 U46.A50
AC_PRESENT: R835.2 RH85.2 U51.A54
AC_PRESENT_R: RH85.1 UH1.BB15
ACAV_DOCK_SRC#: JDOCK1.42 PR1013.2 PR1017.1 PU105.1
ACAV_IN: PR720.1 PR721.1 PR722.2 PR1021.1 U17.1 U51.A64
ACAV_IN_NB: PR743.2 PR1019.2 U51.B20
ACAVDK_SRC: PR1017.2 PU1001.4
ACAVIN: PR1021.2 PU1001.8
ADC_BYPASS: C36.1 U8.44
ADC_M: R410.2 R411.2 U8.9 U8.37 U8.42
ALW_PWRGD_3V_5V: PR108.1 UC4.2
ALWON: PR113.1 U51.A60
AUD_AZACPU_SCLK: CPU1.G27 RH38.1
AUD_AZACPU_SCLK_R: RH38.2 UH1.AM2
AUD_AZACPU_SDI: CPU1.G29 RC66.1
AUD_AZACPU_SDI_R: RC66.2 UH1.AN2
AUD_AZACPU_SDO: CPU1.G25 RH39.1
AUD_AZACPU_SDO_R: RH39.2 UH1.AM1
AUD_HP_NB_SENSE: JIO1.89 U46.A41
AUD_NB_MUTE#: JIO1.51 U46.A39
AUD_PWR_EN: T201.1(TP-1) UH1.BE21
AUX_EN_WOWL: R840.1 U46.B67
AUX_EN_WOWL_R: R723.1 R820.2 R840.2 UZ25.3
BAT1_LED#: R131.1 U51.B1
BAT2_LED#: R130.1 U51.A55
BATT_WHITE_LED: JLED1.4 R130.2
BATT_YELLOW_LED: JLED1.3 R131.2
BBS_BIT0: RH311.2 UH1.AT29
BC_CLK_ECE1117: JKBTP1.11 U51.A20
BC_CLK_ECE5048: U46.A30 U51.A43
BC_DAT_ECE1117: JKBTP1.13 R817.2 U51.B21
BC_DAT_ECE5048: R814.2 U46.B31 U51.B45
BC_INT#_ECE1117: JKBTP1.14 U51.A19
BC_INT#_ECE5048: U46.A29 U51.A42
BCM5882_ALERT#: JUSH1.14 U46.B62
BEEP: JIO1.53 U51.B19
BIA_PWM: D66.1 D68.1 D71.1 R208.1 R1137.1
BIA_PWM_EC: D71.2 U51.B25
BIA_PWM_PCH: D66.2 UH1.W36
BIOS_REC: RH76.2 UH1.AB33
BL_PWR_SRC_ON: C293.1 C297.2 Q21.3 R422.2 R423.1
BLK_MOSFET_GC: PR1006.2 PU1001.30
BLKNG_MOSFET_GC: PR1009.2 PU1001.20
BLUE_DOCK: JDOCK1.45 JMXM1.200
BOARD_ID: C744.1 R875.2 U51.B10
BOOT_1.2V: PR200.2 PU200.18
BQ24780_REGN: PC714.1 PD703.1 PR722.1 PU700.24
BREATH_LED#: JDOCK1.98 Q359.3 R955.1 U51.B57
BREATH_LED#_Q: JLED1.2 R955.2
BREATH_WHITE_LED: JPB1.3 R956.2
BST1: PR1615.1 PU1600.8
BST_3V: PR110.2 PU101.9
BST_3V_C: PC109.2 PR110.1
BST_5V: PR109.1 PU101.17
BST_5V_C: PC110.1 PR109.2
BST_+1VSP: PR801.1 PU800.10
BST_+V0.95SP: PC302.1 PU300.6
BST_+V0.95SP_C: PC302.2 PR312.1
BST_EDRAMP: PR503.1 PU500.9
BST_EOPIOP: PR1803.1 PU1800.9
BST_R_EDRAMP: PC500.1 PR503.2
BST_R_EOPIOP: PC1800.1 PR1803.2
BT_RADIO_DIS#: D36.1 U46.A13
BT_RADIO_DIS#_R: D36.2 JNGFF1.46
CAM_MIC_CBL_DET#: JEDP1.17 RH319.2 UH1.U43
CCD_OFF: T208.1(TP-1) U46.A9
CD3301_DCIN: PC1006.1 PR1011.2 PU1001.1
CD3301_NBDOCK_DC_IN_SS: PR1024.1 PU1001.19
CD3301_SDC_IN: PR1015.2 PU1001.6
CD_PBATT_OFF: PR1016.1 PU1001.26
CFG0: CPU1.BN25 JXDP1.9 RC126.1 RC321.1
CFG1: CPU1.BN27 JXDP1.11
CFG2: CPU1.BN26 JXDP1.15 RC181.1
CFG3: CPU1.BN28 JXDP1.17 RC121.2
CFG4: CPU1.BR20 JXDP1.27 RC322.1
CFG5: CPU1.BM20 JXDP1.29 RC323.1
CFG6: CPU1.BT20 JXDP1.33 RC324.1
CFG7: CPU1.BP20 JXDP1.35 RC325.1
CFG8: CPU1.BR23 JXDP1.10
CFG9: CPU1.BR22 JXDP1.12
CFG10: CPU1.BT23 JXDP1.16
CFG11: CPU1.BT22 JXDP1.18
CFG12: CPU1.BM19 JXDP1.28
CFG13: CPU1.BR19 JXDP1.30
CFG14: CPU1.BP19 JXDP1.34
CFG15: CPU1.BT19 JXDP1.36
CFG16: CPU1.BP23 JXDP1.6
CFG17: CPU1.BN23 JXDP1.4
CFG18: CPU1.BN22 JXDP1.24
CFG19: CPU1.BP22 JXDP1.22
CHARGER_SMBCLK: PR729.1 RP5.5 U51.B50
CHARGER_SMBDAT: PR727.1 RP5.6 U51.A47
CHG: PL701.2 PR723.1 PU700.17
CLK_DDC2_DOCK: JDOCK1.48 JMXM1.188 R5.2
CLK_KBD: JDOCK1.78 RP6.6 U51.A38
CLK_MSE: JDOCK1.71 RP6.5 U51.A39
CLK_PCI_5048: CH42.1 R795.1 RH96.2 U46.A28
CLK_PCI_DOCK: CH51.1 JDOCK1.121 R756.1 RH98.2
CLK_PCI_LPDEBUG: CH50.1 JLPDE1.10 R3757.1 RH99.2
CLK_PCI_MEC: CH49.1 R885.1 RH97.2 U51.A29
CLK_PCIE_N1: JIO1.61 UH1.L7
CLK_PCIE_N2: JNGFF2.45 UH1.D3
CLK_PCIE_N3: U31.45 UH1.E5
CLK_PCIE_N4: JIO2.110 UH1.D5
CLK_PCIE_N5: JSATA2.15 UH1.D8
CLK_PCIE_N6: JNGFF1.41 UH1.R8
CLK_PCIE_N7: JNGFF3.53 UH1.U5
CLK_PCIE_P1: JIO1.59 UH1.L5
CLK_PCIE_P2: JNGFF2.47 UH1.F2
CLK_PCIE_P3: U31.44 UH1.G4
CLK_PCIE_P4: JIO2.108 UH1.E6
CLK_PCIE_P5: JSATA2.14 UH1.D7
CLK_PCIE_P6: JNGFF1.39 UH1.R7
CLK_PCIE_P7: JNGFF3.55 UH1.U7
CLK_PEG_N0: JMXM1.183 UH1.N7
CLK_PEG_P0: JMXM1.185 UH1.N8
CLK_SIO_14M: T207.1(TP-1) U46.A32
CLK_TP_SIO: CZ31.1 R400.1 RZ19.2 U51.A37
CLK_TP_SIO_R: JKBTP1.7 R400.2
CLKDET#: JSATA2.16 R3753.2 UH1.BB22
CLKREQ_PCIE#1: JIO1.65 RH124.1 UH1.AW24
CLKREQ_PCIE#2: JNGFF2.44 RH125.1 UH1.AT24
CLKREQ_PCIE#3: RH126.1 U31.48 UH1.BD25
CLKREQ_PCIE#4: JIO2.104 RH127.1 UH1.BB24
CLKREQ_PCIE#5: JSATA2.18 RH131.1 UH1.BE25
CLKREQ_PCIE#6: JNGFF1.45 RH132.1 UH1.AT33
CLKREQ_PCIE#7: JNGFF3.52 RH133.1 UH1.AR31
CLKREQ_PEG#0: QH3.1 RH128.1 UH1.BC24
CLKRUN#: RH202.1 U46.B20 U51.A32 UH1.AW22
CMPIN: PC737.1 PR737.2 PR738.1 PR745.1 PU700.13
CMPOUT: PC741.2 PR738.2 PR740.1 PR743.1 PU700.14
COMP_3PH_A: PC1113.1 PR1133.1 PU1100.6
COMP_3PH_B: PC1117.2 PC1119.2 PU1100.33
CONTACTLESS_DET#: JUSH1.4 RH90.2 UH1.U36
CPU_2_PCH_TRIGGER: RC177.1 UH1.AK1
CPU_2_PCH_TRIGGER_R: CPU1.J23 RC177.2
CPU_24MHZ_R_D: CPU1.E31 RH169.1
CPU_24MHZ_R_D#: CPU1.D31 RH170.1
CPU_DP1_AUXN: C588.1 CPU1.E27
CPU_DP1_AUXN_C: C588.2 U629.29
CPU_DP1_AUXP: C591.1 CPU1.D27
CPU_DP1_AUXP_C: C591.2 U629.30
CPU_DP1_N0: C597.1 CPU1.K37
CPU_DP1_N0_C: C597.2 U629.12
CPU_DP1_N1: C626.1 CPU1.J34
CPU_DP1_N1_C: C626.2 U629.15
CPU_DP1_N2: C629.1 CPU1.H36
CPU_DP1_N2_C: C629.2 U629.17
CPU_DP1_N3: C584.1 CPU1.J38
CPU_DP1_N3_C: C584.2 U629.20
CPU_DP1_P0: C593.1 CPU1.K36
CPU_DP1_P0_C: C593.2 U629.11
CPU_DP1_P1: C598.1 CPU1.J35
CPU_DP1_P1_C: C598.2 U629.14
CPU_DP1_P2: C628.1 CPU1.H37
CPU_DP1_P2_C: C628.2 U629.16
CPU_DP1_P3: C586.1 CPU1.J37
CPU_DP1_P3_C: C586.2 U629.19
CPU_DP2_AUXN: C548.1 CPU1.E26
CPU_DP2_AUXN_C: C548.2 U631.29
CPU_DP2_AUXP: C552.1 CPU1.F26
CPU_DP2_AUXP_C: C552.2 U631.30
CPU_DP2_N0: C576.1 CPU1.H33
CPU_DP2_N0_C: C576.2 U631.12
CPU_DP2_N1: C580.1 CPU1.G38
CPU_DP2_N1_C: C580.2 U631.15
CPU_DP2_N2: C583.1 CPU1.F35
CPU_DP2_N2_C: C583.2 U631.17
CPU_DP2_N3: C535.1 CPU1.E36
CPU_DP2_N3_C: C535.2 U631.20
CPU_DP2_P0: C574.1 CPU1.H34
CPU_DP2_P0_C: C574.2 U631.11
CPU_DP2_P1: C578.1 CPU1.F37
CPU_DP2_P1_C: C578.2 U631.14
CPU_DP2_P2: C581.1 CPU1.F34
CPU_DP2_P2_C: C581.2 U631.16
CPU_DP2_P3: C546.1 CPU1.E37
CPU_DP2_P3_C: C546.2 U631.19
CPU_DP3_AUXN: C1446.1 CPU1.B27
CPU_DP3_AUXN_C: C1446.2 U636.29
CPU_DP3_AUXP: C1447.1 CPU1.A27
CPU_DP3_AUXP_C: C1447.2 U636.30
CPU_DP3_N0: C1450.1 CPU1.D34
CPU_DP3_N0_C: C1450.2 U636.12
CPU_DP3_N1: C1451.1 CPU1.B34
CPU_DP3_N1_C: C1451.2 U636.15
CPU_DP3_N2: C1454.1 CPU1.E33
CPU_DP3_N2_C: C1454.2 U636.17
CPU_DP3_N3: C1452.1 CPU1.B33
CPU_DP3_N3_C: C1452.2 U636.20
CPU_DP3_P0: C1448.1 CPU1.C34
CPU_DP3_P0_C: C1448.2 U636.11
CPU_DP3_P1: C1453.1 CPU1.B36
CPU_DP3_P1_C: C1453.2 U636.14
CPU_DP3_P2: C1449.1 CPU1.F33
CPU_DP3_P2_C: C1449.2 U636.16
CPU_DP3_P3: C1455.1 CPU1.C33
CPU_DP3_P3_C: C1455.2 U636.19
CPU_EDP_HPD: U630.3 UH1.BD7
CPU_EOPIO_RCOMP: CPU1.BT29 RC227.2
CPU_MSM#: CPU1.AW13 PR1815.2
CPU_MSM#_ED2: CPU1.AY13 RC230.2
CPU_VIDALERT#: CPU1.BH31 RC156.2
CPU_XDP_HOOK6: JXDP1.46 RC6.1 RC144.1
CPU_XDP_PRDY#: CPU1.BP27 JXDP1.5 RC314.1 T189.1(TP-1)
CPU_XDP_PREQ#: CPU1.BL30 JXDP1.3 RC138.1 RC315.1 T190.1(TP-1)
CPU_XDP_PRS: JXDP1.60 RC127.1
CPU_XDP_TCLK: CPU1.BR28 JXDP1.57 RC143.1 RC306.2 T181.1(TP-1)
CPU_XDP_TDI: CPU1.BL32 JXDP1.56 RC308.1 T185.1(TP-1)
CPU_XDP_TDO: CPU1.BT28 JXDP1.52 RC135.2 RC309.1 T184.1(TP-1)
CPU_XDP_TMS: CPU1.BP28 JXDP1.58 RC307.1 T180.1(TP-1)
CPU_XDP_TRST#: CPU1.BP30 JXDP1.54 RC328.2 T179.1(TP-1) UH1.AY5
CPU_ZVM#: CPU1.AT13 PR501.2 PR1801.2
CPU_ZVM#_ED2: CPU1.AU13 RC230.1
CS_1.2V: PR201.2 PU200.13
CS_CTR: RH342.2 UH1.AA44
CSCOMP_3PH_A: PC1121.1 PC1122.2 PH1101.1 PR1138.1 PR1140.1 PU1100.8
CSCOMP_3PH_B: PC1124.1 PC1125.1 PH1102.1 PR1139.2 PR1141.1 PU1100.31
CSN_1PH: PC1102.1 PC1104.1 PH1100.1 PL1700.3 PU1100.48
CSON_1: PC710.2 PC713.1 PR723.3 PR762.1
CSOP_1: PC710.1 PC712.2 PR723.2 PR761.1
CSP1_3PH_A: PC1131.2 PR1154.2 PU1100.11
CSP1_3PH_B: PC1132.2 PR1160.1 PU1100.28
CSP2_3PH_A: PC1133.2 PR1161.2 PU1100.12
CSP2_3PH_B: PC1134.2 PR1162.1 PU1100.27
CSP3_3PH_A: PC1135.2 PR1163.2 PR1169.2 PU1100.13
CSP3_3PH_B: PC1136.2 PR1164.1 PR1170.2 PU1100.26
CSREF_3PH_A: PC1123.2 PC1131.1 PC1133.1 PC1135.1 PR1204.2 PR1205.2 PR1210.2 PU1100.10
CSREF_3PH_B: PC1126.1 PC1132.1 PC1134.1 PC1136.1 PR1404.2 PR1405.2 PR1410.2 PU1100.29
CSS_GC: PR703.2 PR773.1 PU1001.10
CSS_GC_1: PC700.2 PQ700.2 PQ702.2 PR703.1 PR771.1
CSSN_1: PQ702.3 PQ706.3 PR704.1 PR711.1 PR712.1
CSSN_2: PC703.2 PC704.1 PR711.2 PU700.1
CSSP_1: PQ700.3 PQ703.3 PR704.2 PR709.1 PR710.1
CSSP_2: PC702.2 PC703.1 PR710.2 PU700.2
CSSUM_3PH_A: PC1121.2 PC1122.1 PR1142.2 PR1143.2 PR1146.2 PR1148.2 PU1100.9
CSSUM_3PH_B: PC1124.2 PC1125.2 PR1144.2 PR1145.1 PR1147.1 PR1149.1 PU1100.30
CV2_ON: JUSH1.24 U51.A9
D_CLKRUN#: JDOCK1.111 RP3.8 U46.A19
D_DLDRQ1#: JDOCK1.117 RP3.6 U46.B24
D_LAD0: JDOCK1.97 U46.B29
D_LAD1: JDOCK1.99 U46.B28
D_LAD2: JDOCK1.103 U46.A25
D_LAD3: JDOCK1.105 U46.A24
D_LFRAME#: JDOCK1.109 U46.B23
D_SERIRQ: JDOCK1.115 RP3.7 U46.A20
DAI_12MHZ#: JDOCK1.89 JIO1.83 RE11.1
DAI_BCLK#: JDOCK1.77 JIO1.41 RE12.1
DAI_DI: JDOCK1.83 JIO1.37
DAI_DO#: JDOCK1.85 JIO1.39
DAI_LRCK#: JDOCK1.79 JIO1.43
DAT_DDC2_DOCK: JDOCK1.46 JMXM1.186 R3.2
DAT_KBD: JDOCK1.80 RP6.8 U51.B41
DAT_MSE: JDOCK1.73 RP6.7 U51.B42
DAT_TP_SIO: CZ30.1 R370.1 RZ18.2 U51.B40
DAT_TP_SIO_R: JKBTP1.8 R370.2
DC_BLOCK_GC: PQ708.4 PR700.1 PU1001.7
DCIN_ACOK#: JIO2.36 PQ1074.5
DDR4_DRAMRST#_PCH: CD16.1 RD6.1 RD7.2 RD15.1 UH1.BC14
DDR_A_ACT#: CPU1.AU3 JDIMM1.114 JDIMM2.114
DDR_A_ALERT#: CPU1.AU5 JDIMM1.116 JDIMM2.116
DDR_A_BA0: CPU1.AH5 JDIMM1.150 JDIMM2.150
DDR_A_BA1: CPU1.AH1 JDIMM1.145 JDIMM2.145
DDR_A_BG0: CPU1.AU1 JDIMM1.115 JDIMM2.115
DDR_A_BG1: CPU1.AU2 JDIMM1.113 JDIMM2.113
DDR_A_CB0: CPU1.BA2 JDIMM1.87 JDIMM2.87
DDR_A_CB1: CPU1.BA1 JDIMM1.88 JDIMM2.88
DDR_A_CB2: CPU1.AY4 JDIMM1.105 JDIMM2.105
DDR_A_CB3: CPU1.AY5 JDIMM1.101 JDIMM2.101
DDR_A_CB4: CPU1.BA5 JDIMM1.92 JDIMM2.92
DDR_A_CB5: CPU1.BA4 JDIMM1.91 JDIMM2.91
DDR_A_CB6: CPU1.AY1 JDIMM1.104 JDIMM2.104
DDR_A_CB7: CPU1.AY2 JDIMM1.100 JDIMM2.100
DDR_A_CKE0: CPU1.AT1 JDIMM2.109
DDR_A_CKE1: CPU1.AT2 JDIMM2.110
DDR_A_CKE2: CPU1.AT3 JDIMM1.109
DDR_A_CKE3: CPU1.AT5 JDIMM1.110
DDR_A_CLK0: CPU1.AG1 JDIMM2.137
DDR_A_CLK1: CPU1.AK2 JDIMM2.138
DDR_A_CLK2: CPU1.AL3 JDIMM1.137
DDR_A_CLK3: CPU1.AL2 JDIMM1.138
DDR_A_CLK#0: CPU1.AG2 JDIMM2.139
DDR_A_CLK#1: CPU1.AK1 JDIMM2.140
DDR_A_CLK#2: CPU1.AK3 JDIMM1.139
DDR_A_CLK#3: CPU1.AL1 JDIMM1.140
DDR_A_CS#0: CPU1.AD5 JDIMM2.149
DDR_A_CS#1: CPU1.AE2 JDIMM2.157
DDR_A_CS#2: CPU1.AD2 JDIMM1.149
DDR_A_CS#3: CPU1.AE5 JDIMM1.157
DDR_A_D0: CPU1.BR6 JDIMM1.7 JDIMM2.8
DDR_A_D1: CPU1.BT6 JDIMM1.4 JDIMM2.3
DDR_A_D2: CPU1.BP3 JDIMM1.20 JDIMM2.21
DDR_A_D3: CPU1.BR3 JDIMM1.21 JDIMM2.20
DDR_A_D4: CPU1.BN5 JDIMM1.3 JDIMM2.4
DDR_A_D5: CPU1.BP6 JDIMM1.8 JDIMM2.7
DDR_A_D6: CPU1.BP2 JDIMM1.16 JDIMM2.17
DDR_A_D7: CPU1.BN3 JDIMM1.17 JDIMM2.16
DDR_A_D8: CPU1.BL4 JDIMM1.28 JDIMM2.29
DDR_A_D9: CPU1.BL5 JDIMM1.24 JDIMM2.25
DDR_A_D10: CPU1.BL2 JDIMM1.38 JDIMM2.37
DDR_A_D11: CPU1.BM1 JDIMM1.42 JDIMM2.41
DDR_A_D12: CPU1.BK4 JDIMM1.29 JDIMM2.28
DDR_A_D13: CPU1.BK5 JDIMM1.25 JDIMM2.24
DDR_A_D14: CPU1.BK1 JDIMM1.41 JDIMM2.42
DDR_A_D15: CPU1.BK2 JDIMM1.37 JDIMM2.38
DDR_A_D16: CPU1.BG4 JDIMM1.46 JDIMM2.45
DDR_A_D17: CPU1.BG5 JDIMM1.50 JDIMM2.49
DDR_A_D18: CPU1.BF4 JDIMM1.63 JDIMM2.62
DDR_A_D19: CPU1.BF5 JDIMM1.58 JDIMM2.59
DDR_A_D20: CPU1.BG2 JDIMM1.49 JDIMM2.50
DDR_A_D21: CPU1.BG1 JDIMM1.45 JDIMM2.46
DDR_A_D22: CPU1.BF1 JDIMM1.59 JDIMM2.58
DDR_A_D23: CPU1.BF2 JDIMM1.62 JDIMM2.63
DDR_A_D24: CPU1.BD2 JDIMM1.66 JDIMM2.67
DDR_A_D25: CPU1.BD1 JDIMM1.70 JDIMM2.71
DDR_A_D26: CPU1.BC4 JDIMM1.80 JDIMM2.79
DDR_A_D27: CPU1.BC5 JDIMM1.79 JDIMM2.80
DDR_A_D28: CPU1.BD5 JDIMM1.71 JDIMM2.70
DDR_A_D29: CPU1.BD4 JDIMM1.67 JDIMM2.66
DDR_A_D30: CPU1.BC1 JDIMM1.83 JDIMM2.84
DDR_A_D31: CPU1.BC2 JDIMM1.84 JDIMM2.83
DDR_A_D32: CPU1.AB1 JDIMM1.174 JDIMM2.173
DDR_A_D33: CPU1.AB2 JDIMM1.169 JDIMM2.170
DDR_A_D34: CPU1.AA4 JDIMM1.186 JDIMM2.187
DDR_A_D35: CPU1.AA5 JDIMM1.182 JDIMM2.183
DDR_A_D36: CPU1.AB5 JDIMM1.170 JDIMM2.169
DDR_A_D37: CPU1.AB4 JDIMM1.173 JDIMM2.174
DDR_A_D38: CPU1.AA2 JDIMM1.183 JDIMM2.182
DDR_A_D39: CPU1.AA1 JDIMM1.187 JDIMM2.186
DDR_A_D40: CPU1.V5 JDIMM1.190 JDIMM2.191
DDR_A_D41: CPU1.V2 JDIMM1.195 JDIMM2.194
DDR_A_D42: CPU1.U1 JDIMM1.208 JDIMM2.207
DDR_A_D43: CPU1.U2 JDIMM1.203 JDIMM2.204
DDR_A_D44: CPU1.V1 JDIMM1.191 JDIMM2.190
DDR_A_D45: CPU1.V4 JDIMM1.194 JDIMM2.195
DDR_A_D46: CPU1.U5 JDIMM1.207 JDIMM2.208
DDR_A_D47: CPU1.U4 JDIMM1.204 JDIMM2.203
DDR_A_D48: CPU1.R2 JDIMM1.212 JDIMM2.211
DDR_A_D49: CPU1.P5 JDIMM1.216 JDIMM2.215
DDR_A_D50: CPU1.R4 JDIMM1.211 JDIMM2.212
DDR_A_D51: CPU1.P4 JDIMM1.229 JDIMM2.228
DDR_A_D52: CPU1.R5 JDIMM1.215 JDIMM2.216
DDR_A_D53: CPU1.P2 JDIMM1.224 JDIMM2.225
DDR_A_D54: CPU1.R1 JDIMM1.225 JDIMM2.224
DDR_A_D55: CPU1.P1 JDIMM1.228 JDIMM2.229
DDR_A_D56: CPU1.M4 JDIMM1.232 JDIMM2.233
DDR_A_D57: CPU1.M1 JDIMM1.233 JDIMM2.232
DDR_A_D58: CPU1.L4 JDIMM1.249 JDIMM2.250
DDR_A_D59: CPU1.L2 JDIMM1.246 JDIMM2.245
DDR_A_D60: CPU1.M5 JDIMM1.236 JDIMM2.237
DDR_A_D61: CPU1.M2 JDIMM1.237 JDIMM2.236
DDR_A_D62: CPU1.L5 JDIMM1.245 JDIMM2.246
DDR_A_D63: CPU1.L1 JDIMM1.250 JDIMM2.249
DDR_A_DQS0: CPU1.BP5 JDIMM1.13 JDIMM2.13
DDR_A_DQS1: CPU1.BK3 JDIMM1.34 JDIMM2.34
DDR_A_DQS2: CPU1.BF3 JDIMM1.55 JDIMM2.55
DDR_A_DQS3: CPU1.BC3 JDIMM1.76 JDIMM2.76
DDR_A_DQS4: CPU1.AB3 JDIMM1.179 JDIMM2.179
DDR_A_DQS5: CPU1.V3 JDIMM1.200 JDIMM2.200
DDR_A_DQS6: CPU1.R3 JDIMM1.221 JDIMM2.221
DDR_A_DQS7: CPU1.M3 JDIMM1.242 JDIMM2.242
DDR_A_DQS8: CPU1.AY3 JDIMM1.97 JDIMM2.97
DDR_A_DQS#0: CPU1.BR5 JDIMM1.11 JDIMM2.11
DDR_A_DQS#1: CPU1.BL3 JDIMM1.32 JDIMM2.32
DDR_A_DQS#2: CPU1.BG3 JDIMM1.53 JDIMM2.53
DDR_A_DQS#3: CPU1.BD3 JDIMM1.74 JDIMM2.74
DDR_A_DQS#4: CPU1.AA3 JDIMM1.177 JDIMM2.177
DDR_A_DQS#5: CPU1.U3 JDIMM1.198 JDIMM2.198
DDR_A_DQS#6: CPU1.P3 JDIMM1.219 JDIMM2.219
DDR_A_DQS#7: CPU1.L3 JDIMM1.240 JDIMM2.240
DDR_A_DQS#8: CPU1.BA3 JDIMM1.95 JDIMM2.95
DDR_A_DRAMRST#: CD92.1 CD122.1 JDIMM1.108 JDIMM2.108 RD6.2
DDR_A_MA0: CPU1.AH3 JDIMM1.144 JDIMM2.144
DDR_A_MA1: CPU1.AP4 JDIMM1.133 JDIMM2.133
DDR_A_MA2: CPU1.AN4 JDIMM1.132 JDIMM2.132
DDR_A_MA3: CPU1.AP5 JDIMM1.131 JDIMM2.131
DDR_A_MA4: CPU1.AP2 JDIMM1.128 JDIMM2.128
DDR_A_MA5: CPU1.AP1 JDIMM1.126 JDIMM2.126
DDR_A_MA6: CPU1.AP3 JDIMM1.127 JDIMM2.127
DDR_A_MA7: CPU1.AN1 JDIMM1.122 JDIMM2.122
DDR_A_MA8: CPU1.AN3 JDIMM1.125 JDIMM2.125
DDR_A_MA9: CPU1.AT4 JDIMM1.121 JDIMM2.121
DDR_A_MA10: CPU1.AH2 JDIMM1.146 JDIMM2.146
DDR_A_MA11: CPU1.AN2 JDIMM1.120 JDIMM2.120
DDR_A_MA12: CPU1.AU4 JDIMM1.119 JDIMM2.119
DDR_A_MA13: CPU1.AE3 JDIMM1.158 JDIMM2.158
DDR_A_MA14: CPU1.AG4 JDIMM1.151 JDIMM2.151
DDR_A_MA15: CPU1.AD1 JDIMM1.156 JDIMM2.156
