# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_SIDE_LED: length 17.7
  TOP w0.254: R943.2 307.72,5.68 v2(307.72,4.75) 307.72,4.48 306.76,3.51 293.27,3.51 293.05,3.74 JLED1.5
SATAE_LED#: length 352.8
  TOP w0.102: v2(297.1,4.53) 297.86,5.29 D100.1 297.86,6.65 R387.2 ; v2(1.84,35.66) v1(4.5,35.66) U639.1
  IN1 w0.109: v2(171.6,8.11) 171.69,8.11 172.5,8.92 172.69,8.92 173.69,9.93 178.22,9.93 179.61,8.54 179.61,6.66 181.9,4.37 227.09,4.37 228.4,5.68 241.55,5.68 242.68,4.56 244.38,4.56 244.52,4.7 269.86,4.7 270.52,4.03 290.31,4.03 290.78,4.5 293.29,4.5 293.75,4.96 296.67,4.96 v2(297.1,4.53)
  IN3 w0.127: v2(171.6,8.11) 171.33,8.38 160.98,8.38 158.59,10.77 144.06,10.77 142.51,9.23 139.38,9.23 137.26,7.11 128.74,7.11 128.07,7.78 109.92,7.78 107.57,10.13 92.09,10.13 89.28,12.94 72.07,12.94 70.5,11.37 65.01,11.37 63.9,10.26 57.94,10.26 56.46,8.77 56.46,8.46 56.08,8.08 55.06,8.08 54.43,8.72 50.08,8.72 49.53,8.16 45.87,8.16 45.63,8.4 40.93,8.4 39.42,6.89 29.17,6.89 25.74,3.47 5.42,3.47 4.18,4.71 4.18,14.16 7.73,17.7 7.73,30.71 2.77,35.66 v2(1.84,35.66)
SATAGP1: length 1.7
  TOP w0.089: UH1.AG35 v2(118.47,115.33)
  BOTTOM w0.089: v2(118.47,115.33) 118.58,115.45 RH323.2
SATAGP5: length 1.6
  TOP w0.089: UH1.AD38 v2(116.94,114.29)
  BOTTOM w0.089: RH325.2 117.1,114.13 v2(116.94,114.29)
SATAGP6: length 5.4
  TOP w0.089: 112.37,113.76 112.77,113.76 112.98,113.56 113,113.56 113.01,113.54 113.37,113.54 113.53,113.38 113.61,113.38 113.65,113.42 113.88,113.42 113.92,113.38 114.09,113.38 114.27,113.2 UH1.AC43
  TOP w0.102: RH326.2 110.39,112.15 111.22,112.98 v1(111.22,113.15) 111.22,113.4 111.36,113.54 111.78,113.54 112.01,113.76 112.37,113.76
SATAGP7: length 5.5
  TOP w0.089: UH1.AB44 113.37,112.51 113.07,112.51 112.81,112.25 112.37,112.25
  TOP w0.102: 112.37,112.25 112.06,112.25 v1(111.54,111.73) 110.95,111.15 109.39,111.15 109.26,111.27 RH322.2
SBIOS_TX: length 120.3
  TOP w0.089: 112.37,121.23 112.37,121.15 112.82,120.7 113.37,120.7 113.46,120.6 113.49,120.6 UH1.AV44
  TOP w0.102: v2(108.94,118.43) 108.89,118.38 108.26,118.38 RH71.2 108.23,119.15 108.51,119.43 109.58,119.43 109.81,119.65 109.81,121.66 110.24,122.09 111.51,122.09 112.37,121.23 ; v2(109.72,94.46) 109.16,95.02 108.68,95.02 106.22,97.47 v1(105.47,97.47) 104.12,97.47 v2(102.81,96.17)
  IN2 w0.127: v2(174.86,101.55) 174.53,101.87 166.28,101.87 165.74,101.33 163.97,101.33 159.82,105.48 157.78,105.48 155.5,103.21 151.14,103.21 148.1,100.17 146.56,100.17 144.59,98.2 135.27,98.2 132.17,95.1 110.36,95.1 v2(109.72,94.46) ; v2(108.94,118.43) 109.34,118.04 109.34,117.63 109.3,117.6 109.3,116.8 105.71,113.2 105.71,112.67 104.67,111.63 103.56,111.63 100.69,108.76 100.69,105.42 99.8,104.53 99.8,101.45 101.1,100.14 101.1,97.88 v2(102.81,96.17)
  BOTTOM w0.102: R863.2 175.6,101.57 175.58,101.55 v2(174.86,101.55)
SIM_DET: length 26.4
  IN3 w0.127: v2(336.19,29.1) 335.55,28.47 334.75,28.47 334.46,28.76 327.24,28.76 325.96,30.04 325.96,36.77 324.45,38.29 v2(322.89,38.29)
  BOTTOM w0.102: v2(322.89,38.29) 322.61,38.57 322.61,39.4 322.34,39.68 JNGFF2.58 ; RZ113.2 336.19,28.2 v2(336.19,29.1) 336.19,29.59 v1(336.26,29.66)
SIM_DET_R: length 4.2
  BOTTOM w0.102: RZ113.1 336.87,26.14 v1(337.6,26.14) 339.77,26.14 JSIM1.1
SIO_EXT_SCI#: length 190.2
  TOP w0.089: v2(120.44,120.27) 120.59,120.41 UH1.AV29
  IN2 w0.127: v2(194.93,106.77) 195.45,106.26 198.92,106.26 200.17,105.01 200.17,104.39 200.17,104.39 200.17,103.97 200.71,103.43 200.84,103.43 201.41,103.43 201.89,102.95 202.88,102.95 203.2,102.64 205.87,102.64 206.4,102.1 206.47,102.04 208.7,102.04 209.3,101.44 210.96,101.44 212.29,100.12 217.08,100.12 217.15,100.19 217.51,100.19 217.97,99.73 218.31,99.73 219.12,100.54 219.12,102.38 v2(219.23,102.49) ; v2(117.75,128.32) 119.97,128.32 121.98,130.32 123.94,130.32 124.63,131.01 127.98,131.01 129.22,132.24 132.06,132.24 135.19,135.37 139.76,135.37 142.38,137.99 149.29,137.99 149.96,138.67 152.38,138.67 153.47,139.76 155.41,139.76 156.72,138.45 159.8,138.45 162.06,136.2 165.15,136.2 166.1,135.24 167.19,135.24 167.45,135.5 168.01,135.5 169.03,134.49 171.85,134.49 172.33,134.96 174.89,134.96 175.09,134.75 181.14,134.75 181.16,134.73 184.09,134.73 184.51,135.15 186.3,135.15 187.48,133.97 193.12,133.97 194.56,135.4 201.59,135.4 202.04,135.85 212.18,135.85 v2(213.02,136.69)
  IN3 w0.127: v2(114.83,127.3) 116.73,127.3 v2(117.75,128.32) ; v2(213.02,136.69) 213.07,136.69 216.2,133.57 216.2,129.31 216.86,128.65 216.86,125.05 217.44,124.46 217.44,123.73 217.24,123.53 217.24,115.73 217.99,114.98 217.99,113.18 219.99,111.17 219.99,110.3 220.12,110.17 220.12,107.88 219.63,107.38 219.63,106.51 220.12,106.01 220.12,104.84 220.41,104.55 220.41,104.17 220.18,103.94 219.61,103.94 219.12,103.45 219.12,102.61 v2(219.23,102.49)
  BOTTOM w0.089: 114.9,124.36 115.35,123.91 115.35,123.67 115.87,123.15 115.87,123.14 115.93,123.08 115.93,122.42 117.04,121.31 117.71,121.31 118.59,120.42 120.29,120.42 v2(120.44,120.27) ; RH339.2 117.85,128.21 v2(117.75,128.32)
  BOTTOM w0.102: v2(114.83,127.3) 115.22,126.92 115.22,125.74 114.74,125.26 114.74,124.52 114.9,124.36 ; U51.A33 195.05,107.09 194.97,107.02 194.97,106.81 v2(194.93,106.77)
SIO_EXT_SMI#: length 142.6
  TOP w0.089: UH1.AF41 114.72,115.21 114.38,115.21 114.38,115.21 114.17,115.21 114.1,115.27 113.92,115.27 113.88,115.24 113.69,115.24 113.66,115.21 113.45,115.21 113.43,115.2 113.38,115.15 113.31,115.15 113.31,115.14 112.37,115.14
  TOP w0.102: RH310.1 109.47,115.4 110.17,115.4 v2(110.18,115.42) 110.18,115.69 110.3,115.81 111.71,115.81 112.37,115.14
  IN1 w0.089: 113.64,115.48 114.29,116.14 114.33,116.14 114.37,116.17 127.16,116.17 127.42,115.91 132.37,115.91 134.92,118.46 134.92,120.54 135.75,121.37 136.73,121.37 137.44,122.09 137.44,123.06 139.49,125.11 139.49,125.31
  IN1 w0.109: 113.64,115.48 113.11,114.96 110.41,114.96 110.18,115.18 v2(110.18,115.42) ; v2(158.34,130.51) 158.34,129.71 155.98,127.36 153.48,127.36 153.21,127.09 152.82,127.09 152.47,126.75 151.24,126.75 151.11,126.61 150.35,126.61 148.9,125.17 147.91,125.17 147.03,124.29 142.68,124.29 141.67,125.3 141.67,125.86 141.11,126.42 140.32,126.42 139.49,125.59 139.49,125.31
  IN3 w0.127: v2(210.91,125.92) 210.91,125.89 212.01,124.79 212.01,113.95 211.56,113.49 210.86,113.49 210.09,112.72 v2(207.3,112.72)
  IN4 w0.109: v2(158.34,130.51) 158.96,131.13 161.7,131.13 163.91,128.92 168.25,128.92 170.25,126.92 173.83,126.92 174.38,127.47 187.16,127.47 187.57,127.05 193.5,127.05 194.44,126.11 196.1,126.11 196.98,126.99 201.31,126.99 202.04,126.27 204.77,126.27 205.39,126.89 208.22,126.89 208.94,126.17 210.67,126.17 v2(210.91,125.92)
  BOTTOM w0.102: v2(207.3,112.72) 207.3,112.54 207.11,112.36 v1(206.94,112.36) 205.96,112.36 U51.A6
SIO_EXT_WAKE#: length 129.5
  TOP w0.089: 112.37,117.99 112.56,118.18 113.16,118.18 113.24,118.26 UH1.AN44
  TOP w0.102: RH309.2 109.12,117.42 109.5,117.8 110.15,117.8 110.39,117.56 v2(110.39,117.38) 111.77,117.38 112.37,117.99 ; v2(210.17,115.67) 210.17,115.72 210.26,115.82 210.26,116.7 209.4,117.57 209.4,119.13 208.4,120.14 208.4,121.32 v1(207.36,122.36) 207.14,122.58 207.14,125.16 v2(206.32,125.98)
  IN2 w0.089: 112.37,116.99 113.22,116.14 120.22,116.14 120.26,116.17 123.76,116.17 123.99,115.94 123.99,115.69 124.24,115.45 124.49,115.45 124.76,115.18 124.76,114.93 125.05,114.64 127.21,114.64 127.98,113.86 133.66,113.86 136.63,110.89 141.76,110.89
  IN2 w0.127: v2(206.32,125.98) 206.14,126.16 201.52,126.16 200.45,125.09 196.38,125.09 196.18,124.89 194.37,124.89 193.62,124.14 192.44,124.14 190.96,122.65 188.38,122.65 187.5,121.77 184.56,121.77 184.08,121.3 180.82,121.3 180.19,120.67 180.19,120.3 179.81,119.92 178.97,119.92 178.81,119.77 173.41,119.77 171.82,118.18 171.04,118.18 169.69,116.83 169.69,115.81 169.72,115.77 169.72,113.65 168.97,112.9 168.97,110.36 168.62,110.01 167.61,110.01 166.78,110.84 164.82,110.84 164.4,111.26 153.53,111.26 152.74,110.47 148.91,110.47 148.46,110.03 147.4,110.03 146.54,110.89 141.76,110.89 ; 112.37,116.99 111.98,117.38 v2(110.39,117.38)
  BOTTOM w0.102: R797.1 210.34,115.49 v2(210.17,115.67)
SIO_PWRBTN#: length 262.2
  TOP w0.089: UH1.AT13 129.12,119.57 v2(129.54,119.15)
  TOP w0.102: v2(154.05,7.06) 154.05,6.92 154.36,6.6 JXDP1.41 ; CC269.1 RC241.2 ; RC241.2 158.04,14.04 158.27,14.27 158.27,16.01 v1(156.75,17.53) 156.75,18.4 145.86,29.29 145.86,60.1 156.12,70.37 157.24,70.37 160.74,73.86 160.74,76.36 161.14,76.75 v2(164.37,76.75) ; RC241.2 157.65,13.93 v2(157.65,12.98)
  IN3 w0.089: 141.57,114.9 141.57,113.86 139.36,111.65 139.36,108.22 141.32,106.25 141.32,105.67 141.76,105.24
  IN3 w0.127: v2(164.37,76.75) 160.79,76.75 160.43,76.4 156.69,76.4 151.63,81.45 150.76,81.45 143.74,88.47 143.74,88.95 142.77,89.93 142.77,91.68 142.88,91.8 142.88,96.48 144.5,98.1 144.5,102.49 141.76,105.24 ; 141.57,114.9 141.58,114.92 141.58,118.37 141.04,118.91 141.04,119.88 140.18,120.74 140.18,122.05 139.68,122.55 139.68,123.21 139.21,123.68 138.19,123.68 137.57,123.06 137.57,121.94 136.81,121.18 135.3,121.18 134.79,121.69 134.79,122.09 134.54,122.34 134.54,123.08 133.8,123.82 132.51,123.82 131.86,123.16 129.97,123.16 129.83,123.3 129.52,123.3 129.16,122.95 129.16,119.53 v2(129.54,119.15)
  IN4 w0.089: 141.76,118.09 141.1,118.09 140.86,118.33 132.01,118.33 131.96,118.28 130.7,118.28 130.23,118.76 129.93,118.76 v2(129.54,119.15)
  IN4 w0.109: v2(200.3,113.97) 199.42,113.08 198.71,113.08 198.33,112.7 198.33,111.81 197.72,111.2 196.45,111.2 194.97,109.72 192.94,109.72 192.36,109.14 185.12,109.14 184.47,109.79 183.06,109.79 183.06,109.79 181.67,109.79 180.16,111.31 177.06,111.31 176.24,112.13 175.1,112.13 172.45,114.77 171.47,114.77 171.47,114.77 171.28,114.77 170.4,115.65 166.87,115.65 165.92,116.6 165.01,116.6 164.24,117.38 162.72,117.38 161.71,116.37 158.79,116.37 158.45,116.71 157.46,116.71 157.12,116.37 153.38,116.37 153.19,116.56 151.73,116.56 151.22,117.07 150.1,117.07 149.32,117.85 143.53,117.85 143.28,118.09 141.76,118.09
  BOTTOM w0.102: U51.B58 199.52,115.69 199.52,114.75 199.66,114.61 199.66,114.28 199.97,113.97 v2(200.3,113.97) ; v2(154.05,7.06) 153.35,7.76 153.35,9.72 151.74,11.33 151.74,12.16 152.92,13.34 153.69,13.34 155.27,11.75 156.42,11.75 v2(157.65,12.98)
SIO_RCIN#: length 99.5
  TOP w0.089: UH1.AT17 126.95,119.73 v2(127.65,119.32)
  TOP w0.102: RH213.1 139.52,125.22 137.73,125.22 137.55,125.05 v2(137.46,125.05)
  IN3 w0.127: v2(188.59,124.09) 188.59,123.5 190.15,121.94 190.45,121.94 191.58,120.81 191.58,119.82 194.07,117.33 194.07,115.88 196.73,113.22 197.83,113.22 198.18,112.87 198.18,112.26 198.51,111.93 198.51,111.09 198.27,110.86 198.27,110.49 197.92,110.14 197.92,108.99 197.27,108.34 197.27,107.59 197.02,107.34 197.02,107.02 198.05,105.99 198.24,105.99 198.99,105.24 198.99,104.59 v2(198.88,104.48)
  IN4 w0.089: 141.47,124.21 141.44,124.24 138.4,124.24 137.58,125.05 v2(137.46,125.05)
  IN4 w0.109: v2(188.59,124.09) 188.29,124.39 181.86,124.39 181.19,123.72 180.41,123.72 180.4,123.72 176.3,123.72 175.72,123.14 169.23,123.14 169.12,123.03 167.94,123.03 166.73,124.24 157.62,124.24 156.32,125.55 153,125.55 151.97,124.51 148.99,124.51 148.76,124.29 145.29,124.29 145.23,124.23 144.05,124.23 143.95,124.33 142.91,124.33 142.79,124.21 141.47,124.21
  BOTTOM w0.089: v2(137.46,125.05) 136.69,124.29 136.69,123.91 136.1,123.32 136.1,123.25 136.08,123.23 136.08,122.63 136.22,122.49 136.22,122.16 134.6,120.54 132.8,120.54 132.54,120.79 131.97,120.79 131.63,120.45 131.63,120.06 131.88,119.82 131.88,119.5 131.61,119.23 130.93,119.23 130.49,119.68 129.76,119.68 129.69,119.61 129.19,119.61 128.91,119.34 v1(128.38,119.34) 128.36,119.32 v2(127.65,119.32)
  BOTTOM w0.102: v2(198.88,104.48) 198.87,104.49 198.87,104.58 198.99,104.7 198.99,105.07 199.25,105.34 U51.A27
SIO_SLP_A#: length 195.3
  TOP w0.089: v2(127.43,122.95) 127.51,123.03 UH1.BC15
  TOP w0.102: QH5.2 112.56,128.22 112.77,128.01 112.77,127.13 113.82,126.08 v2(114.51,126.08) ; v2(215.16,112.35) 215.43,112.35 215.88,111.91 215.88,110.58 215.47,110.17 215.47,108.98 215.88,108.57 217.12,107.33 218.68,107.33 218.82,107.18 218.82,107.18 218.99,107.01 219.73,107.01 220.13,107.4 221.83,107.4 v2(222.44,106.79) ; v2(153.48,132.46) 153.48,132.06 153.47,132.05 153.47,129.86 156.51,126.82 156.51,124.75 154.49,122.73 154.49,122.57 R877.1
  IN1 w0.089: v2(127.43,122.95) 128.12,122.95 130.33,125.16 131.28,125.16 131.83,124.61 132.91,124.61 133.18,124.87 133.18,125.17 132.99,125.35 132.99,125.78 133.42,126.2
  IN1 w0.109: v2(153.48,132.46) 153.46,132.46 153.46,132.47 153.24,132.25 152.87,132.25 151.92,133.21 151.23,133.21 150.47,133.97 145.23,133.97 144.09,132.83 141.82,132.83 141.37,132.37 140.69,132.37 139.83,131.51 136.23,131.51 134.19,129.48 134.19,126.98 133.42,126.2
  IN3 w0.127: v2(215.16,112.35) 214.58,112.93 213.73,112.93 212.78,113.88 212.78,123.87 213.25,124.35 213.25,129.01 v2(210.99,131.27)
  IN4 w0.089: 115.83,126.05 116.44,125.45 117.23,125.45 118.39,124.28 118.39,123.85 118.62,123.62 119.23,123.62 120.25,122.6 120.78,122.6 121.11,122.27 125.3,122.27 125.98,122.95 v2(127.43,122.95)
  IN4 w0.109: v2(153.48,132.46) 153.74,132.72 154.32,132.72 154.98,133.39 155.26,133.39 155.86,133.99 155.86,134.26 156.36,134.76 163.06,134.76 165.87,131.95 173.75,131.95 174.3,131.39 183.99,131.39 184.75,132.15 186.39,132.15 187.1,132.86 194.08,132.86 194.76,132.18 195.17,132.18 195.34,132.01 198.02,132.01 198.33,132.32 209.94,132.32 v2(210.99,131.27) ; v2(215.16,112.35) 214.96,112.15 214.96,112.12 214.72,111.88 213.18,111.88 212.02,113.04 210.86,113.04 210.12,112.3 205.75,112.3 205.72,112.27 203.13,112.27 202.68,112.72 201.89,112.72 199.46,110.29 199.46,108.3 v2(199.56,108.2) ; v2(114.51,126.08) 115.8,126.08 115.83,126.05
  BOTTOM w0.102: JAPS1.6 223.98,97.71 223.55,98.14 v1(223.55,98.27) 223.55,100.05 223.78,100.27 223.78,101.1 223.39,101.49 223.39,103.47 221.85,105 221.85,106.19 v2(222.44,106.79) ; v2(199.56,108.2) 199.56,108.1 199.88,107.78 199.88,107.71 199.89,107.69 199.89,107.36 199.88,107.34 199.88,107.14 199.5,106.77 U51.B28
SIO_SLP_LAN#: length 180.4
  TOP w0.089: UH1.AV15 v2(128.5,120.11)
  TOP w0.102: UZ25.5 219.33,121.73 219.2,121.6 218.71,121.6 218.16,121.05 218.16,120.21 v2(219.07,119.31) 220.4,117.97 v1(220.4,117.04) 220.4,115.97 220.13,115.7 220.13,112.45 220.35,112.24 221.62,112.24 222.13,112.75 v2(222.13,113.82) ; RH204.1 124.11,129.62 v2(124.8,128.93)
  IN2 w0.089: 141.76,118.35 141.38,118.35 141.15,118.13 137.14,118.13 135.02,120.25 135.02,120.28 133.95,121.34 133.61,121.34 133.46,121.19 133.46,120.89 133.07,120.5 132.71,120.5 131.98,119.78 131.98,119.61 131.61,119.23 131.08,119.23 130.64,119.68 129.86,119.68 129.8,119.61 129.05,119.61 128.56,120.11 v2(128.5,120.11) 128.26,120.11 127.83,119.68 127.39,119.68 126.72,119.02 121.84,119.02 121.01,119.84 121.01,121.18 120.63,121.56 120.25,121.56 119.93,121.88 119.93,123.02 121.45,124.54 121.45,125.38 122.27,126.2 122.37,126.2
  IN2 w0.127: 141.76,118.35 144.03,118.35 144.57,117.82 150.48,117.82 151.34,118.68 153.67,118.68 154.4,117.94 161.3,117.94 162.34,118.98 164.55,118.98 165.48,118.05 168.52,118.05 171.76,121.29 176.83,121.29 177.47,121.93 179.1,121.93 179.74,122.57 183.49,122.57 184.03,123.11 186.98,123.11 188.65,124.78 189.73,124.78 191.11,126.16 195.55,126.16 196.63,127.24 201.51,127.24 202.35,128.07 204.25,128.07 204.58,127.74 206.72,127.74 207.48,126.98 214.34,126.98 215.21,127.85 217.58,127.85 v2(217.64,127.79) ; v2(124.8,128.93) 124.8,128.63 122.37,126.2 ; v2(222.13,113.82) 222.1,113.82 219.24,110.95 217.56,110.95 216.39,109.78 216.39,107.32 216.09,107.03 215.03,107.03 214.84,106.84 210.98,106.84 210.07,107.74 210.07,107.74 209.82,107.98 208.97,107.98 207.61,109.34 203.89,109.34 203.67,109.12 202.94,109.12 202,110.06 196.7,110.06 196.22,109.58 196.22,109.12 v2(196.77,108.57)
  IN3 w0.127: v2(217.64,127.79) 217.64,125.77 219.57,123.84 219.57,119.82 v2(219.07,119.31)
  BOTTOM w0.102: U51.B37 196.21,108.11 196.65,108.56 196.75,108.56 v2(196.77,108.57)
SIO_SLP_S0#: length 177.7
  TOP w0.089: UH1.BC26 122.34,123.09 122.53,123.29 122.53,123.35 122.56,123.38 122.56,123.62 122.53,123.64 122.53,124.09 122.6,124.16 122.6,124.69 122.39,124.89 122.39,125.47 v2(122.22,125.64)
  TOP w0.102: v2(207.42,103.28) 207.92,102.79 207.92,100.93 207.31,100.32 205.77,100.32 205.19,99.75 UC1.1
  IN2 w0.089: 126.16,126.2 125.35,125.39 125.35,124.89 124.49,124.02 122.94,124.02 122.56,124.4 122.56,125.3 v2(122.22,125.64)
  IN2 w0.127: v2(207.42,103.28) 207.87,103.73 211.95,103.73 212.29,103.39 218.12,103.39 218.86,104.12 219.3,104.57 v2(219.76,104.57) ; 126.16,126.2 126.39,126.44 126.39,127.94 130.19,131.73 132.27,131.73 135.4,134.86 139.97,134.86 142,136.89 145.69,136.89 146.29,137.48 150.42,137.48 151,138.07 152.56,138.07 153.74,139.25 155.2,139.25 156.51,137.94 159.59,137.94 161.84,135.69 164.93,135.69 165.89,134.73 167.15,134.73 167.52,134.36 167.68,134.36 168.23,133.81 173.03,133.81 173.47,134.25 179.73,134.25 179.97,134.01 184.74,134.01 184.92,133.83 186.9,133.83 187.27,133.46 193.33,133.46 194.77,134.89 199.05,134.89 v2(199.24,134.7) 201.61,134.7 202.25,135.34 212.79,135.34 v2(213.25,135.8)
  IN3 w0.127: v2(219.76,104.57) 218.91,105.41 218.91,106.16 219.37,106.61 219.37,107.49 219.86,107.98 219.86,110.07 219.74,110.19 219.74,111.07 217.73,113.07 217.73,113.84 216.97,114.6 216.97,123.65 216.6,124.02 216.6,128.33 215.12,129.81 215.12,133.94 v2(213.25,135.8)
  BOTTOM w0.102: RZ83.1 195.75,129.69 196.45,130.39 196.45,131.78 199.24,134.58 v2(199.24,134.7) ; JAPS1.15 219.48,96.75 219.12,97.11 218.64,97.11 218.42,97.33 218.42,98.91 v1(219.3,99.79) 219.92,100.42 219.92,101.57 220.55,102.2 220.55,103.78 v2(219.76,104.57)
SIO_SLP_S3#: length 640.5
  TOP w0.102: UH1.AW15 128.1,121.15 v2(128.5,120.74) ; v2(53.96,46.34) 53.85,46.34 53.37,45.85 JIO2.96 ; v2(86.85,63.27) 86.85,60.73 89.95,57.63 89.95,26.36 89.26,25.67 RC330.1 ; v2(200.14,101.94) 200.14,102.55 RC329.1 199.67,103.02 197.78,103.02 197.4,103.4 194.99,103.4 194.45,103.94 v2(194.45,105.92) ; U9.1 321.02,4.45 320.78,4.21 316.4,4.21 313.22,7.39 313.22,18.37 316.65,21.8 318.69,21.8 319.51,22.63 319.51,25.29 320.65,26.44 320.65,27.07 321.16,27.58 323.57,27.58 v2(324.39,26.77) ; v2(217.33,99.77) 217.02,99.77 216.06,100.73 UC5.2
  IN1 w0.109: v2(324.39,26.77) 324.39,29.52 323.47,30.44 323.47,30.47 322.89,31.05 322.26,31.05 321.32,32 321.32,40.53 317.58,44.27 315.88,44.27 314.2,45.94 310.25,45.94 308.89,47.3 304.18,47.3 303.94,47.06 292.03,47.06 289.52,49.57 286.77,49.57 286.35,49.99 286.35,49.99 286.26,50.09 284.52,50.09 283.47,51.14 278.2,51.14 263.17,66.17 263.17,67.63 257.37,73.43 257.37,75.8 255.88,77.28 255.88,84.38 253.04,87.22 253.04,90.19 251.3,91.93 251.3,93.6 v2(251.45,93.75)
  IN2 w0.089: 135.11,126.2 135.11,125.56 135.47,125.2 135.47,124.9 134.65,124.09 132.56,124.09 131.36,122.89 130.86,122.89 130.24,122.27 129.46,122.27 129.07,121.88 129.07,121.31 v2(128.5,120.74)
  IN2 w0.127: v2(215.57,132.04) 213.47,132.04 213.13,131.69 209.29,131.69 208.56,130.96 200.51,130.96 200.42,131.05 196.24,131.05 195.74,130.55 190.24,130.55 188.77,129.08 188.77,128.01 188.48,127.71 187.86,127.71 187.79,127.78 173.08,127.78 172.41,127.11 170.07,127.11 169.56,127.62 168.2,127.62 165.94,129.88 161.2,129.88 160.78,129.46 153.74,129.46 152.72,130.47 146.88,130.47 143.49,127.09 139.85,127.09 139.53,126.77 138.54,126.77 138.22,127.08 137.39,127.08 137.14,127.34 136.14,127.34 135.11,126.31 135.11,126.2 ; v2(108.69,107.96) 108.38,107.96 106.91,109.43 106.72,109.43 106.72,109.43 105.41,109.43 103.76,107.79 103.76,105.44 104.12,105.09 104.12,104.18 104.88,103.42 104.88,102.23 104.49,101.85 104.49,99.33 107.12,96.7 107.12,94.25 106.23,93.36 106.23,90.3 105.5,89.56 104.56,89.56 104.37,89.75 101.99,89.75 101.99,89.75 101.37,89.75 101.16,89.75 87.83,76.41 87.83,64.25 v2(86.85,63.27) 76.62,53.04 72.93,53.04 72.27,52.38 70.21,52.38 68.85,52.38 65.07,48.6 60.47,48.6 59.76,47.89 56.23,47.89 55.1,46.76 54.38,46.76 v2(53.96,46.34) ; v2(194.45,105.92) 194.52,106 198.77,106 199.92,104.85 199.92,104.5 199.91,104.5 199.91,103.86 200.61,103.17 200.74,103.17 201.31,103.17 201.78,102.7 202.78,102.7 203.7,101.77 208.61,101.77 209.19,101.19 210.86,101.19 212.28,99.77 v2(217.33,99.77)
  IN3 w0.089: 120.45,126.2 120.45,124.26 121.45,123.26 121.45,122.54 122.18,121.81 122.18,121.32 122.34,121.15 122.34,120.04 122.6,119.78 127.82,119.78 128.12,120.09 128.12,120.67 128.19,120.74 v2(128.5,120.74)
  IN3 w0.127: v2(251.45,93.75) 251.45,93.75 251.45,96.45 249.98,97.92 249.98,102.83 247.1,105.71 245.33,105.71 242.89,108.14 242.89,113.54 242.02,114.42 242.02,117.46 241.61,117.87 241.61,123.48 237.08,128.01 235.22,128.01 v2(235.09,128.14) ; v2(108.69,107.96) 108.62,108.03 105.64,108.03 105.52,108.16 99.99,108.16 98.45,109.7 98.45,113.61 95.76,116.3 93.65,116.3 92.09,117.86 92.09,124.62 97.47,129.99 99.61,129.99 100.53,130.91 102.59,130.91 103.15,131.47 103.76,131.47 103.98,131.68 104.33,131.68 104.54,131.47 112.09,131.47 113.93,133.31 115.61,133.31 116.12,132.8 116.12,131.33 120.45,126.99 120.45,126.2 ; v2(217.33,99.77) 217.48,99.92 217.48,100.28 217.93,100.73 217.93,105.05 217.66,105.32 217.66,107.79 216.63,108.83 216.63,110.29 216.21,110.71 216.21,113.16 215.41,113.96 215.41,114.41 v2(215.1,114.71)
  IN4 w0.109: v2(235.09,128.14) 230.67,132.56 226.51,132.56 225.75,131.81 219.03,131.81 218.65,131.43 217.65,131.43 217.07,132.01 215.71,132.01 215.69,132.04 v2(215.57,132.04)
  BOTTOM w0.102: v2(200.14,101.94) 200.14,100.81 199.55,100.21 Q370.2 ; JAPS1.2 225.98,95.15 225.16,94.33 218.04,94.33 217.42,94.95 217.42,97.13 217.67,97.38 217.67,98.31 217.33,98.65 v1(217.33,99) v2(217.33,99.77) ; U51.A35 194.81,108.36 194.47,108.02 194.47,107.81 194.18,107.52 194.18,106.6 194.42,106.36 194.42,105.93 194.44,105.9 194.45,105.92 v2(194.45,105.92) ; v2(215.57,132.04) 215.69,132.04 215.69,131.15 215.37,130.83 215.37,129.31 214.55,128.48 214.55,125.56 215.31,124.8 215.31,114.92 v2(215.1,114.71)
SIO_SLP_S3#_UZ30: length 3.7
  TOP w0.102: UZ30.4 89.52,22.88 89.26,23.13 RC330.2 v1(88.29,23.69) 88,23.4 UC7.4
SIO_SLP_S4#: length 651.5
  TOP w0.089: UH1.BD15 128.16,123.68 127.91,123.92 v2(127.91,124.1)
  TOP w0.102: v2(200.26,94.15) 197.07,94.15 196.59,94.63 191.45,94.63 RC303.1 ; v2(198.92,138.96) 198.92,135.72 198.32,135.12 198.32,131.55 198.81,131.07 198.81,129.7 199.28,129.23 199.28,122.63 199.15,122.5 199.15,121.34 199.26,121.24 199.26,120.05 198.19,118.98 198.19,116.75 199.51,115.42 199.51,114.25 199.65,114.11 199.65,113.55 199.28,113.18 199.28,112.05 198.18,110.94 198.18,109.05 196.86,107.73 v2(196.77,107.73) ; UC7.2 v2(87.35,19.45) ; PR401.2 17.14,59.47 v4(16.62,58.95)
  IN1 w0.089: 112.37,118.07 112.74,118.07 113.88,119.21 115.33,119.21 115.66,119.54 115.66,119.84 115.4,120.09 114.46,120.09 114.23,120.32 114.23,120.87 114.71,121.35 114.71,121.52 115,121.81 115.42,121.81 116.97,123.36 120.16,123.36 120.21,123.41 123.31,123.41 123.33,123.39 125.06,123.39 125.77,124.1 v2(127.91,124.1)
  IN1 w0.102: 39.57,26.9 39.57,25.59 38.57,24.59 34.45,24.59 33.56,23.7 32.23,23.7 31.64,24.28 31.64,25.72 31.53,25.83 31.53,26.82 31.43,26.91 30.73,26.91 28.17,24.35 23.02,24.35 22.2,23.54
  IN1 w0.109: 112.37,118.07 112.25,117.95 109.66,117.95 108.04,116.33 101.69,116.33 98.28,112.92 98.28,110.76 99.04,110 102.34,110 102.79,109.56 102.79,108.1 99.55,104.86 99.55,102.2 90.47,93.13 90.47,91.99 63.4,64.92 58.91,64.92 56.76,67.07 25.22,67.07 v2(24.93,66.78) ; 39.57,26.9 41.42,28.75 42.77,28.75 43.65,27.86 49.57,27.86 52.91,24.52 52.91,18.97 54.46,17.42 v2(54.83,17.42) ; v2(21.14,22.42) 22.2,23.49 22.2,23.54
  IN2 w0.127: v2(218.11,100.18) 218.11,101.04 217.91,101.24 216.77,101.24 216.26,100.73 213.21,100.73 213.04,100.91 v2(213.04,101.13) 211.99,101.13 211.17,101.95 210.43,101.95 209.77,102.61 206.62,102.61 206.08,103.15 203.41,103.15 203.09,103.46 202.1,103.46 201.63,103.93 201.05,103.93 201.05,103.93 200.92,103.93 200.68,104.18 200.68,105.22 198.88,107.02 198.21,107.02 197.64,107.59 196.91,107.59 v2(196.77,107.73) ; v2(198.92,138.96) 197.93,139.95 196.79,139.95 196.62,139.78 189.67,139.78 187.9,141.56 178.55,141.56 178.19,141.21 176.67,141.21 176.06,141.82 167.75,141.82 167.05,142.51 158.69,142.51 157.1,144.1 154.12,144.1 153.86,144.36 149.92,144.36 149.54,144.74 144.25,144.74 142.83,144.74 142.13,144.04 136.2,144.04 134.43,142.26 122.94,142.26 119.63,138.96 117.03,136.35 113.26,136.35 112.21,137.41 111.57,137.41 111.37,137.22 107.64,137.22 106.77,136.35 104.54,136.35 99.74,131.55 99.74,128.4 99.33,128 94.99,128 92.16,125.17 92.16,116.91 93.21,115.86 94.99,115.86 96.37,114.47 96.37,110.53 94.21,108.37 94.21,105.18 89.17,100.13 89.17,90.84 63.15,64.81 58.72,64.81 56.32,67.22 54.66,67.22 54.22,66.78 v2(24.93,66.78) 18.61,66.78 16.62,64.79 v4(16.62,58.95)
  IN3 w0.127: v2(21.14,22.42) 20.07,22.42 15.85,26.64 12.45,26.64 11.42,27.67 11.42,29.22 5.35,35.29 5.35,43.37 7.75,45.77 7.75,49.27 7.47,49.55 6.84,49.55 5.79,50.6 5.79,55.75 8.98,58.95 v4(16.62,58.95)
  IN4 w0.109: v2(200.26,94.15) 200.55,94.15 200.84,93.86 203.51,93.86 204.43,92.95 207.11,92.95 v2(207.34,92.72) ; v2(54.83,17.42) 54.83,17 58.09,13.74 66.53,13.74 67.67,14.88 86.34,14.88 87.35,15.9 v2(87.35,19.45)
  BOTTOM w0.102: U51.B36 196.66,107.61 196.77,107.72 196.77,107.73 v2(196.77,107.73) ; v2(207.34,92.72) 207.38,92.72 207.38,93.38 208.47,94.47 209.18,94.47 v1(210.64,95.93) 213.02,98.31 213.02,101.12 v2(213.04,101.13) ; v2(218.11,100.18) 217.9,99.97 217.9,97.29 217.66,97.05 217.66,96.8 217.65,96.8 217.65,95.94 217.66,95.93 217.66,95.04 218.14,94.56 224.13,94.56 224.48,94.9 JAPS1.5
  BOTTOM w0.203: v2(54.83,17.42) 55.21,17.04 PR206.1
SIO_SLP_S5#: length 320.5
  TOP w0.089: UH1.BA13 129.09,121.8 v2(129.54,121.35)
  TOP w0.102: v2(53.47,37.35) JIO2.62 ; v2(85.86,52.24) 85.86,79.62 93.7,87.46 98.36,87.46 100.12,89.22 100.67,89.22 103.98,92.53 v2(104.23,92.53)
  IN2 w0.089: v2(129.54,121.35) 129.57,121.35 130.86,122.63 131.36,122.63 132.63,123.91 134.73,123.91 135.65,124.83 135.65,125.3 135.36,125.58 135.36,126.2
  IN2 w0.127: v2(85.86,52.24) 78.83,45.21 75.19,45.21 73.87,43.89 73.84,43.89 70.93,40.98 70.93,40.95 70.59,40.61 70.59,39.82 70.13,39.35 69.41,39.35 67.44,37.38 66.74,37.38 61.18,37.38 61.07,37.49 60.23,37.49 59.65,36.92 57.63,36.92 57.11,37.44 56.88,37.44 56.52,37.8 53.76,37.8 53.47,37.51 v2(53.47,37.35) ; v2(104.23,92.53) 104.12,92.63 104.12,96.71 102.25,98.59 102.25,104.14 101.86,104.53 101.86,108.48 102.4,109.02 102.4,110.1 103.06,110.76 v2(103.56,110.76) ; v2(224.58,132.86) 217.28,132.86 216.03,131.62 213.42,131.62 212.5,130.7 200.2,130.7 200.11,130.8 196.35,130.8 195.69,130.14 193.98,130.14 193.34,129.5 190.16,129.5 189.03,128.36 189.03,127.9 188.58,127.46 187.75,127.46 187.68,127.53 173.18,127.53 172.36,126.7 170.07,126.7 169.41,127.36 168.1,127.36 165.83,129.63 161.31,129.63 160.86,129.18 153.62,129.18 152.58,130.22 147.01,130.22 143.62,126.83 139.95,126.83 139.63,126.51 138.44,126.51 138.25,126.7 138.12,126.83 137.29,126.83 137.03,127.08 136.24,127.08 135.36,126.2 ; v2(224.79,107.82) 224.79,108.58 224.29,109.07 223.88,109.07 223.55,109.41 220.94,109.41 220.25,108.72 220.25,107.75 218.84,106.34 218.84,105.98 218.27,105.42 215.28,105.42 215.14,105.56 213.64,105.56 212.91,104.82 207.03,104.82 206.44,105.4 205.34,105.4 205.04,105.1 205.01,105.1 v2(204.64,104.73)
  IN3 w0.127: v2(224.79,107.82) 225.21,108.24 225.21,108.81 225.57,109.16 225.57,112.04 224.6,113 224.6,122.73 224.74,122.87 224.74,132.7 v2(224.58,132.86)
  IN4 w0.089: v2(129.54,121.35) 129.33,121.35 129.14,121.15 129.14,119.81 128.15,118.82 127.21,118.82 127,119.02 124.44,119.02 123.68,119.78 122.13,119.78 121.82,119.48 121.54,119.48 121.34,119.68 121.34,121.13 120.88,121.58 118.81,121.58 117.35,120.12 117.35,119.37 117.5,119.22 117.5,118.54 117.23,118.26 114.23,118.26 113.39,117.41 113.39,115.69 112.64,114.94 112.37,114.94
  IN4 w0.109: v2(103.56,110.76) 105.82,110.76 107.14,112.08 107.14,113.91 107.88,114.65 111.31,114.65 111.6,114.94 112.37,114.94
  BOTTOM w0.102: JAPS1.4 224.98,96.77 224.61,97.14 224.61,98.35 224.01,98.95 v1(224.01,99.54) 224.01,101.19 223.8,101.4 223.8,105.99 224.79,106.98 v2(224.79,107.82) ; U51.A18 203.75,105.24 203.84,105.15 203.94,105.15 203.94,105.15 204.08,105.15 204.12,105.11 204.13,105.11 204.26,104.98 204.51,104.98 204.64,104.85 v2(204.64,104.73)
SIO_SLP_SUS#: length 331.9
  TOP w0.102: v2(127.3,131.45) 127.12,131.28 127.12,129.99 127.67,129.44 R374.2 ; v2(86.72,19.45) 86.7,19.47 UC7.1 ; v2(196.11,116.66) 196.94,116.66 197.22,116.93 197.22,117.98 196.88,118.32 196.88,120.66 196.6,120.94 195.5,120.94 195.15,121.28 195.15,121.69 196.89,123.43 196.89,124.72 196.63,124.99 196.63,126.12 198.03,127.53 198.03,130.87 196.8,132.1 195.37,132.1 193.91,133.56 193.91,134.07 v2(193.21,134.77)
  IN1 w0.109: v2(96.88,127.58) 97.08,127.78 97.77,127.78 98.4,128.42 98.4,128.81 100.02,130.42 101.81,130.42 103.84,132.46 106.15,132.46 107.55,133.85 112.53,133.85 113.16,133.22 117.14,133.22 117.94,132.42 124.31,132.42 124.51,132.22 126.53,132.22 127.3,131.45 v2(127.3,131.45)
  IN2 w0.127: v2(229.29,107.75) 229.29,107.89 226.99,110.19 225.8,110.19 225.28,110.72 225.28,110.85 222.8,113.33 222.8,114.79 222.76,114.83 221.77,115.82 218.91,115.82 218.5,115.41 216.04,115.41 215.37,116.08 210.98,116.08 210.19,116.88 209.88,116.88 209.7,117.06 205.62,117.06 204.87,116.31 196.45,116.31 v2(196.11,116.66) ; v2(127.3,131.45) 127.96,131.45 129,132.5 131.73,132.5 132.31,133.07 132.31,134.33 133.6,135.62 139.65,135.62 142.35,138.32 148.95,138.32 149.71,139.09 152.32,139.09 153.86,140.63 155.37,140.63 155.72,140.29 155.72,140.09 157.11,138.7 159.91,138.7 162.16,136.45 165.25,136.45 166.21,135.49 167.08,135.49 167.5,135.91 170.16,135.91 170.89,136.64 171.98,136.64 173,135.62 176.28,135.62 176.89,135.01 180.18,135.01 180.76,135.59 182.33,135.59 182.89,135.03 184.03,135.03 184.4,135.4 186.4,135.4 186.89,134.92 188.17,134.92 188.87,134.22 191.33,134.22 192.1,134.99 192.98,134.99 v2(193.21,134.77)
  BOTTOM w0.102: PR900.1 236.82,91.41 236.41,91.82 236.41,92.63 236.89,93.11 237.48,93.11 239.06,94.69 239.08,94.7 239.41,95.04 240.87,96.5 240.87,97.63 241.23,97.99 v1(241.23,98.65) 241.23,99.51 240.8,99.94 240.8,101.6 239.85,102.54 239.02,102.54 237.18,104.39 237.18,105.85 236.78,106.24 231.96,106.24 230.45,107.75 v2(229.29,107.75) ; U51.B52 196.5,116.15 196.43,116.21 196.43,116.32 196.1,116.66 v2(196.11,116.66) ; PR804.1 98.4,128.81 98.4,128.42 97.9,127.91 97.21,127.91 v2(96.88,127.58) 96.47,127.99 93.27,127.99 90.91,125.62 90.91,121.15 98.37,113.7 98.37,108.31 95.86,105.81 95.86,105.18 95.36,104.67 95.36,100.99 95.99,100.35 95.99,96.36 93.3,93.66 93.3,87.68 94.47,86.51 94.47,75.39 93.64,74.57 93.64,44.28 87.99,38.63 87.99,20.72 v2(86.72,19.45)
SIO_SLP_SUS#_R: length 9.4
  TOP w0.089: UH1.BB13 128.93,122.5 v2(128.57,122.15)
  TOP w0.102: R418.1 128.95,127.48 128.76,127.29 v2(128.08,127.29) 128.08,127.94 R374.1
  BOTTOM w0.089: v2(128.57,122.15) 128.9,122.48 v1(128.9,122.85) 128.9,124.77 128.16,125.51 128.16,126.2
  BOTTOM w0.102: v2(128.08,127.29) 128.16,127.21 128.16,126.2
SIO_SLP_WLAN#: length 115.4
  TOP w0.089: v2(129.54,119.98) UH1.AV13
  TOP w0.102: R820.1 215.83,123.69 215.83,123.85 214.01,125.67 v1(214.01,127.66) 214.01,130.95 214.15,131.08 214.15,131.09 v2(214.14,131.09)
  IN1 w0.109: v2(182.05,116.94) 182.22,117.1 182.22,118.16 182.19,118.18 182.19,119.19 182.53,119.52 182.53,122.36 181.64,123.25 181.64,124.63 v2(183.67,126.66)
  IN2 w0.089: 136.89,126.2 136.89,126.01 136.53,125.65 136.2,125.65 135.88,125.33 135.88,124.81 134.47,123.4 133.92,123.4 133.56,123.04 132.24,123.04 131.17,121.97 131.17,121.84 130.7,121.37 130.44,121.37 130.09,121.02 130.09,120.52 v2(129.54,119.98)
  IN2 w0.127: 136.89,126.2 136.89,126.26 137.2,126.58 138,126.58 138.32,126.26 139.74,126.26 140.06,126.58 143.75,126.58 147.13,129.97 152.47,129.97 153.51,128.93 160.97,128.93 161.41,129.37 165.73,129.37 167.99,127.11 169.31,127.11 169.97,126.45 172.47,126.45 173.29,127.27 182.73,127.27 183.34,126.66 v2(183.67,126.66) 184.21,127.2 188.69,127.2 189.28,127.8 189.28,128.26 190.27,129.24 193.54,129.24 194.18,129.89 195.79,129.89 196.45,130.54 199.58,130.54 199.67,130.45 213.49,130.45 v2(214.14,131.09)
  BOTTOM w0.102: U46.A14 v2(182.05,116.94)
SKL_CNL#: length 9.2
  TOP w0.102: 170.39,24.52 170.39,24.88 171.11,25.6 171.11,25.61 171.45,25.95 171.46,25.95 171.62,26.1 CPU1.BN1
  TOP w0.254: 170.39,24.52 169.73,23.86
  TOP w0.508: RC171.2 166.07,22.47 167.26,21.28 168.03,21.28 v1(168.21,21.46) 168.53,21.79 168.53,22.66 169.73,23.86
SL_BAT_PRES#: length 2.7
  TOP w0.102: v2(335.79,58.33) 335.7,58.43 PR1023.1
  TOP w0.254: PU1001.21 334.7,57.29 335.11,57.71 PR1023.1
SLICE_BAT_ON: length 238.9
  TOP w0.254: PR1016.2 331.56,59.58 331.24,59.9 330.23,59.9 v2(329.97,59.65)
  IN2 w0.127: v2(323.64,36.66) 323.64,34.78 321.05,32.19 319.01,32.19 318.62,31.8 317.07,31.8 316.7,31.43 315.91,31.43 314.64,32.7 312.97,32.7 312.16,31.88 309.13,31.88 308.14,32.87 303.36,32.87 301.56,31.07 297.14,31.07 294.4,33.81 294.4,34.46 290.6,38.26 289.23,38.26 286.96,40.53 282.62,40.53 278.89,44.27 276.29,44.27 257.3,63.26 257.3,64.99 255.31,66.98 255.31,69.02 255.01,69.32 251.27,73.06 249.25,75.08 246.61,75.08 243.65,78.04 243.65,78.78 240.02,82.42 227.12,82.42 225.67,83.87 222.52,83.87 221.34,85.05 220.58,85.05 217.91,87.71 216.57,87.71 215.77,88.51 215.77,89.67 213.28,92.16 212.73,92.16 212.13,92.75 212.13,95.89 208.14,99.88 203.98,99.88 203.94,99.92 202.93,99.92 201.97,100.88 201.08,100.88 200.54,101.42 196.9,101.42 196.76,101.56 195.05,101.56 194.57,102.04 194.57,102.88 193.27,104.18 192.15,104.18 191.76,104.57 191.76,104.67 189.63,106.8 186.47,106.8 185.77,107.5 185.54,107.5 v2(185.49,107.55) 185.25,107.55 183.91,108.88 183.06,108.88 182.46,108.88 182.18,109.16 176.71,109.16 176.41,108.86 173.82,108.86 173.17,108.21 171.87,108.21 v2(170.76,109.32)
  IN3 w0.127: v2(323.64,36.66) 323.64,37.23 323.22,37.65 322.18,37.65 321.73,38.1 321.73,39.17 325.28,42.71 327.98,42.71 329.29,44.03 329.29,46.91 330.18,47.8 330.18,58.01 330.46,58.29 330.46,59.16 v2(329.97,59.65)
  BOTTOM w0.102: U46.A31 185.46,107.51 v2(185.49,107.55) ; RP4.3 170.74,113.88 170.54,113.68 170.54,113.26 170,112.72 168.58,112.72 v1(168.16,112.29) 167.89,112.02 167.89,111.17 168.2,110.86 168.67,110.86 170.2,109.32 v2(170.76,109.32)
SLICE_BAT_PRES#: length 402.1
  TOP w0.102: v2(194.68,146.58) 194.26,147 v1(192.79,147) 191.79,147 191.01,146.22 190.05,146.22 189.01,145.18 188.07,145.18 187.37,144.48 v2(185.91,144.48)
  TOP w0.254: v2(250.05,14.28) 249.21,13.44 PR33.1 ; v2(338.99,59.65) PD1100.1 338.17,59.77 338.17,60.17 337.54,60.8 336.76,60.8 336.41,60.45 336.41,60.24 335.51,59.34 PR1023.2
  IN1 w0.254: v2(338.99,59.65) 338.19,58.85 332.55,58.85 330.81,57.11 330.81,49.45 329.67,48.3 329.67,46.87 329.44,46.64 329.44,44.32 328.48,43.35 327.57,43.35 325.71,41.49 325.71,40.21 326.59,39.32 326.59,37.84 325.54,36.79 v2(325.54,32.3) 325.54,29.96 326.84,28.66 328.05,28.66 329.56,27.15 331.24,27.15 332.09,26.29 332.09,25.18 334.07,23.2 334.07,20.53 332.75,19.2 332.75,15.06 328.12,10.43 315.02,10.43 310.45,15.01 299.93,15.01 297.51,17.42 285.47,17.42 284.08,16.02 282.87,16.02 282.02,16.87 262.37,16.87 258.85,13.36 250.98,13.36 v2(250.05,14.28)
  IN2 w0.127: v2(325.54,32.3) 324.54,31.29 317.29,31.29 316.92,30.92 309.11,30.92 309.04,30.84 306.11,30.84 305.59,31.36 302.93,31.36 301.14,29.57 301.12,29.57 300.87,29.32 296.79,29.32 292.49,33.63 292.49,34.86 290.73,36.62 288.82,36.62 285.67,39.77 282.31,39.77 278.57,43.51 275.97,43.51 256.54,62.94 256.54,64.67 255.32,65.89 254.55,66.66 254.55,68.7 250.46,72.79 248.94,74.32 246.29,74.32 245.52,75.09 244.62,75.09 243.48,76.23 243.48,76.94 242.02,78.4 241.6,78.4 238.37,81.63 224.03,81.63 223.14,82.52 221.92,82.52 218.58,85.86 215.75,85.86 214.86,86.74 214.86,89.5 212.96,91.4 212.41,91.4 211.34,92.46 211.34,95.25 209.42,97.18 208.49,97.18 206.55,99.12 203.66,99.12 203.62,99.16 202.61,99.16 201.65,100.12 200.76,100.12 200.23,100.66 196.58,100.66 196.44,100.79 194.73,100.79 193.76,101.77 193.76,102.62 193.03,103.35 191.9,103.35 191.4,103.85 191.19,104.06 190.67,104.58 189.48,104.58 188.02,106.04 187.02,106.04 v2(186.61,105.62) 186.58,105.62 186.16,106.04 186.15,106.04 185.64,106.55 185.04,106.55 184.52,107.06 v2(183.18,107.06)
  IN3 w0.127: v2(186.61,105.62) 186.61,106.03 188.92,108.34 188.92,112.95 188.99,113.03 188.99,114.44 188.39,115.05 188.39,118.57 186.38,120.57 186.38,125.66 186.97,126.25 187.83,126.25 188.79,127.21 189.59,127.21 190,127.62 190,131.17 189.21,131.95 189.21,132.62 186.92,134.91 186.92,143.15 185.88,144.2 185.88,144.45 v2(185.91,144.48)
  BOTTOM w0.102: R2158.2 186.61,105.95 v2(186.61,105.62) ; v2(183.18,107.06) 183.38,107.26 U46.B33 ; JDOCK1.141 194.75,146.65 v2(194.68,146.58) 195.08,146.58 195.25,146.74 JDOCK1.143
SLOT2_CONFIG_0: length 241.3
  TOP w0.102: v2(186.62,110.67) 186.44,110.85 186.44,110.85 186.19,111.1 185.35,111.1 184.88,111.58 184.88,112.96 185.31,113.4 185.94,113.4 185.99,113.44 186.08,113.44 187.3,114.67 v1(187.3,114.91) 187.3,115.23 186.77,115.76 v2(186.77,116.07)
  IN1 w0.109: v2(228.32,107.43) 228.01,107.74 228.01,108.87 226.06,110.81 v2(226.06,110.88)
  IN2 w0.127: v2(228.32,107.43) 228.31,107.42 228.16,107.42 226.17,105.43 223.69,105.43 222.89,104.63 222.13,104.63 220.56,103.05 220.56,100.84 217.43,97.71 217.43,91.33 219.14,89.62 219.14,88.93 219.14,88.72 221.72,86.14 221.72,85.82 222.8,84.74 227.74,84.74 229.22,86.21 229.22,88.37 229.29,88.45 234.52,88.45 238.62,84.35 239.42,84.35 245.24,78.53 245.24,77.53 246.93,75.84 249.57,75.84 256.07,69.33 256.07,67.29 258.06,65.3 258.06,63.58 276.61,45.03 279.2,45.03 282.94,41.3 288.44,41.3 290.93,38.8 292,38.8 294.95,35.85 294.95,34.8 298.17,31.58 301.35,31.58 303.15,33.38 308.35,33.38 309.34,32.39 311.56,32.39 312.43,33.26 315.44,33.26 316.18,32.52 318.38,32.52 v2(318.58,32.72) ; v2(180.73,114.51) 181.18,114.96 183.87,114.96 184.99,116.08 185.3,116.08 185.32,116.1 186.14,116.1 186.16,116.08 186.75,116.08 186.75,116.07 v2(186.77,116.07) 186.78,116.08 187.01,116.08 187.03,116.1 188.28,116.1 189.27,117.09 191.31,117.09 192.46,118.23 193.69,118.23 194.52,119.06 195.41,119.06 195.91,118.56 201.33,118.56 201.49,118.72 204.22,118.72 204.81,118.13 205.31,118.13 206.32,119.14 210.13,119.14 210.22,119.22 210.98,119.22 211.5,118.7 212.22,118.7 212.75,119.23 215.33,119.23 217.32,117.24 218.52,117.24 219.43,116.33 221.98,116.33 222.97,115.33 223.31,115 223.31,113.54 225.97,110.88 v2(226.06,110.88)
  BOTTOM w0.102: U46.B12 180.8,115.03 180.74,114.97 180.74,114.61 180.73,114.61 v2(180.73,114.51) ; v2(186.62,110.67) 186.62,110.61 187.2,110.04 RP9.8 ; v2(318.58,32.72) 318.75,32.54 318.75,31.64 318.78,31.61 318.78,31.61 319.02,31.37 319.02,31.37 319.16,31.23 319.16,27.93 319.55,27.54 323.08,27.54 323.21,27.67 323.21,27.68 323.96,28.43 JNGFF2.13
SLOT2_CONFIG_1: length 228.5
  TOP w0.102: UZ29.9 v2(332.8,39.25)
  IN1 w0.109: v2(217.34,100.74) 217.34,100.34 218.32,99.35 218.32,97.17 218.58,96.91 218.58,92.67 v2(218.71,92.54) ; v2(185.44,114.74) 184.83,114.14 184.83,110.73 185.31,110.26 185.98,110.26 v2(186.66,109.58)
  IN2 w0.127: v2(218.71,92.54) 218.71,90.6 219.39,89.92 219.39,88.83 221.97,86.24 221.97,85.93 222.91,85 227.64,85 228.96,86.32 228.96,88.48 229.19,88.7 234.63,88.7 238.73,84.6 239.52,84.6 245.49,78.63 245.49,77.63 247.03,76.09 249.67,76.09 256.33,69.44 256.33,67.4 258.32,65.41 258.32,63.68 276.71,45.29 279.31,45.29 283.04,41.55 288.54,41.55 291.04,39.06 292.1,39.06 295.21,35.95 295.21,35.08 298.45,31.83 301.24,31.83 303.73,34.32 304.45,34.32 304.98,34.86 307.04,34.86 308.18,33.71 308.38,33.71 309.45,32.65 311.45,32.65 312.32,33.51 315.71,33.51 315.83,33.4 318.69,33.4 319.65,34.36 319.82,34.36 321.2,35.74 321.2,36.57 322.08,37.45 324.55,37.45 325.16,38.06 328.9,38.06 329.26,37.69 330.48,37.69 331.25,36.93 332.8,36.93 333.33,37.46 333.33,38.73 v2(332.8,39.25) ; v2(217.34,100.74) 217.08,100.48 212.29,100.48 211.07,101.7 209.4,101.7 208.74,102.36 206.51,102.36 205.97,102.89 203.3,102.89 202.99,103.21 201.99,103.21 201.52,103.68 200.95,103.68 200.82,103.68 200.42,104.07 200.42,105.12 199.03,106.51 195.87,106.51 195.19,107.19 194.4,107.19 194.05,106.84 193.31,106.84 193,106.53 191.36,106.53 189.77,108.12 188.35,108.12 186.89,109.58 v2(186.66,109.58)
  BOTTOM w0.102: v2(186.66,109.58) 186.7,109.54 RP9.7 ; U46.A18 185.21,114.01 185.43,114.24 185.43,114.74 v2(185.44,114.74) ; JNGFF2.61 327.7,40.43 327.36,40.09 326.31,40.09 326,40.39 326,43.64 326.27,43.91 329.04,43.91 329.59,44.47 331.83,44.47 v1(332.22,44.08) 332.8,43.5 v2(332.8,39.25)
SLOT2_CONFIG_2: length 240
  IN2 w0.127: v2(331.25,29.28) 329.37,27.4 328.35,27.4 326.93,25.98 317.89,25.98 317.81,25.9 316.23,25.9 315.78,26.34 312.85,26.34 311.57,25.06 304.03,25.06 303.27,25.83 298.2,25.83 297.53,25.16 294.96,25.16 294.23,24.43 292.82,24.43 289.02,28.22 289.02,30.15 286.87,32.3 286.87,34.53 284.46,36.94 280.31,36.94 278.53,38.72 277.96,38.72 277.56,39.11 277.56,39.15 276,40.71 274.82,40.71 258.23,57.3 251.39,57.3 248.2,60.49 248.2,66.23 248.77,66.8 248.77,70.27 247.52,71.52 245.13,71.52 244.4,72.25 241.55,72.25 239.66,74.15 239.66,74.95 238.76,75.84 237.13,75.84 234.38,78.58 220.94,78.58 219.72,79.8 213.6,79.8 212.13,81.27 211.07,81.27 207.86,84.48 206.7,84.48 204.64,86.54 204.64,88.35 203.98,89.01 203.98,93.18 203.41,93.75 202.47,93.75 200.88,95.33 198.98,95.33 198.63,95.69 197.49,95.69 196.87,96.31 193.34,96.31 192.66,96.98 191.47,96.98 190.52,97.94 186.08,97.94 185.13,98.89 183.71,98.89 182.55,100.04 182.55,100.97 182.22,101.3 181.59,101.3 179.56,103.33 178.63,103.33 v2(178.03,103.94)
  IN3 w0.127: v2(331.25,29.28) 327.08,29.28 326.22,30.14 326.22,40.19 v2(326.56,40.53)
  BOTTOM w0.102: v2(326.56,40.53) 326.91,40.88 326.91,41.33 327.51,41.93 JNGFF2.67 ; U46.A44 177.55,104.42 v2(178.03,103.94) 178.62,103.35 180.66,103.35 180.73,103.41 182.86,103.41 183.29,103.84 185.19,103.84 185.47,103.56 187.98,103.56 188.76,104.34 188.76,106.99 187.99,107.75 187.99,108.86 187.81,109.04 RP9.6
SLOT2_CONFIG_3: length 204.4
  IN2 w0.127: v2(325.13,26.77) 325.13,27.24 323.5,28.87 322.1,28.87 321.01,29.97 314.69,29.97 314.24,30.41 309.82,30.41 309.74,30.34 307.51,30.34 306.6,29.42 305.96,29.42 305.07,28.53 304.17,28.53 303.89,28.81 293.75,28.81 291.84,30.72 291.84,33.42 289.73,35.53 289.19,35.53 285.46,39.26 282.1,39.26 278.36,43 275.76,43 259.16,59.6 252.32,59.6 250.49,61.44 250.49,65.28 251.06,65.85 251.06,71.47 249.95,72.58 249.95,72.58 248.73,73.81 246.08,73.81 245.31,74.59 244.41,74.59 242.97,76.02 242.97,76.73 241.88,77.82 241.46,77.82 238.16,81.12 223.82,81.12 222.93,82.01 221.71,82.01 218.37,85.35 215.54,85.35 213.72,87.16 213.72,89.92 212.75,90.89 212.17,90.89 210.25,92.81 210.25,94.19 210.8,94.73 210.8,95.08 209.21,96.67 208.28,96.67 206.34,98.61 203.45,98.61 203.41,98.65 202.4,98.65 201.44,99.61 200.55,99.61 200.02,100.15 196.37,100.15 196.23,100.29 194.43,100.29 193.24,101.48 192.52,101.48 191.39,102.61 191.39,103.03 190.39,104.03 187.92,104.03 187.21,104.74 186.53,104.74 185.47,105.81 v2(185.26,105.81)
  BOTTOM w0.102: 185.28,105.81 184.56,106.53 184.55,106.53 184.32,106.76 U46.B34 ; 185.28,105.81 v2(185.26,105.81) ; 185.28,105.81 186.1,104.99 187.99,104.99 188.38,105.38 188.38,106.86 187.39,107.85 RP9.5 ; v2(325.13,26.77) 325.13,24.56 326.27,23.43 JNGFF2.1 329.06,23.43 329.8,22.69 v1(330.47,22.69)
SLOT2_SATA_LED#: length 37.6
  TOP w0.102: v2(301.05,4.73) 300.83,4.73 R384.2 300.51,4.21 D98.1 ; v2(319.05,24.24) v1(319.05,23.63)
  IN4 w0.109: v2(301.05,4.73) 301.65,5.34 306.76,5.34 311.15,9.74 311.15,19.78 315.41,24.04 318.85,24.04 v2(319.05,24.24)
  BOTTOM w0.102: JNGFF2.10 319.46,25.68 319.05,25.27 v2(319.05,24.24)
SLOT3_SATA_LED#: length 323.3
  TOP w0.102: v2(5.21,10.52) 5.21,10.75 v1(4.96,11.01) ; v2(305.19,4.91) 305.19,5.15 D99.1 304.79,5.54 R385.2
  IN1 w0.109: v2(305.19,4.91) 305.19,4.8 304.49,4.11 295.5,4.11 295.34,4.27 291.16,4.27 290.66,3.77 270.23,3.77 269.54,4.46 244.62,4.46 244.48,4.32 242.56,4.32 241.44,5.45 228.5,5.45 227.18,4.13 181.8,4.13 179.08,6.86 179.08,8.74 178.13,9.69 173.88,9.69 172.25,8.06 v2(172.24,8.06)
  IN3 w0.127: v2(5.21,10.52) 5.77,11.08 12.31,11.08 15.84,7.56 15.84,5.96 18.07,3.72 25.64,3.72 29.06,7.15 39.32,7.15 40.83,8.66 45.73,8.66 45.97,8.41 49.42,8.41 49.98,8.97 56.3,8.97 57.84,10.51 63.79,10.51 64.9,11.62 70.39,11.62 71.96,13.19 89.38,13.19 92.19,10.38 107.68,10.38 110.03,8.03 128.18,8.03 128.85,7.36 137.16,7.36 140.92,11.12 158.67,11.12 161.16,8.63 171.67,8.63 v2(172.24,8.06)
  BOTTOM w0.102: v2(5.21,10.52) 5,10.73 JNGFF3.10
SLOT3_SSD_PWR_EN: length 286
  TOP w0.102: v2(18.65,39.07) 18.33,39.39 18.33,40.09 18.62,40.38 UZ21.3
  IN2 w0.127: v2(179.3,140.8) 178.92,140.8 177.86,139.74 174.85,139.74 174.65,139.94 171.87,139.94 170.44,141.36 170.03,141.36 170.02,141.37 164.26,141.37 163.37,142.26 158.58,142.26 156.99,143.85 154.01,143.85 153.76,144.1 149.82,144.1 149.44,144.48 144.14,144.48 144.14,144.48 143.3,144.48 142.94,144.48 142.24,143.78 136.31,143.78 134.53,142.01 123.04,142.01 117.14,136.1 110.24,136.1 107.32,133.18 107.32,130.93 103.69,127.3 103.69,121.2 103.94,120.95 103.94,117.94 103.22,117.22 101.51,117.22 96.88,112.59 96.88,110.32 95.78,109.22 95.78,104.11 90.19,98.53 90.19,88.02 83,80.83 83,72.57 74.23,63.8 57.28,63.8 55.31,65.77 28.05,65.77 24.69,62.41 24.69,54.82 21.89,52.02 21.89,42.31 v2(18.65,39.07)
  IN3 w0.127: v2(179.3,140.8) 179.43,140.67 179.43,140.36 180.26,139.53 180.26,135.63 183.18,132.71 183.2,132.71 184.07,131.85 184.07,130.51 185.02,129.55 185.02,128.33 184.35,127.66 183.23,127.66 182.73,127.15 182.73,125.75 183.81,124.67 183.81,119.71 185.51,118 185.51,117.59 184.67,116.75 184.67,112.67 184.41,112.41 184.41,107.92 183.71,107.22 183.71,106.74 183.48,106.51 182.94,106.51 182.68,106.77 v2(182.68,107.36)
  BOTTOM w0.102: U46.B32 183.68,107.76 183.41,107.49 183.29,107.49 183.26,107.47 183.01,107.47 182.9,107.36 v2(182.68,107.36)
SML0_SMBCLK: length 206.1
  TOP w0.089: UH1.AY44 114.27,121.8 v2(114.35,121.88)
  TOP w0.102: U31.28 v2(250.13,107.91) ; RH67.2 107.15,124.86 v2(107.17,124.86)
  IN1 w0.109: v2(187.08,145.34) 187.08,145.34 187.26,145.17 187.26,144.78 187.49,144.55 188.62,144.55 189.52,143.64 192.21,143.64 192.7,143.15 198.03,143.15 198.37,142.81 206.24,142.81 206.61,142.45 206.91,142.15 212.27,142.15 227.13,127.3 227.13,118.9 229.22,116.81 229.84,116.81 236.08,110.57 243.37,110.57 244.71,109.24 250.3,109.24 250.61,108.92 250.61,108.02 250.5,107.91 v2(250.13,107.91)
  IN4 w0.089: v2(114.35,121.88) 114.67,122.2 114.67,123.24 114.51,123.4 114.5,123.4 114.48,123.41
  IN4 w0.109: 114.48,123.41 114.4,123.49 111.17,123.49 107.49,127.18 107.49,132.93 108.69,134.14 109.58,134.14 113.37,137.92 119.88,137.92 121.28,136.53 128.39,136.53 128.63,136.29 134.28,136.29 135.55,135.02 140.46,135.02 143.68,138.24 149.5,138.24 150.35,139.09 151.75,139.09 154.97,142.31 159.67,142.31 161.96,140.02 171.21,140.02 171.46,139.77 173.43,139.77 174.32,138.88 175.34,138.88 176.35,137.86 180.35,137.86 180.65,138.17 183.51,138.17 184.4,139.06 184.4,141.63 187.26,144.49 187.26,145.16 v2(187.08,145.34)
  BOTTOM w0.089: v2(114.35,121.88) 114.2,121.73 113.97,121.73 113.94,121.7 113.23,121.7 112.81,122.12 112.37,122.12
  BOTTOM w0.102: 112.37,122.12 110.5,122.12 109.19,123.43 109.19,124.19 108.81,124.57 v1(108.23,124.57) 107.31,124.57 107.16,124.72 107.16,124.86 v2(107.17,124.86)
SML0_SMBDATA: length 206.7
  TOP w0.089: v2(115.16,122.3) 115.56,122.3 UH1.BB39
  TOP w0.102: RH77.2 106.84,126.34 v2(107.19,125.99) ; U31.31 v2(251.33,107.91)
  IN1 w0.109: v2(251.33,107.91) 250.96,107.91 250.85,108.02 250.85,109.02 250.39,109.48 244.81,109.48 243.47,110.81 236.18,110.81 229.94,117.05 229.32,117.05 227.36,119 227.36,127.4 212.37,142.39 207.01,142.39 206.71,142.69 206.34,143.05 198.47,143.05 198.13,143.39 192.8,143.39 192.3,143.88 189.62,143.88 188.72,144.78 187.59,144.78 187.49,144.88 187.49,145.17 187.66,145.34 v2(187.66,145.35)
  IN4 w0.089: 114.65,123.58 114.66,123.56 114.66,123.55 114.89,123.33 114.89,122.57 v2(115.16,122.3)
  IN4 w0.109: 114.65,123.58 114.5,123.73 111.27,123.73 107.73,127.27 107.73,132.84 108.79,133.9 109.68,133.9 113.47,137.69 119.79,137.69 121.18,136.29 128.3,136.29 128.53,136.05 134.18,136.05 135.45,134.78 140.56,134.78 143.78,138.01 149.6,138.01 150.44,138.85 151.85,138.85 155.07,142.07 159.58,142.07 161.86,139.78 171.11,139.78 171.37,139.53 173.34,139.53 174.22,138.64 175.24,138.64 176.25,137.62 180.45,137.62 180.75,137.93 183.61,137.93 184.64,138.96 184.64,141.53 187.5,144.39 187.5,145.18 v2(187.66,145.35)
  BOTTOM w0.089: 112.55,122.35 112.9,122.35 113.33,121.92 113.84,121.92 114.27,122.35 115.11,122.35 v2(115.16,122.3)
  BOTTOM w0.102: 112.55,122.35 110.6,122.35 109.41,123.53 109.41,124.29 107.71,125.99 v2(107.19,125.99)
SML1_SMBCLK: length 140.7
  TOP w0.089: UH1.AW42 115.05,120.92 v2(115.24,120.72)
  TOP w0.102: RH80.2 106.56,124.41 106.96,124.01 v2(107.17,124.01)
  IN1 w0.089: v2(115.24,120.72) 115.42,120.54 115.68,120.54 115.78,120.44 115.87,120.35 116.36,120.35 116.64,120.07 117.56,120.07 120.09,122.6 120.62,122.6 120.63,122.58 125.4,122.58 125.76,122.94 126.61,122.94 126.96,122.59 128.01,122.59 130.32,124.9 131.29,124.9 131.88,124.3 133.28,124.3 134.42,125.44 134.42,126.12 134.41,126.13 134.41,126.2
  IN1 w0.109: 134.41,126.2 134.41,126.5 134.68,126.77 134.68,128.87 134.68,129.27 136.43,131.02 140.94,131.02 141.54,131.61 141.54,131.85 142.03,132.34 145.55,132.34 146.69,133.48 149.82,133.48 150.93,132.37 152.07,132.37 152.69,131.75 153.54,131.75 153.84,132.04 154.24,132.04 154.33,132.14 154.33,132.17 v2(154.32,132.17)
  IN2 w0.089: v2(115.24,120.72) 115.24,120.55 114.72,120.04 114.42,120.04 113.62,120.84 112.86,120.84 112.58,121.11 112.37,121.11
  IN2 w0.127: v2(107.17,124.01) 107.34,123.85 107.34,123.83 107.58,123.58 107.96,123.58 108.12,123.42 108.12,122.96 108.77,122.3 111.32,122.3 111.74,121.89 111.74,121.53 112.16,121.11 112.37,121.11
  IN3 w0.127: v2(206.14,131.72) 206.42,131.44 206.42,129.77 206.54,129.65 206.54,128.35 207.43,127.46 207.43,126.53 208.89,125.07 208.89,113.69 208.64,113.43 207.01,113.43 206.89,113.3 205.91,113.3 205.43,112.83 204.5,112.83 v2(204.35,112.68)
  IN4 w0.109: v2(206.14,131.72) 205.85,131.43 194.59,131.43 194.3,131.72 187.68,131.72 187.63,131.66 185.53,131.66 184.96,131.09 184.38,131.09 183.86,130.57 179.76,130.57 179.45,130.88 174.12,130.88 173.54,131.46 165.67,131.46 163.27,133.86 158.68,133.86 158.27,134.27 156.83,134.27 155.46,132.9 155.19,132.9 154.52,132.23 154.38,132.23 v2(154.32,132.17)
  BOTTOM w0.102: v2(204.35,112.68) 204.4,112.63 205.08,112.63 U51.B6
