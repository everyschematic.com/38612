# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSSP_1: length 24.3
  IN1 w0.254: v2(35.67,26.56) 35.67,26.31 35.87,26.11 36.2,26.11 37.57,27.48 38.47,27.48 39.6,28.61 39.6,29.26 40.11,29.76 41.65,29.76 41.94,30.05 v2(41.94,30.12)
  BOTTOM w0.254: PR710.1 41.94,29.62 v2(41.94,30.12) 42.06,30.25 42.06,30.5 41.81,30.75 PR704.2 41.92,30.88 41.92,31.28 41.74,31.45 41.22,31.45 40.92,31.16 39.94,31.16 39.38,31.72 PQ700.3 ; PR709.1 35.67,27.12 v2(35.67,26.56) 35.67,26.37 36.03,26 36.71,26 38.89,28.19 v1(38.89,29.28) 38.89,30.32 38.08,31.14 PQ703.3
CSSP_2: length 343
  TOP w0.203: PU700.2 273.87,35.15 274.37,35.64 275.95,35.64 276.58,36.28 276.58,36.98 276.86,37.26 PC702.2
  TOP w0.254: v2(280.2,35.78) 280.14,35.85 280.14,36.25 279.38,37.02 278.4,37.02 PC703.1 278.16,37.26 PC702.2 ; v2(182.39,6.37) 182.4,6.37 v1(183.3,6.37)
  IN1 w0.254: v2(243.21,5.84) 242.19,6.86 221.3,6.86 220.24,5.8 183.1,5.8 182.49,6.41 182.43,6.41 v2(182.39,6.37) ; v2(41.94,27.96) 42.02,27.87 42.02,27.38 40.3,25.65 40.3,21.71 42.83,19.18 45.14,19.18 46.62,17.7 46.62,14.13 48.48,12.28 48.48,6.45 49.7,5.23 75.24,5.23 77.9,7.89 107.08,7.89 111.23,3.73 124.88,3.73 124.88,3.73 126.48,3.73 126.48,3.73 140.38,3.73 142.44,5.79 v2(142.44,6.37)
  IN2 w0.254: v2(142.44,6.37) 142.42,6.35 142.42,6.26 143.31,5.38 181.4,5.38 v2(182.39,6.37)
  IN4 w0.254: v2(280.2,35.78) 280.2,35.58 278.94,34.31 278.94,33.79 277.76,32.61 277.76,30.62 281.72,26.65 289.48,26.65 294.69,21.45 295.48,21.45 299.89,17.04 300.89,16.03 300.89,8.61 300.49,8.21 300.49,6.88 298.89,5.28 291.47,5.28 290.22,4.02 269.26,4.02 268.2,5.08 243.97,5.08 v2(243.21,5.84)
  BOTTOM w0.254: v2(41.94,27.96) 42.06,28.09 42.06,28.33 PR710.2
CSSUM_3PH_A: length 10.4
  TOP w0.203: PC1122.1 255.88,49.77 255.88,49.25 256.15,48.98 PU1100.9
  TOP w0.254: PR1143.2 PR1146.2 251.61,54.26 253.24,54.26 PR1148.2 254.56,53.72 v1(254.94,53.34) 255.28,53 PR1142.2 PC1121.2 PC1122.1
CSSUM_3PH_B: length 11.8
  TOP w0.203: PU1100.30 255.75,41.19 255.43,40.88 v1(255.43,39.59) 253.57,37.73 PC1124.2
  TOP w0.254: PR1144.2 255.07,36.11 254,36.11 253.57,36.55 PC1125.2 PC1124.2 253.09,37.61 PR1149.1 PR1147.1 PR1145.1
CV2_ON: length 215.2
  TOP w0.102: v2(108.53,92.53) 108.29,92.29 107.8,92.29 107.5,92.59 107.5,92.82 107.02,93.3 104.43,93.3 100.58,89.45 100.03,89.45 98.27,87.69 93.47,87.69 77.83,72.05 77.83,37.24 76.53,35.94 73.99,35.94 72.35,34.3 JUSH1.24 ; v2(202.92,92.8) 203.05,92.93 203.05,93.82 201.67,95.21 201.67,95.94 202.16,96.43 206.17,96.43 207.81,98.06 208.71,98.06 209,98.35 209,102.56 209.14,102.69 209.14,103.48 207.89,104.73 207.89,106.19 208.25,106.55 208.25,109.4 208.05,109.6 v2(208.05,110.48)
  IN2 w0.127: v2(202.92,92.8) 202.92,92.78 202.85,92.7 202.34,92.7 200.48,94.57 199.63,94.57 199.41,94.34 197.3,94.34 196.37,95.27 191.74,95.27 190.09,96.92 185.66,96.92 184.71,97.87 183.92,97.87 183.92,97.87 183.28,97.87 183.2,97.87 180.95,100.12 180.95,100.35 179.68,101.62 176.2,101.62 175.43,100.85 174.4,100.85 173.91,101.34 172.55,101.34 172.24,101.04 167.49,101.04 167.15,100.69 162.81,100.69 160.8,102.7 157.16,102.7 153.19,98.72 146.74,98.72 144.2,96.18 136.63,96.18 136.08,96.74 134.94,96.74 132.45,94.25 110.99,94.25 110.17,93.43 109.07,93.43 108.53,92.89 v2(108.53,92.53)
  BOTTOM w0.102: v2(208.05,110.48) 207.67,110.86 U51.A9
D_CLKRUN#: length 46.3
  IN3 w0.127: v2(186.13,113.04) 186.13,114.09 186.67,114.63 186.67,115.37 186.28,115.77 186.28,118.32 184.64,119.96 184.64,126.36 184.69,126.41 184.69,126.92 185.62,127.85 187.26,127.85 187.62,128.2 187.62,130.74 182.18,136.18 182.18,143.38 182.84,144.04 183.56,144.04 v2(184.13,144.61)
  BOTTOM w0.102: JDOCK1.111 187.25,147.03 186.03,145.82 185.29,145.82 184.58,145.11 184.58,145.06 v2(184.13,144.61) ; U46.A19 185.67,113.51 186.13,113.05 ; v2(186.13,113.04) 186.13,113.05 ; 186.13,113.05 186.13,113.06 186.18,113.11 187.29,113.11 RP3.8
D_DLDRQ1#: length 65.7
  TOP w0.102: v2(186.66,112.09) 186.66,112.06 187.07,111.66 187.07,109.31 186.73,108.97 185.42,108.97 183.76,110.64 183.06,110.64 182.8,110.38 182.8,110.38 v2(182.62,110.2)
  IN3 w0.127: v2(179.24,143.78) 179.24,143.36 178.5,142.62 178.5,141.32 177.77,140.59 177.77,136.05 178.23,135.59 178.23,131.9 179.62,130.51 180.76,130.51 181.46,129.81 181.46,125.94 183.05,124.35 183.05,118.24 182.85,118.04 182.85,115.47 183.9,114.42 183.9,112.99 183.65,112.73 183.65,112.27 183.3,111.92 182.85,111.92 182.19,111.26 182.19,110.64 v2(182.62,110.2)
  BOTTOM w0.102: v2(182.62,110.2) 182.12,110.7 182.12,111.52 182.28,111.68 183.31,111.68 183.56,111.93 183.73,111.93 U46.B24 ; RP3.6 187.3,111.97 186.77,111.97 v2(186.66,112.09) ; JDOCK1.117 188.75,146.82 188.19,146.26 187.37,146.26 186.48,145.37 186.48,143.97 184.95,142.45 v1(180.4,142.45) 179.81,142.45 179.24,143.02 v2(179.24,143.78)
D_LAD0: length 46.9
  IN3 w0.127: v2(180.13,144.35) 180.55,143.94 180.55,142.64 178.28,140.37 178.28,139.16 179.02,138.41 179.02,135.87 183.14,131.75 183.14,127.92 182.27,127.05 182.27,125.86 183.56,124.56 183.56,119.6 185.26,117.9 185.26,117.7 184.41,116.85 184.41,112.77 184.16,112.52 184.16,110.18 183.28,109.3 v2(183.23,109.3)
  BOTTOM w0.102: U46.B29 183.27,109.26 v2(183.23,109.3) ; JDOCK1.97 183.75,147.28 183.04,146.57 182.94,146.57 v1(181.8,145.43) 180.72,144.35 v2(180.13,144.35)
D_LAD1: length 47.8
  IN3 w0.127: v2(182.63,109.3) 183.05,109.72 183.34,109.72 183.9,110.28 183.9,112.63 184.16,112.88 184.16,114.52 183.84,114.84 183.84,117.54 184.21,117.9 184.21,118.2 183.3,119.1 183.3,124.46 181.96,125.8 181.96,127.2 182.89,128.13 182.89,130.62 178.77,134.73 178.77,138.1 178.02,138.84 178.02,140.49 178.79,141.26 178.79,142.39 v2(180.13,143.72)
  BOTTOM w0.102: v2(182.63,109.3) 183.09,109.76 U46.B28 ; v2(180.13,143.72) 180.51,144.1 180.95,144.1 183.3,146.45 184,146.45 184.25,146.7 JDOCK1.99
D_LAD2: length 48.1
  IN3 w0.127: v2(181.4,143.85) 180.92,143.36 180.92,136.48 183.94,133.46 183.94,133.43 187.11,130.26 187.11,128.8 186.67,128.35 185.4,128.35 184.45,127.4 183.34,127.4 183,127.06 183,125.84 184.07,124.77 184.07,119.81 185.77,118.11 185.77,116.23 185.64,116.11 185.31,116.11 184.94,115.74 184.94,111.2 v2(185.45,110.7)
  BOTTOM w0.102: v2(185.45,110.7) 185.26,110.51 U46.A25 ; v2(181.4,143.85) 181.4,144.1 183.43,146.13 184.64,146.13 185.25,146.75 JDOCK1.103
D_LAD3: length 47.1
  IN3 w0.127: v2(186.04,110.69) 186.44,111.09 186.75,111.09 187.08,111.42 187.08,112.27 186.99,112.37 186.99,114.59 187.19,114.79 187.19,117.77 184.89,120.06 184.89,126.25 184.94,126.3 184.94,126.81 185.66,127.53 187.3,127.53 187.88,128.1 187.88,130.84 182.63,136.09 182.63,143.24 v2(182.8,143.4)
  BOTTOM w0.102: JDOCK1.105 185.75,146.92 184.61,145.78 183.4,145.78 182.48,144.86 182.48,143.72 v2(182.8,143.4) ; U46.A24 184.99,111.01 185.1,111.12 185.6,111.12 v2(186.04,110.69)
D_LFRAME#: length 52.8
  IN3 w0.127: v2(177.84,144.55) 177.84,144.55 177.08,143.78 176.06,143.78 175.34,143.06 175.34,139.64 176.57,138.41 176.57,131.67 177.4,130.84 177.4,128.93 179.75,126.58 179.75,125.08 180.64,124.18 180.64,118.78 181.1,118.32 181.1,116.86 183.65,114.31 183.65,113.09 183.21,112.65 v2(183.21,112.43)
  BOTTOM w0.102: v2(177.84,144.55) 178.31,145.02 178.71,145.02 179.15,144.57 179.15,144.5 179.39,144.27 179.39,144.27 179.68,143.97 179.68,143.15 180,142.83 182.86,142.83 183.24,143.21 183.24,144.04 182.99,144.29 182.99,144.93 183.49,145.43 v1(183.97,145.43) 184.58,145.43 185.22,146.07 185.91,146.07 186.75,146.91 JDOCK1.109 ; U46.B23 183.37,112.26 v2(183.21,112.43)
D_SERIRQ: length 50.1
  IN3 w0.127: v2(185.48,112.99) 185.48,113.55 185.44,113.59 185.44,113.76 186.42,114.74 186.42,115.09 186.36,115.14 186.36,115.22 186.11,115.47 186.11,115.58 186.02,115.67 186.02,118.22 184.32,119.92 184.32,124.88 183.25,125.95 183.25,126.83 183.57,127.15 184.56,127.15 185.51,128.1 187.05,128.1 187.37,128.42 187.37,130.51 181.91,135.97 181.91,143.76 182.75,144.61 v2(183.49,144.61)
  BOTTOM w0.102: U46.A20 184.79,113.05 185.41,113.05 v2(185.48,112.99) 185.67,112.8 185.79,112.8 186.05,112.54 RP3.7 ; JDOCK1.115 188.25,146.76 188,146.51 187.24,146.51 v1(185.91,145.18) 184.76,144.04 184.07,144.04 v2(183.49,144.61)
DAI_12MHZ#: length 229.5
  TOP w0.102: RE11.1 180.68,146.72 v2(180.75,146.65) 180.75,146.42 183.58,146.42 185.3,144.7 185.3,144.23 185.65,143.87 187.62,143.87 188.32,144.57 189.26,144.57 189.64,144.95 191.2,144.95 191.52,144.63 204.74,144.63 208.17,141.21 v1(216.32,141.21) 222.45,141.21 v2(223.69,139.97) ; JIO1.83 317.83,27.8 318.37,28.34 318.37,29.69 318.98,30.31 318.98,31.29 318.75,31.53 318.75,32.16 318.98,32.4 318.98,32.92 318.41,33.49 v2(318.41,34.25)
  IN3 w0.127: v2(223.69,139.97) 230.1,133.56 230.1,128.64 234.04,124.71 234.04,124.1 235.69,122.45 235.69,104.76 241.13,99.32 243.77,99.32 248.23,94.86 249.51,94.86 250.81,93.56 250.81,93.49 251.67,92.63 254.88,92.63 255.11,92.86 256.15,92.86 256.86,92.15 256.86,90.95 257.97,89.83 257.97,88.9 258.47,88.41 258.47,83.61 258.61,83.46 258.61,73.75 262.74,69.63 262.74,67.26 280.58,49.42 297.16,49.42 299.25,47.33 312.14,47.33 312.84,46.63 316.73,46.63 317.63,45.73 v2(317.63,45.49)
  BOTTOM w0.102: v2(180.75,146.65) 180.75,146.65 JDOCK1.89 ; v2(317.63,45.49) 317.63,40.72 318.29,40.05 318.29,39.16 318.11,38.98 318.11,38.5 317.96,38.35 317.96,37.19 318.71,36.44 318.71,34.55 v2(318.41,34.25)
DAI_BCLK#: length 223
  TOP w0.089: JIO1.41 316.16,38.3 v2(316.46,37.99)
  TOP w0.102: RE12.1 177.63,147.21 177.75,147.1 v2(177.75,146.72) 179.29,145.18 184.13,145.18 184.81,144.5 184.81,144.03 185.45,143.39 188.42,143.39 188.74,143.71 192.46,143.71 193.52,142.65 202.73,142.65 v1(208.83,136.54) 212.01,133.37 212.01,124.97 215.78,121.2 215.78,121.02 216.64,120.16 216.64,118.01 217.24,117.42 218.45,117.42 218.68,117.19 218.68,115.58 218.08,114.98 218.08,113.7 218.22,113.56 218.22,111.32 218.04,111.15 217.41,110.51 216.9,110 216.9,108.99 217.54,108.35 218.61,108.35 218.79,108.53 219.37,108.53 219.88,108.01 222.09,108.01 223.13,106.98 223.13,104.54 223.39,104.28 223.39,102.32 223.1,102.03 222.83,102.03 222.48,101.68 221.59,101.68 220.43,100.52 220.43,98.29 v2(220.55,98.17)
  IN1 w0.109: v2(316.46,37.99) 316.45,38.01 316.21,38.01 316.2,38.02 314.48,38.02 312.21,40.29 305.98,40.29 302.24,44.03 290.69,44.03 288.8,45.93 285.56,45.93 284.61,46.87 283.4,46.87 282.16,48.1 276.83,48.1 267.64,57.29 266.13,57.29 260.06,63.36 260.06,66.3 259.34,67.02 259.34,67.02 254.33,72.02 254.33,74.54 251.31,77.56 251.31,79.94 249.27,81.99 249.27,83.9 248.35,84.82 248.35,88.01 247.21,89.14 247.21,89.15 246.97,89.39 246.96,89.39 244.98,91.38 v2(244.98,95.16)
  IN3 w0.127: v2(244.98,95.16) 243.41,95.16 243.04,95.52 239.43,95.52 239.3,95.4 230.2,95.4 229.1,94.29 227.42,94.29 226.95,94.76 222.71,94.76 221.53,95.94 221.53,97.18 v2(220.55,98.17)
  BOTTOM w0.102: v2(177.75,146.72) 177.75,146.72 JDOCK1.77
DAI_DI: length 212.9
  TOP w0.102: JIO1.37 316.55,39.3 v2(317.03,38.82)
  IN1 w0.109: v2(245.67,104.12) 245.89,103.9 245.89,94.71 246.84,93.75 246.84,91.64 250.46,88.02 250.46,85.43 251.66,84.23 252.32,84.23 253.69,82.86 253.69,76.4 255.19,74.89 255.19,72.53 260.91,66.8 260.91,63.71 266.33,58.29 267.96,58.29 277.3,48.96 282.55,48.96 283.64,47.87 285.01,47.87 285.49,47.39 288.62,47.39 291.12,44.88 302.59,44.88 306.33,41.14 312.57,41.14 314.63,39.08 316.77,39.08 v2(317.03,38.82)
  IN2 w0.127: v2(179.25,146.71) 179.73,146.23 183.81,146.23 184.26,146.68 189.24,146.68 190.74,145.18 195.47,145.18 198.84,141.82 199.8,141.82 200.97,140.65 224.47,140.65 236.44,128.68 236.44,120.88 235.4,119.83 235.4,111.67 238.84,108.22 241.13,108.22 244.75,104.6 244.75,104.35 245.03,104.07 245.62,104.07 v2(245.67,104.12)
  BOTTOM w0.102: JDOCK1.83 v2(179.25,146.71)
DAI_DO#: length 211.1
  TOP w0.089: JIO1.39 316.29,38.8 v2(316.46,38.63)
  IN1 w0.109: v2(316.46,38.63) 316.45,38.64 314.74,38.64 312.47,40.9 306.23,40.9 302.49,44.65 290.95,44.65 288.44,47.15 285.39,47.15 284.95,47.59 283.56,47.59 282.43,48.72 277.2,48.72 267.87,58.06 266.24,58.06 260.68,63.62 260.68,66.66 254.95,72.39 254.95,74.8 253.45,76.3 253.45,78.68 249.89,82.24 249.89,84.15 249.36,84.68 249.36,88.65 246.56,91.45 246.56,93.71 245.65,94.61 245.65,103.29 245.2,103.74 245.2,104.4 v2(245.5,104.69)
  IN2 w0.127: v2(245.5,104.69) 245.02,104.69 241.23,108.48 238.95,108.48 235.65,111.77 235.65,119.73 236.69,120.77 236.69,128.79 224.58,140.9 201.07,140.9 199.91,142.07 198.95,142.07 195.39,145.63 193.03,145.63 192.45,146.21 190.07,146.21 189.22,147.06 180.93,147.06 180.93,147.07 180.29,147.07 v2(179.93,146.71)
  BOTTOM w0.102: JDOCK1.85 179.75,146.89 v2(179.93,146.71)
DAI_LRCK#: length 218
  TOP w0.089: v2(317.1,37.99) 316.65,37.55 316.2,37.55 315.95,37.8 JIO1.43
  IN1 w0.109: v2(317.1,37.99) 317.08,37.98 317.08,37.74 316.68,37.34 316.46,37.34 315.68,36.56 313.77,36.56 311.98,38.34 309.31,38.34 308.96,38.69 306.58,38.69 301.87,43.41 290.44,43.41 288.54,45.31 285.3,45.31 284.36,46.25 283.15,46.25 281.9,47.49 276.57,47.49 276.21,47.85 267.39,56.67 265.88,56.67 259.44,63.1 259.44,66.04 259.08,66.41 253.72,71.77 253.72,74.28 250.7,77.3 250.7,79.68 248.65,81.73 248.65,83.51 247.71,84.46 247.71,86.68 244.33,90.06 244.33,95.27 245.41,96.36 245.41,102.87 v2(245.13,103.16)
  IN2 w0.127: v2(177.72,146.13) 177.87,145.97 183.92,145.97 184.37,146.43 189.13,146.43 190.63,144.93 195.35,144.93 199.06,141.22 199.89,141.22 200.72,140.39 224.37,140.39 236.19,128.58 236.19,120.98 235.14,119.94 235.14,111.56 238.74,107.97 241.02,107.97 244.49,104.5 244.49,103.8 245.13,103.17 v2(245.13,103.16)
  BOTTOM w0.102: JDOCK1.79 178.25,146.98 178.16,146.89 178.16,146.55 177.74,146.13 v2(177.72,146.13)
DAT_DDC2_DOCK: length 121.2
  TOP w0.102: v2(179.43,85.17) 179.42,85.17 179.24,85 179.24,83.21 177.78,81.74 175.75,81.74 175.58,81.58 175.58,81.58 175.34,81.34 175.34,81.34 174.92,80.92 174.29,80.92 174.1,80.73 174.1,80.47 174.25,80.33 JMXM1.186 174.25,78.97 174.13,78.86 174.13,78.25 173.83,77.95 172.29,77.95 171.4,77.06 v4(170.21,77.06) 167.01,77.06 R3.2
  IN3 w0.127: v2(167.84,151.41) 168.01,151.58 168.01,153.04 169.04,154.07 171.98,154.07 173.04,153.01 173.04,149.9 173.21,149.73 173.21,147.25 174.16,146.3 174.16,145.67 175.15,144.67 176.25,144.67 176.89,145.31 177.95,145.31 178.46,145.82 180.38,145.82 184.45,145.82 185.02,145.24 185.02,143.21 184.64,142.83 184.64,135.44 189.34,130.75 189.34,128.16 187.94,126.77 187.13,126.77 185.65,125.29 185.65,120.39 188,118.04 188,114.61 188.17,114.44 188.17,113.78 188.17,113.76 188.08,113.66 188.08,113.15 188.23,113 188.23,108.37 185.93,106.07 185.93,104.8 185.42,104.29 185.42,102.9 184.7,102.18 184.7,99.14 181.82,96.27 181.82,94.33 182.06,94.09 182.06,92.05 181.55,91.55 180.68,91.55 179.75,90.61 179.75,86.63 179.23,86.11 179.23,85.38 v2(179.43,85.17)
  BOTTOM w0.102: JDOCK1.46 168.75,154.95 168.89,154.82 168.89,154.17 168.02,153.3 168.02,151.59 v2(167.84,151.41)
DAT_KBD: length 85.4
  TOP w0.102: RP6.8 192.44,118.57 192.69,118.32 193.29,118.32 194.99,116.61 194.99,116.08 195.41,115.67 195.41,114.68 196.65,113.44 196.65,111.14 v2(197.01,110.77)
  IN3 w0.127: v2(197.01,110.77) 196.89,110.89 194.12,110.89 193.95,110.73 193.61,110.73 193.45,110.57 192.51,110.57 191.69,111.4 191.43,111.4 191.03,111.8 191.03,114.83 189.77,116.09 189.77,119.14 187.86,121.04 187.86,123.96 188.75,124.84 188.75,125.37 189.32,125.94 192.11,125.94 192.57,126.41 192.57,130.6 193.06,131.08 194.03,131.08 194.8,131.85 194.8,132.67 193.59,133.88 192.13,133.88 189.59,136.42 189.59,143.55 189.72,143.68 189.72,145.86 188.64,146.94 188.64,153.22 186.2,155.66 184.15,155.66 183.07,154.58 180.17,154.58 178.16,156.59 178.16,157.51 v2(178.29,157.64)
  BOTTOM w0.102: JDOCK1.80 178.25,156.97 178.11,157.11 178.11,157.46 v2(178.29,157.64) ; U51.B41 196.56,110.11 197.01,110.56 v2(197.01,110.77)
DAT_MSE: length 82.2
  TOP w0.102: RP6.7 191.94,118.39 192.49,117.84 193.03,117.84 194.04,116.83 194.04,116.14 v1(194.67,115.5) 194.92,115.25 194.92,114.48 196.17,113.24 196.17,110.94 196.81,110.29 197.21,110.29 197.49,110.58 197.49,110.66 v2(197.59,110.77)
  IN3 w0.127: v2(175.4,145.31) 175.59,145.5 176.28,145.5 176.64,145.86 176.64,147.02 177.21,147.59 181.4,147.59 182.54,146.45 184.66,146.45 187.18,143.93 187.18,136.25 189.59,133.84 189.59,131.93 190.12,131.4 190.54,131.4 190.99,130.96 190.99,127.15 190.8,126.96 188.9,126.96 187.68,125.74 187.68,125.21 186.85,124.38 186.85,120.62 187.34,120.13 187.75,119.72 188.75,118.72 188.75,115.67 190.01,114.4 190.01,110.36 191.88,108.49 194.66,108.49 195.05,108.88 195.05,109.94 195.43,110.32 197.15,110.32 v2(197.59,110.77)
  BOTTOM w0.102: v2(175.4,145.31) 175.57,145.49 176.32,145.49 176.62,145.79 176.62,146.82 176.75,146.95 176.75,146.95 JDOCK1.73 ; U51.B42 196.31,110.61 196.49,110.79 196.49,110.86 196.84,111.21 197.25,111.21 197.59,110.87 v2(197.59,110.77)
DAT_TP_SIO: length 151
  TOP w0.102: R370.1 CZ30.1 RZ18.2 287.62,33.37 287.56,33.43 v2(287.56,33.42)
  IN1 w0.109: v2(196.64,109.41) 196.64,109.37 196.5,109.23 196.07,109.23 195.9,109.39 195.9,109.66 196.33,110.08 197.51,110.08 198.16,109.43 198.16,108.86 198.7,108.32 198.7,106.99 199.5,106.19 204.96,106.19 205.83,107.07 208.25,107.07 209.5,105.82 209.5,105.26 210.8,103.97 211.82,103.97 213.47,102.32 213.83,102.32 214.06,102.09 214.06,101.76 213.98,101.68 213.71,101.68 v2(213.56,101.83)
  IN3 w0.127: v2(287.56,33.42) 287.81,33.68 288.04,33.68 288.22,33.49 288.22,33.16 288.02,32.96 287.32,32.96 287.09,33.19 287.09,34.44 283.63,37.89 283.63,39.62 272.87,50.39 271.4,50.39 265.35,56.44 265.35,57.43 257.98,64.79 257.98,68.44 253.98,72.44 253.98,85.74 251.88,87.84 237.15,87.84 233.11,91.88 217.29,91.88 216.32,92.84 216.32,96.52 214.42,98.42 214.42,101.34 214.08,101.68 213.7,101.68 v2(213.56,101.83)
  BOTTOM w0.102: U51.B40 196.42,109.61 196.64,109.4 v2(196.64,109.41) ; v2(213.56,101.83) 213.56,102.08 v3(212.9,102.74)
DAT_TP_SIO_R: length 8.7
  TOP w0.102: v1(297.86,30.35) 296.36,31.85 JKBTP1.8 291.25,31.85 290.64,32.46 R370.2
DC_BLOCK_GC: length 388.1
  TOP w0.102: v2(32.49,40.41) v1(32.94,40.85)
  TOP w0.254: v2(32.49,40.41) 32.26,40.17 PQ708.4 ; PU1001.7 334.7,50.03 v2(334.96,49.76) 335.11,49.61 PR700.1
  IN2 w0.254: v2(32.49,40.41) 32.49,38.93 39.03,32.39 39.03,25.67 40.48,24.22 40.48,22.78 40.94,22.33 40.94,21.29 43.54,18.69 v2(47.16,18.69)
  IN4 w0.254: v2(47.16,18.69) 45.96,17.49 45.96,9.37 50.2,5.13 112.66,5.13 115.23,7.7 138.22,7.7 142.33,3.59 180.02,3.59 180.2,3.77 226.45,3.77 227.65,4.97 236.99,4.97 238.52,3.45 243.5,3.45 244.75,4.7 268.04,4.7 269.23,3.51 290.87,3.51 291.76,4.4 292.84,4.4 293.73,3.51 308.6,3.51 310.44,5.35 313.8,5.35 315.07,4.08 326.11,4.08 326.81,4.78 326.81,8.52 331.5,13.2 331.5,14.78 336.47,19.76 336.47,27.17 334.37,29.27 332.63,29.27 332.17,29.73 332.17,34.7 331.74,35.13 331.74,36.41 331.99,36.66 332.34,36.66 333.39,37.7 333.39,39.74 333.67,40.02 333.67,43.73 333.41,43.99 333.41,45.88 332.85,46.44 332.85,48.92 333.04,49.11 334.69,49.11 334.96,49.38 v2(334.96,49.76)
DCIN_ACOK#: length 362.2
  TOP w0.102: v1(335.02,44.11) PQ1074.5 v2(337.66,44.11) ; v2(53.85,31.87) 53.85,31.07 53.63,30.85 JIO2.36
  IN1 w0.109: v2(254.83,12) 255.56,12 256.61,13.05 258.98,13.05 262.5,16.56 281.76,16.56 282.74,15.58 284.2,15.58 285.62,16.99 297.51,16.99 300,14.5 310.45,14.5 314.85,10.1 328.52,10.1 329.41,11 333.78,11 333.96,10.82 339.13,10.82 339.55,11.23 339.55,15.43 337.7,17.28 337.7,44.07 v2(337.66,44.11) ; v2(141.01,8.77) 140.94,8.85 139.75,8.85 139.6,9 139.25,9 139.01,8.76 139.01,8.75 138.81,8.55 136.32,8.55 134.31,6.54 132.68,6.54 132.67,6.53 130.87,6.53 130.39,6.05 126.07,6.05 125.93,5.91 114.06,5.91 107.26,12.7 90.69,12.7 88.4,14.99 85.06,14.99 84.99,14.91 77.85,14.91 75.89,12.96 69.93,12.96 69.28,13.6 68.34,13.6 67.7,12.96 58,12.96 57.4,13.56 57.4,14.38 57.16,14.62 56.34,14.62 55.78,15.18 55.78,17.38 56.75,18.35 56.75,19.01 56.41,19.34 55.05,19.34 53.2,21.19 53.2,26.51 53.85,27.16 v2(53.85,31.87)
  IN3 w0.127: v2(254.83,12) 253.74,10.9 252.84,10.9 251.91,9.98 242.36,9.98 240.6,8.22 217.26,8.22 215.96,6.93 200.45,6.93 198.89,8.49 181.8,8.49 180.07,6.77 162.23,6.77 158.48,10.52 144.16,10.52 142.42,8.77 v2(141.01,8.77)
DDR4_DRAMRST#_PCH: length 221.5
  TOP w0.089: v2(127.43,121.33) 127.81,121.71 127.81,122.17 127.89,122.25 128.14,122.25 128.3,122.41 128.3,122.61 128.52,122.83 UH1.BC14
  TOP w0.102: v2(103.36,40.06) 103.37,40.08 CD16.1 RD15.1 104.83,40.03 RD7.2 104.91,39.06 RD6.1 ; v2(59.71,46.95) 60.68,45.97 60.68,43.75 61.47,42.96 v1(61.47,38.37) 61.47,37.68 61.73,37.42 61.73,36.37 62.22,35.87 62.76,35.87 v2(63.36,36.48)
  IN1 w0.089: v2(113.01,109.11) 113.01,110.76 112.63,111.15 112.37,111.15 ; v2(127.43,121.33) 127.15,121.33 126.51,120.69 126.21,120.69 126,120.9 126,121.27 125.1,122.17 121.43,122.17 120.88,121.62 119.67,121.62 118.28,120.24 118.28,119.26 118.07,119.05 117.77,119.05 117.62,119.2 116.21,119.2 115.93,118.92 115.93,118.38 115.64,118.1 113.98,118.1 113.06,117.18 112.37,117.18
  IN1 w0.109: 112.37,117.18 111.76,117.18 111.48,116.91 109.66,116.91 108.47,115.72 101.96,115.72 98.91,112.67 98.91,111.02 99.29,110.64 102.63,110.64 103.46,111.46 104.03,111.46 106.19,109.3 108.94,109.3 110.79,111.15 112.37,111.15
  IN4 w0.089: 112.37,106.63 113.39,107.65 113.39,108.73 v2(113.01,109.11)
  IN4 w0.109: v2(59.71,46.95) 59.07,47.58 56.94,47.58 56.42,48.1 56.42,62.47 58.11,64.15 63.18,64.15 87.2,88.17 87.2,91.74 87.6,92.14 93.33,97.88 93.33,97.88 93.55,98.1 94.66,98.1 102.16,98.12 102.34,98.12 103.63,99.41 105.04,100.81 105.88,101.65 106.45,101.65 106.69,101.89 106.69,102.98 108.71,105 110.4,105 112.04,106.63 112.37,106.63 ; v2(103.36,40.06) 83.38,40.06 79.94,43.5 74.55,43.5 72.67,41.63 72.67,36.16 70.79,34.28 68.23,34.28 66.48,36.04 63.81,36.04 v2(63.36,36.48)
DDR_A_ACT#: length 63.1
  TOP w0.089: CPU1.AU3 172.54,37.84 169.5,37.84 169.24,37.58 ; 169.24,37.58 v2(168.71,37.05) ; 169.24,37.58 v1(169.24,37.59)
  TOP w0.203: v2(130.92,43.57) 130.92,43.53 130.49,43.11 129.48,43.11 129.17,42.8 126.52,42.8 125.9,43.42 JDIMM1.114
  IN1 w0.089: 166.41,36.16 168.85,36.16 168.98,36.28 168.98,36.92 168.85,37.05 v2(168.71,37.05)
  IN1 w0.102: v2(130.92,43.57) 131.06,43.71 131.08,43.71
  IN1 w0.208: 131.08,43.71 132.01,43.71 134.38,41.33 134.38,40.24 134.64,39.99 135.92,39.99 136.37,39.54 136.83,39.54 137.02,39.35 137.02,39.17 137.18,39.02 137.66,39.02 137.79,39.14 137.79,39.42 137.91,39.55 138.43,39.55 138.56,39.42 138.56,39.14 138.69,39.02 139.12,39.02 144.32,33.82 162.86,33.82 165.2,36.16 166.41,36.16
  BOTTOM w0.203: JDIMM2.114 131.84,43.42 130.8,42.39 129.73,42.39 129.6,42.51 129.6,42.98 129.73,43.11 130.46,43.11 130.91,43.57 v2(130.92,43.57)
DDR_A_ALERT#: length 62.4
  TOP w0.089: v2(169.43,36.45) 169.59,36.29 v1(170.21,36.29) 170.54,36.62 170.76,36.62 170.91,36.77 173.68,36.77 CPU1.AU5
  TOP w0.203: v2(129.5,43.57) 129.04,43.11 126.65,43.11 125.83,43.92 JDIMM1.116
  IN1 w0.089: 166.41,35.83 168.8,35.83 v2(169.43,36.45)
  IN1 w0.102: 129.5,43.47 v2(129.5,43.57)
  IN1 w0.208: 166.41,35.83 165.38,35.83 162.82,33.27 144.09,33.27 138.89,38.46 136.71,38.46 136.58,38.59 136.58,38.83 136.44,38.97 136.03,38.97 135.91,38.84 135.91,38.59 135.78,38.46 135.3,38.46 135.17,38.59 135.17,38.84 135.05,38.97 134.88,38.97 133.61,40.24 133.61,40.57 133.8,40.76 133.8,41.14 131.87,43.06 129.68,43.06 129.5,43.24 129.5,43.47
  BOTTOM w0.203: v2(129.5,43.57) 129.44,43.57 129.31,43.69 129.31,44.01 129.44,44.14 131.79,44.14 132,43.92 JDIMM2.116
DDR_A_BA0: length 66.5
  TOP w0.089: v2(170.5,44.04) 170.87,44.4 174.45,44.4 174.57,44.53 174.57,44.8 174.45,44.93 CPU1.AH5
  TOP w0.203: v2(129.18,54.88) 128.73,54.43 JDIMM1.150
  IN1 w0.089: v2(170.5,44.04) 170.59,44.04 170.72,44.17 170.72,44.92 170.59,45.05 162.5,45.05 162.26,45.3 162.26,46.27
  IN1 w0.208: v2(129.18,54.88) 128.67,55.38 128.67,55.56 129.02,55.91 129.2,55.91 129.68,55.43 146.84,55.43 148.16,54.11 148.4,54.11 148.54,54.25 149.05,54.25 149.23,54.07 149.23,53.78 148.93,53.48 148.93,53.3 149.34,52.89 149.52,52.89 149.82,53.19 150.11,53.19 154.82,48.48 155.11,48.48 155.4,48.77 155.58,48.77 155.99,48.36 155.99,48.18 155.65,47.84 155.65,47.66 156.08,47.22 156.26,47.22 156.6,47.56 156.78,47.56 157.19,47.15 157.19,46.75 157.36,46.58 161.95,46.58 162.26,46.27
  BOTTOM w0.203: JDIMM2.150 131.73,54.43 130.73,55.42 129.15,55.42 129.02,55.29 129.02,55 129.15,54.88 v2(129.18,54.88)
DDR_A_BA1: length 66.6
  TOP w0.089: CPU1.AH1 169.49,44.93 v2(168.6,44.04)
  TOP w0.203: v2(126.91,53.35) 127.38,53.82 130.02,53.82 130.66,53.17 JDIMM1.145
  IN1 w0.089: 161.49,44.97 161.83,44.64 168,44.64 v2(168.6,44.04)
  IN1 w0.208: v2(126.91,53.35) 125.23,53.35 125.1,53.48 125.1,54.2 125.29,54.39 127.54,54.39 127.54,54.38 127.95,54.38 127.96,54.39 130.31,54.39 130.37,54.33 146.35,54.33 152.84,47.83 153.91,47.83 155.91,45.83 156.39,45.83 156.79,45.42 161.04,45.42 161.49,44.97
  BOTTOM w0.203: v2(126.91,53.35) 126.82,53.26 126.82,52.62 126.95,52.5 127.52,52.5 127.65,52.37 127.65,51.9 127.52,51.77 126.01,51.77 125.58,52.2 125.58,53.04 125.45,53.17 JDIMM2.145
DDR_A_BG0: length 64.3
  TOP w0.089: CPU1.AU1 169.8,37.39 v1(167.77,35.36) v2(166.87,34.46)
  TOP w0.203: v2(130.37,41.51) 130.37,41.79 130.19,41.97 129.36,41.97 129.21,42.12 129.21,42.41 129.48,42.69 130.38,42.69 130.66,42.41 131.06,42.41 131.25,42.6 131.25,43.1 131.42,43.28 131.42,43.54 131.55,43.68 JDIMM1.115
  IN1 w0.089: 162.48,31.49 165,34.01 165.61,34.01 165.74,34.14 165.74,34.53 165.87,34.65 166.75,34.65 166.87,34.53 v2(166.87,34.46)
  IN1 w0.208: 162.48,31.49 143.37,31.49 139.71,35.15 139.37,35.15 138.72,35.8 138.72,36.14 138.57,36.29 137.96,36.29 137.84,36.16 137.84,35.74 137.71,35.61 137.13,35.61 137,35.74 137,36.16 136.87,36.29 135,36.29 131.79,39.5 131.79,40.6 131.55,40.84 131.2,40.84 131.07,40.71 131.07,40.67 130.9,40.51 130.54,40.51 130.37,40.67 v2(130.37,41.51)
  BOTTOM w0.203: JDIMM2.115 125.66,43.68 126.53,42.8 128.8,42.8 129.54,42.07 129.81,42.07 v2(130.37,41.51)
DDR_A_BG1: length 63.1
  TOP w0.089: v2(166.08,33.67) 166.08,34.2 168.09,36.2 168.37,36.2 169.84,37.66 172.06,37.66 CPU1.AU2
  TOP w0.203: v2(129.07,41.51) 129.07,41.4 129.56,40.92 131.03,40.92 131.55,41.44 131.55,42.76 131.97,43.17 JDIMM1.113
  IN1 w0.089: 160.67,30.94 162.6,30.94 164,32.34 164,32.72 164.96,33.67 v2(166.08,33.67)
  IN1 w0.208: v2(129.07,41.51) 129.07,41.02 130.21,39.89 130.67,39.89 131.09,39.47 131.09,39 135.04,35.06 138.65,35.06 139.3,34.41 139.55,34.41 143.03,30.94 160.67,30.94
  BOTTOM w0.203: JDIMM2.113 125.73,43.17 126.4,42.5 127.59,42.5 128.02,42.07 128.25,42.07 128.56,42.38 128.8,42.38 129.07,42.1 v2(129.07,41.51)
DDR_A_CB0: length 65.4
  TOP w0.089: v2(170,33.49) 170,33.82 170.68,34.5 171.96,34.5 CPU1.BA2
  TOP w0.14: v2(127.88,35.75) 128.4,35.23 130.49,35.23 131.93,36.68 JDIMM1.87
  IN3 w0.17: v2(170,33.49) 170,31.56 167.12,28.68 152.4,28.68 152.23,28.85 152.23,29.21 152.06,29.38 151.72,29.38 151.55,29.21 151.55,28.85 151.38,28.68 151.04,28.68 150.87,28.85 150.87,29.21 150.7,29.38 150.36,29.38 150.19,29.21 150.19,28.85 150.02,28.68 149.68,28.68 149.51,28.85 149.51,29.21 149.34,29.38 149,29.38 148.73,29.12 148.24,29.12 147.98,29.38 145.86,29.38 140.29,34.95 137.36,34.95 136.93,34.52 128.86,34.52 127.88,35.5 v2(127.88,35.75)
  BOTTOM w0.14: v2(127.88,35.75) 127.88,36.28 127.18,36.97 126.89,36.97 126.72,36.81 126.72,36.38 126.56,36.21 126.33,36.21 126.16,36.38 126.16,36.86 126.06,36.97 125.84,36.97 125.54,36.68 JDIMM2.87
DDR_A_CB1: length 64.7
  TOP w0.089: CPU1.BA1 170.81,34.87 169.44,33.5 v2(169.44,33.51)
  TOP w0.14: v2(129.15,35.78) 128,36.92 JDIMM1.88
  IN3 w0.17: v2(129.15,35.78) 129.15,35.14 129.37,34.91 136.76,34.91 137.2,35.35 140.69,35.35 146.16,29.88 152.69,29.88 152.86,29.71 152.86,29.25 153.03,29.08 153.37,29.08 153.54,29.25 153.54,29.71 153.71,29.88 154.05,29.88 154.22,29.71 154.22,29.25 154.39,29.08 154.73,29.08 154.9,29.25 154.9,29.71 155.07,29.88 155.41,29.88 155.58,29.71 155.58,29.25 155.75,29.08 156.09,29.08 156.26,29.25 156.26,29.71 156.43,29.88 156.77,29.88 156.94,29.71 156.94,29.25 157.11,29.08 157.45,29.08 157.62,29.25 157.62,29.71 157.79,29.88 158.14,29.88 158.31,29.71 158.31,29.25 158.48,29.08 167.03,29.08 169.44,31.48 v2(169.44,33.51)
  BOTTOM w0.14: v2(129.15,35.78) 129.6,35.33 130.75,35.33 131.23,35.81 131.23,36.51 131.65,36.92 JDIMM2.88
DDR_A_CB2: length 66
  TOP w0.089: CPU1.AY4 173.64,35.73 v2(173.31,36.05)
  TOP w0.14: v2(127.22,39.48) 127.65,39.05 129.38,39.05 130.64,40.31 131.16,40.31 132.02,41.17 JDIMM1.105
  IN3 w0.17: v2(127.22,39.48) 128.41,38.29 142.44,38.29 148.15,32.58 153.61,32.58 153.78,32.75 153.78,33.29 153.9,33.42 154.33,33.42 154.46,33.29 154.46,32.75 154.63,32.58 155.11,32.58 155.28,32.75 155.28,33.42 155.45,33.59 164.4,33.59 165.14,32.85 165.89,32.85 167.54,34.5 171.76,34.5 v2(173.31,36.05)
  BOTTOM w0.14: JDIMM2.105 125.47,41.17 125.98,40.67 128.2,40.67 128.4,40.47 128.4,40.18 128.2,39.98 127.33,39.98 127.22,39.87 v2(127.22,39.48)
DDR_A_CB3: length 66.6
  TOP w0.089: v2(173.87,36.03) 174.29,35.62 CPU1.AY5
  TOP w0.14: JDIMM1.101 131.42,40.17 131.17,39.92 131.17,39.71 131.34,39.54 131.34,39.23 130.89,38.78 130.55,38.78 130.38,38.95 129.65,38.95 129.27,38.56 129.27,38.37 129.39,38.25 130.61,38.25 130.75,38.11 130.75,37.92 v2(130.6,37.77)
  IN3 w0.17: v2(130.6,37.77) 130.72,37.89 141.95,37.89 147.67,32.18 155.67,32.18 155.84,32.35 155.84,33.02 156.01,33.19 156.35,33.19 156.52,33.02 156.52,32.35 156.69,32.18 157.03,32.18 157.2,32.35 157.2,33.02 157.37,33.19 157.71,33.19 157.88,33.02 157.88,32.35 158.05,32.18 158.39,32.18 158.56,32.35 158.56,33.02 158.73,33.19 163.57,33.19 164.65,32.11 165.84,32.11 167.94,34.21 172.06,34.21 v2(173.87,36.03)
  BOTTOM w0.14: JDIMM2.101 125.32,40.17 126.7,38.8 129.6,38.8 130.6,37.8 v2(130.6,37.77)
DDR_A_CB4: length 65.7
  TOP w0.089: CPU1.BA5 173.98,34.56 v2(173.98,34.5)
  TOP w0.14: JDIMM1.92 125.51,37.92 126.34,38.76 128.4,38.76 128.57,38.59 128.57,38.36 128.4,38.2 127.47,38.2 127.33,38.07 v2(127.33,37.76)
  IN3 w0.17: v2(127.33,37.76) 128.85,36.24 136.96,36.24 137.06,36.15 141.43,36.15 146.77,30.8 163.04,30.8 163.9,29.95 166.1,29.95 167.67,31.52 167.67,33.49 168.14,33.95 173.43,33.95 v2(173.98,34.5)
  BOTTOM w0.14: JDIMM2.92 131.63,37.92 130.91,37.2 127.89,37.2 v2(127.33,37.76)
DDR_A_CB5: length 66.9
  TOP w0.089: CPU1.BA4 173.06,34.29 170.78,34.29 170.44,33.96 170.44,33.29 170.17,33.01 168.75,33.01 v2(168.26,33.5)
  TOP w0.14: JDIMM1.91 131.82,37.68 131.66,37.51 131.66,36.91 131.41,36.66 130.63,36.66 130.5,36.8 129.19,36.8 129.07,36.68 129.07,36.34 129.15,36.25 130.29,36.25 130.42,36.13 v2(130.42,35.8)
  IN3 w0.17: v2(130.42,35.8) 130.9,35.31 136.6,35.31 137.03,35.75 141.13,35.75 146.5,30.37 158.6,30.37 158.77,30.2 158.77,29.7 158.94,29.53 159.28,29.53 159.45,29.7 159.45,30.2 159.62,30.37 159.96,30.37 160.13,30.2 160.13,29.7 160.3,29.53 160.64,29.53 160.81,29.7 160.81,30.2 160.98,30.37 161.32,30.37 161.49,30.2 161.49,29.7 161.66,29.53 162,29.53 162.17,29.7 162.17,29.84 162.3,29.97 162.73,29.97 162.85,29.84 162.85,29.7 163.02,29.53 166.05,29.53 168.26,31.74 v2(168.26,33.5)
  BOTTOM w0.14: v2(130.42,35.8) 129.32,36.9 127.6,36.9 127.21,37.28 126.13,37.28 125.74,37.68 JDIMM2.91
DDR_A_CB6: length 64.4
  TOP w0.089: CPU1.AY1 171.69,35.73 v2(171.36,36.05)
  TOP w0.14: JDIMM1.104 127.73,40.92 v2(129.17,39.49)
  IN3 w0.17: v2(171.36,36.05) 170.58,35.28 166.09,35.28 165.37,34.55 148,34.55 147.31,35.24 147.31,35.48 147.43,35.6 147.43,35.78 147.13,36.08 146.95,36.08 146.83,35.96 146.59,35.96 146.35,36.2 146.35,36.44 146.52,36.61 146.52,36.79 146.22,37.09 146.04,37.09 145.87,36.92 145.63,36.92 145.39,37.16 145.39,37.4 145.69,37.7 145.69,37.88 145.38,38.18 145.2,38.18 144.91,37.88 144.66,37.88 144.42,38.13 144.42,38.37 144.72,38.66 144.72,38.84 144.42,39.15 144.24,39.15 143.94,38.85 143.7,38.85 143.46,39.09 142.49,39.09 142.32,39.26 142.32,39.5 142.19,39.63 141.76,39.63 141.64,39.5 141.64,39.26 141.47,39.09 141.12,39.09 140.95,39.26 140.95,39.45 140.78,39.62 140.44,39.62 140.27,39.45 140.27,39.26 140.1,39.09 139.76,39.09 139.59,39.26 139.59,39.45 139.42,39.62 139.08,39.62 138.91,39.45 138.91,39.26 138.74,39.09 138.4,39.09 138.23,39.26 138.23,39.45 138.06,39.62 137.72,39.62 137.55,39.45 137.55,39.26 137.38,39.09 137.04,39.09 136.87,39.26 136.87,39.45 136.7,39.62 136.36,39.62 136.19,39.45 136.19,39.26 136.02,39.09 134.37,39.09 134.2,39.26 134.2,39.45 134.03,39.62 133.69,39.62 133.52,39.45 133.52,39.26 133.35,39.09 133.01,39.09 132.84,39.26 132.84,39.45 132.67,39.62 132.33,39.62 132.16,39.45 132.16,39.26 131.99,39.09 131.65,39.09 131.48,39.26 131.48,39.45 131.31,39.62 130.97,39.62 130.8,39.45 130.8,39.26 130.63,39.09 129.57,39.09 v2(129.17,39.49)
  BOTTOM w0.14: JDIMM2.104 132.03,40.92 131.37,40.26 131.14,40.26 130.97,40.42 130.74,40.42 130.58,40.26 130.58,40.03 130.74,39.87 130.74,39.63 130.62,39.51 129.2,39.51 v2(129.17,39.49)
DDR_A_CB7: length 65.1
  TOP w0.089: v2(172.01,36.05) 172.34,35.73 CPU1.AY2
  TOP w0.14: v2(127.88,39.48) 127.88,40.32 127.66,40.54 127.36,40.54 127.14,40.32 127.14,40.1 126.98,39.94 126.75,39.94 126.59,40.1 126.59,40.36 126.34,40.61 125.99,40.61 125.74,40.36 125.74,40.06 125.6,39.92 JDIMM1.100
  IN3 w0.17: v2(172.01,36.05) 170.83,34.88 166.45,34.88 165.56,33.99 153.87,33.99 153.21,33.32 153.21,33.11 153.08,32.98 152.65,32.98 152.53,33.11 152.53,33.82 152.36,33.99 152.02,33.99 151.85,33.82 151.85,33.11 151.72,32.98 151.29,32.98 151.16,33.11 151.16,33.82 150.99,33.99 150.65,33.99 150.48,33.82 150.48,33.11 150.36,32.98 149.93,32.98 149.8,33.11 149.8,33.82 149.63,33.99 149.29,33.99 149.12,33.82 149.12,33.11 149,32.98 148.57,32.98 148.44,33.11 148.44,33.82 148.27,33.99 147.76,33.99 143.06,38.69 128.67,38.69 v2(127.88,39.48)
  BOTTOM w0.14: v2(127.88,39.48) 128.31,39.05 131.08,39.05 131.95,39.92 JDIMM2.100
DDR_A_CKE0: length 57.4
  TOP w0.089: v2(164.56,32.77) 164.56,33.41 169.27,38.12 CPU1.AT1
  IN1 w0.178: v2(164.56,32.77) 164.49,32.69 164.49,31.97 162.96,30.44 142.82,30.44 139.35,33.92 139.09,33.92 138.44,34.56 134.72,34.56 129.26,40.03 127.49,40.03 127.3,40.22 127.3,40.84 127.8,41.34 v2(127.8,41.54)
  BOTTOM w0.165: v2(127.8,41.54) 127.37,41.97 125.82,41.97 125.62,42.17 JDIMM2.109
DDR_A_CKE1: length 56.8
  TOP w0.089: v2(172.01,38.57) 172.34,38.24 CPU1.AT2
  IN1 w0.089: 166.02,36.51 167.47,36.51 167.97,37.01 167.97,37.39 168.25,37.68 169.93,37.68 170.37,37.23 171.61,37.23 172.01,37.63 v2(172.01,38.57)
  IN1 w0.178: v2(135.66,41.61) 135.04,40.99 135.04,40.65 135.2,40.49 135.57,40.49 136.16,41.08 136.38,41.08 136.67,40.79 136.67,40.57 136.54,40.44 136.54,40.18 136.66,40.05 137.17,40.05 137.3,40.18 137.3,40.52 137.42,40.65 137.88,40.65 138.01,40.52 138.01,40.18 138.14,40.05 138.68,40.05 138.81,40.18 138.81,40.52 138.94,40.65 139.84,40.65 140.02,40.47 140.02,40.28 139.61,39.87 139.61,39.29 144.58,34.32 162.85,34.32 165.05,36.51 166.02,36.51
  BOTTOM w0.165: v2(135.66,41.61) 135.66,41.77 136.6,42.71 136.6,44.22 136.47,44.34 136.05,44.34 135.93,44.22 135.93,43.11 134.87,42.06 133.92,42.06 133.55,42.42 JDIMM2.110
DDR_A_CKE2: length 59.6
  TOP w0.089: CPU1.AT3 172.99,38.24 v2(172.66,38.57)
  TOP w0.165: JDIMM1.109 134.66,42.17 134.83,42.34 134.83,42.49 134.99,42.65 135.32,42.65 135.49,42.49 135.49,42.34 135.65,42.17 136.69,42.17 136.93,41.93 v2(136.93,41.61)
  IN1 w0.089: v2(172.66,38.57) 172.79,38.57 172.91,38.69 172.91,38.98 172.79,39.11 171.34,39.11 170.92,38.69 170.92,38.5 171.53,37.89 171.53,37.65 171.38,37.5 171.16,37.5 170.72,37.94 168.02,37.94 167.64,37.55 167.64,37.05 167.44,36.85 166.38,36.85
  IN1 w0.178: v2(136.93,41.61) 136.82,41.5 136.82,41.31 137.01,41.13 137.27,41.13 137.46,41.32 137.75,41.32 137.94,41.13 140.04,41.13 140.68,40.49 140.68,40.26 140.09,39.67 140.09,39.49 140.41,39.17 140.59,39.17 141.21,39.78 141.39,39.78 141.71,39.46 141.71,39.28 141.1,38.66 141.1,38.48 141.42,38.16 141.6,38.16 142.22,38.78 142.4,38.78 142.72,38.45 142.72,38.27 142.1,37.66 142.1,37.48 142.43,37.15 142.61,37.15 143.22,37.77 143.4,37.77 143.72,37.45 143.72,37.27 143.11,36.65 143.11,36.47 143.43,36.15 143.61,36.15 144.23,36.76 144.41,36.76 144.73,36.44 144.73,36.26 144.11,35.64 144.11,35.47 144.44,35.14 144.62,35.14 145.23,35.76 145.47,35.76 145.74,35.48 145.74,34.93 145.87,34.8 162.83,34.8 164.88,36.85 166.38,36.85
DDR_A_CKE3: length 57.6
  TOP w0.089: v2(173.95,37.74) CPU1.AT5
  TOP w0.165: JDIMM1.110 125.59,42.42 v2(126.5,41.51)
  IN1 w0.178: v2(173.95,37.74) 172.74,36.53 170.51,36.53 168.99,35.01 165.56,35.01 162.54,31.99 143.57,31.99 138.77,36.79 135.2,36.79 132.34,39.66 132.34,40.78 131.12,41.99 126.98,41.99 v2(126.5,41.51)
DDR_A_CLK0: length 62
  TOP w0.089: CPU1.AG1 171.86,45.67 171.93,45.74 171.93,45.88 171.82,45.99 171.33,45.99 171.14,45.8 170.95,45.8 167.2,45.8 164.6,43.2 164.6,41.71 v2(164.79,41.53)
  IN1 w0.109: v2(164.79,41.53) 164.66,41.53 164.49,41.69 164.49,41.84 164.63,41.98 164.63,42.36 164.41,42.59 163.82,42.59 163.42,42.2 163.22,42.2 162.8,42.62 161.88,42.62 161.62,42.36 161.62,41.96 161.51,41.84 161.22,41.84 160.95,42.11 152.99,42.11 152.79,42.31 152.45,42.31 152.15,42.02 151.97,42.02 151.77,42.22 151.77,42.33 152.07,42.64 152.07,43.03 144.25,50.85 142.98,50.85 142.74,50.61 142.74,50.35 142.63,50.24 142.3,50.24 142.19,50.35 142.19,50.61 141.95,50.85 139.26,50.85 139.06,51.06 137.48,51.06 137.2,50.77 137.11,50.69 135.37,50.69 134.91,50.24 134.62,50.24 134.21,50.65 133.76,50.65 133.56,50.45 133.24,50.45 132.91,50.78 132.36,50.78 132.13,50.55 131.97,50.39 128.48,50.39 128.38,50.29 127.87,50.29 127.6,50.02 127.6,49.75 127.5,49.64 v2(127.37,49.64)
  BOTTOM w0.102: JDIMM2.137 125.6,49.17 125.7,49.27 126.1,49.27 126.32,49.49 126.32,49.83 126.17,49.99 126.17,50.07 126.35,50.26 126.42,50.32 126.5,50.32 126.78,50.05 127.23,50.05 127.35,50.16 127.48,50.16 127.55,50.09 127.55,49.71 127.48,49.64 v2(127.37,49.64)
DDR_A_CLK1: length 64.8
  TOP w0.089: v2(166.69,41.53) 166.69,42.75 167.27,43.32 170.14,43.32 170.59,42.87 172.06,42.87 CPU1.AK2
  IN1 w0.109: v2(129.56,50.8) 129.67,50.92 129.67,51.3 130.09,51.72 131.09,51.72 131.31,51.5 131.31,51.38 131.42,51.27 131.77,51.27 131.88,51.38 131.88,51.59 132.1,51.81 133.12,51.81 133.5,51.43 136.8,51.43 136.89,51.52 137.17,51.8 139.37,51.8 139.57,51.6 143.69,51.6 143.9,51.8 144.2,51.8 144.38,51.62 144.61,51.62 144.79,51.8 145.31,51.8 145.61,51.5 145.61,51.15 145.38,50.93 145.38,50.77 145.62,50.54 145.77,50.54 146,50.77 146.34,50.77 146.71,50.4 146.71,50.06 146.48,49.83 146.48,49.68 146.71,49.44 146.87,49.44 147.09,49.67 147.44,49.67 147.8,49.3 147.8,48.96 147.58,48.73 147.58,48.58 147.81,48.35 147.96,48.35 148.19,48.57 148.53,48.57 148.9,48.21 148.9,47.86 148.67,47.64 148.67,47.48 148.91,47.25 149.06,47.25 149.29,47.48 149.63,47.48 150,47.11 150,46.77 149.77,46.54 149.77,46.39 150,46.15 150.16,46.15 150.38,46.38 150.73,46.38 151.09,46.01 151.09,45.67 150.87,45.44 150.87,45.29 151.1,45.06 151.25,45.06 151.48,45.28 151.82,45.28 152.19,44.92 152.19,44.57 151.96,44.35 151.96,44.19 152.2,43.96 152.35,43.96 152.58,44.19 152.92,44.19 153.29,43.82 153.29,43.48 153.06,43.25 153.06,43.1 153.29,42.86 153.45,42.86 153.67,43.09 154.02,43.09 154.25,42.86 160.88,42.86 161.1,43.07 164.79,43.07 165.17,42.69 165.17,42.32 165.3,42.18 165.64,42.18 166.29,42.83 167.23,42.83 167.49,42.57 167.49,42.21 167.07,41.79 166.96,41.79 v2(166.69,41.53)
  BOTTOM w0.102: v2(129.56,50.8) 129.71,50.65 129.71,50.4 130.02,50.1 130.67,50.1 131.34,49.43 JDIMM2.138
DDR_A_CLK2: length 70.1
  TOP w0.089: v2(170.5,41.53) 170.43,41.6 170.43,42.01 170.5,42.08 171.11,42.08 171.36,41.83 172.49,41.83 172.67,42.01 172.8,42.01 172.92,41.89 173.05,41.89 173.22,42.06 173.22,42.18 CPU1.AL3
  TOP w0.102: v2(136.6,49.54) 136.4,49.54 136.33,49.46 136.33,49.24 136.48,49.08 137.03,49.08 137.13,49.17 137.13,49.9 137.39,50.16 138.77,50.16 139.04,49.89 v4(139.04,49.42) 139.04,48.36 138.77,48.09 136.41,48.09 136.12,48.38 135.22,48.38 134.82,48.78 134.82,49.12 134.5,49.45 134,49.45 133.9,49.34 133.9,49.25 133.82,49.17 JDIMM1.137
  IN1 w0.109: v2(170.5,41.53) 170.45,41.47 170.34,41.47 170.1,41.23 170.1,41.02 169.84,40.76 163,40.76 162.76,41 162.76,41.49 162.63,41.61 162.34,41.61 162.22,41.49 162.22,41 161.97,40.76 161.28,40.76 160.9,41.14 159.69,41.14 159.49,40.94 158.78,40.94 158.58,41.14 158.14,41.14 157.94,40.94 157.23,40.94 157.03,41.14 156.59,41.14 156.39,40.94 155.68,40.94 155.48,41.14 155.04,41.14 154.84,40.94 154.13,40.94 153.93,41.14 153.49,41.14 153.29,40.94 151.41,40.94 150.4,41.95 150.4,42.29 150.83,42.72 150.83,42.9 150.62,43.11 150.44,43.11 150.02,42.68 149.67,42.68 149.31,43.05 149.31,43.39 149.74,43.82 149.74,43.99 149.52,44.21 149.35,44.21 148.92,43.78 148.58,43.78 148.21,44.14 148.21,44.49 148.64,44.92 148.64,45.09 148.42,45.3 148.25,45.3 147.82,44.88 147.48,44.87 147.11,45.24 147.11,45.59 147.54,46.01 147.54,46.19 147.33,46.4 147.15,46.4 146.73,45.97 146.38,45.97 146.02,46.34 146.02,46.68 146.42,47.09 146.42,47.27 146.21,47.47 146.03,47.47 145.63,47.07 145.28,47.07 144.92,47.43 144.92,47.78 145.34,48.2 145.34,48.38 145.13,48.59 144.96,48.59 144.53,48.17 144.19,48.17 143.82,48.53 143.82,48.88 144.25,49.3 144.25,49.48 144.04,49.69 143.86,49.69 143.43,49.26 143.09,49.26 141.86,49.26 141.55,49.58 141.37,49.58 141.08,49.28 140.68,49.28 140.42,49.54 140.42,49.77 140.31,49.88 139.98,49.88 139.87,49.77 139.87,49.51 139.63,49.26 139.11,49.26 138.87,49.51 138.87,49.87 138.76,49.98 138.43,49.98 138.32,49.87 138.32,49.51 138.08,49.26 137.63,49.26 137.41,49.48 137.41,49.6 137.28,49.72 136.78,49.72 v2(136.6,49.54)
DDR_A_CLK3: length 68
  TOP w0.089: v2(167.96,41.53) 168.1,41.66 168.1,42.19 168.74,42.83 169.92,42.83 170.05,42.7 171.65,42.7 171.66,42.69 171.86,42.69 172.14,42.41 CPU1.AL2
  TOP w0.102: JDIMM1.138 125.45,49.43 125.58,49.55 126.07,49.55 126.63,50.11 127.77,50.11 128.02,50.36 128.02,50.64 v2(128.19,50.8)
  IN1 w0.109: v2(167.96,41.53) 167.96,42.98 167.83,43.12 165.18,43.12 164.93,43.37 154.47,43.37 145.52,52.31 143.68,52.31 143.48,52.11 139.78,52.11 139.58,52.31 136.95,52.31 136.59,51.95 133.71,51.95 133.33,52.33 126.28,52.33 125.26,51.32 124.98,51.32 124.44,50.78 124.44,49.08 124.57,48.95 125.4,48.95 125.53,49.08 125.53,50.77 126.51,51.75 127.79,51.75 128.13,51.4 128.13,50.85 v2(128.19,50.8)
DDR_A_CLK#0: length 62
  TOP w0.089: CPU1.AG2 172.27,45.67 172.15,45.78 172.15,45.97 171.91,46.21 171.24,46.21 171.05,46.01 170.86,46.01 167.11,46.01 164.39,43.29 164.39,41.76 v2(164.15,41.53)
  IN1 w0.109: v2(164.15,41.53) 164.15,41.57 164.27,41.69 164.27,41.94 164.41,42.08 164.41,42.27 164.31,42.36 163.91,42.36 163.52,41.97 163.12,41.97 162.7,42.39 161.97,42.39 161.85,42.27 161.85,41.86 161.6,41.61 161.13,41.61 160.86,41.88 152.9,41.88 152.7,42.08 152.54,42.08 152.25,41.79 151.88,41.79 151.54,42.13 151.54,42.43 151.85,42.74 151.85,42.94 146.93,47.85 144.16,50.62 143.08,50.62 142.97,50.51 142.97,50.25 142.72,50.01 142.21,50.01 141.96,50.25 141.96,50.51 141.86,50.62 139.17,50.62 138.96,50.83 137.57,50.83 137.29,50.55 137.21,50.46 135.46,50.46 135.01,50.01 134.53,50.01 134.11,50.43 133.86,50.43 133.65,50.22 133.15,50.22 132.82,50.55 132.46,50.55 132.29,50.39 132.06,50.16 128.57,50.16 128.47,50.06 127.96,50.06 127.83,49.93 127.83,49.82 v2(128,49.64)
  BOTTOM w0.102: JDIMM2.139 125.42,49.68 125.59,49.5 126,49.5 126.09,49.59 126.09,49.74 125.94,49.89 125.94,50.17 126.19,50.42 126.32,50.55 126.6,50.55 126.88,50.27 127.14,50.27 127.25,50.39 127.58,50.39 127.78,50.19 127.78,49.73 127.86,49.64 v2(128,49.64)
DDR_A_CLK#1: length 64.8
  TOP w0.089: v2(166.06,41.53) 166.17,41.53 166.48,41.83 166.48,42.84 167.18,43.54 170.23,43.54 170.68,43.09 171.25,43.09 171.32,43.15 171.32,43.36 171.42,43.47 171.58,43.47 171.69,43.36 CPU1.AK1
  IN1 w0.109: v2(166.06,41.53) 166.25,41.53 166.32,41.6 166.32,41.68 166.54,41.9 166.74,41.9 166.86,42.02 166.97,42.02 167.26,42.31 167.26,42.47 167.13,42.6 166.39,42.6 165.74,41.96 165.21,41.96 164.94,42.22 164.94,42.6 164.69,42.84 161.19,42.84 160.98,42.63 154.16,42.63 153.92,42.86 153.77,42.86 153.54,42.63 153.2,42.63 152.83,43 152.83,43.35 153.06,43.57 153.06,43.73 152.83,43.96 152.67,43.96 152.45,43.73 152.1,43.73 151.74,44.1 151.74,44.44 151.96,44.67 151.96,44.82 151.73,45.05 151.58,45.05 151.35,44.83 151.01,44.83 150.64,45.2 150.64,45.54 150.86,45.77 150.87,45.92 150.63,46.15 150.48,46.15 150.25,45.92 149.91,45.92 149.54,46.29 149.54,46.64 149.77,46.86 149.77,47.02 149.54,47.25 149.38,47.25 149.16,47.02 148.81,47.02 148.44,47.39 148.44,47.73 148.67,47.96 148.67,48.11 148.44,48.34 148.28,48.34 148.06,48.12 147.71,48.12 147.35,48.49 147.35,48.83 147.57,49.06 147.57,49.21 147.34,49.44 147.19,49.44 146.96,49.22 146.62,49.22 146.25,49.58 146.25,49.93 146.48,50.15 146.48,50.31 146.25,50.54 146.09,50.54 145.87,50.31 145.52,50.31 145.15,50.68 145.15,51.02 145.38,51.25 145.38,51.4 145.21,51.57 144.88,51.57 144.7,51.39 144.29,51.39 144.11,51.57 143.99,51.57 143.79,51.37 139.47,51.37 139.27,51.57 137.26,51.57 136.98,51.29 136.9,51.21 133.4,51.21 133.02,51.59 132.19,51.59 132.11,51.5 132.11,51.29 131.87,51.04 131.33,51.04 131.08,51.29 131.08,51.4 131,51.49 130.19,51.49 129.9,51.21 129.9,51.1 v2(130.2,50.8)
  BOTTOM w0.102: JDIMM2.140 131.74,49.92 131.69,49.87 131.69,49.7 131.64,49.65 131.44,49.65 130.77,50.32 130.11,50.32 129.94,50.5 129.94,50.54 v2(130.2,50.8)
DDR_A_CLK#2: length 70.1
  TOP w0.089: CPU1.AK3 172.7,42.87 172.7,42.34 172.4,42.04 171.45,42.04 171.2,42.3 170.41,42.3 170.21,42.1 170.21,41.82 169.92,41.53 v2(169.87,41.53)
  TOP w0.102: v2(135.87,49.64) 135.89,49.61 135.89,49.43 136.05,49.28 136.05,49.19 136.39,48.85 137.13,48.85 137.35,49.08 137.35,49.8 137.48,49.93 138.68,49.93 138.8,49.8 138.8,48.45 138.69,48.33 v4(137.88,48.33) 136.49,48.33 136.21,48.61 135.32,48.61 135.05,48.87 135.05,49.22 134.59,49.68 JDIMM1.139
  IN1 w0.109: v2(169.87,41.53) 169.87,41.12 169.74,40.99 163.1,40.99 162.99,41.1 162.99,41.58 162.73,41.84 162.25,41.84 161.99,41.58 161.99,41.1 161.88,40.99 161.38,40.99 161,41.37 159.59,41.37 159.39,41.17 158.87,41.17 158.67,41.37 158.04,41.37 157.84,41.17 157.32,41.17 157.12,41.37 156.5,41.37 156.3,41.17 155.77,41.17 155.57,41.37 154.95,41.37 154.75,41.17 154.22,41.17 154.02,41.37 153.4,41.37 153.2,41.17 151.51,41.17 150.63,42.05 150.63,42.2 151.06,42.63 151.06,42.99 150.71,43.34 150.35,43.34 149.92,42.91 149.77,42.91 149.53,43.14 149.53,43.3 149.96,43.73 149.96,44.09 149.61,44.44 149.25,44.44 148.82,44.01 148.67,44.01 148.44,44.24 148.44,44.39 148.87,44.82 148.87,45.18 148.52,45.53 148.16,45.53 147.73,45.1 147.57,45.1 147.34,45.34 147.34,45.49 147.77,45.92 147.77,46.28 147.42,46.63 147.06,46.63 146.63,46.2 146.48,46.2 146.24,46.43 146.24,46.59 146.65,46.99 146.65,47.36 146.31,47.7 145.94,47.7 145.53,47.3 145.38,47.3 145.15,47.53 145.15,47.68 145.57,48.11 145.57,48.48 145.23,48.82 144.86,48.82 144.44,48.39 144.28,48.39 144.05,48.63 144.05,48.78 144.48,49.21 144.48,49.57 144.13,49.92 143.77,49.92 143.34,49.49 143.09,49.49 141.95,49.49 141.64,49.8 141.28,49.8 140.99,49.51 140.77,49.51 140.65,49.64 140.65,49.86 140.4,50.11 139.89,50.11 139.64,49.86 139.64,49.6 139.53,49.49 139.21,49.49 139.1,49.6 139.1,49.97 138.85,50.21 138.34,50.21 138.09,49.97 138.09,49.6 137.98,49.49 137.72,49.49 137.63,49.58 137.63,49.69 137.38,49.95 136.18,49.95 v2(135.87,49.64)
DDR_A_CLK#3: length 68
  TOP w0.089: CPU1.AL1 171.63,42.41 171.56,42.48 169.96,42.48 169.83,42.61 168.83,42.61 168.31,42.1 168.31,41.64 168.43,41.53 v2(168.6,41.53)
  TOP w0.102: JDIMM1.140 125.5,49.92 125.65,49.78 125.98,49.78 126.54,50.34 127.67,50.34 127.79,50.46 127.79,50.68 127.67,50.8 v2(127.53,50.8)
  IN1 w0.109: v2(168.6,41.53) 168.49,41.53 168.19,41.82 168.19,43.08 167.92,43.35 165.28,43.35 165.03,43.6 154.56,43.6 145.62,52.54 143.59,52.54 143.38,52.34 139.88,52.34 139.67,52.54 136.86,52.54 136.49,52.18 133.81,52.18 133.43,52.56 126.18,52.56 125.17,51.54 124.88,51.54 124.21,50.87 124.21,48.99 124.47,48.72 125.5,48.72 125.76,48.99 125.76,50.67 126.61,51.52 127.7,51.52 127.91,51.31 127.91,51.15 127.56,50.8 v2(127.53,50.8)
DDR_A_CS#0: length 62.3
  TOP w0.089: v2(174.62,48.61) 174.62,48 174.55,47.92 174.35,47.92 174.29,47.99 CPU1.AD5
  IN1 w0.089: 163.83,46.5 164.34,45.99 171.44,45.99 172.55,47.1 173.14,47.1 174.62,48.58 v2(174.62,48.61)
  IN1 w0.178: 163.83,46.5 162.12,48.22 158.44,48.22 154.96,51.7 153.92,51.7 149.73,55.89 148.69,55.89 147.54,57.05 129.23,57.05 128.88,56.69 128.88,56.52 127.75,55.39 v2(127.75,54.88)
  BOTTOM w0.165: v2(127.75,54.88) 127.66,54.88 127.53,54.76 127.53,54.55 127.66,54.43 128.25,54.43 128.36,54.31 128.36,54.12 128.1,53.86 127.09,53.86 127.01,53.93 127.01,54.33 126.89,54.45 126.53,54.45 126.4,54.33 126.4,53.64 126.28,53.51 125.86,53.51 125.73,53.64 125.73,54.06 125.61,54.17 JDIMM2.149
DDR_A_CS#1: length 66.2
  TOP w0.089: CPU1.AE2 172.04,47.15 169.81,47.15 v2(169.23,46.58)
  IN1 w0.089: v2(169.23,46.58) 168.04,47.77 165.95,47.77 164.63,49.09 164.63,50.75 163.06,52.32 161.95,52.32
  IN1 w0.178: v2(127.08,59.19) 128.1,60.21 131,60.21 132,61.21 133.02,61.21 133.54,61.72 135.84,61.72 136.28,62.17 143.88,62.17 144.18,61.87 145.23,61.87 145.52,61.58 148.22,61.58 149.87,59.93 152.37,59.93 156.84,55.45 157.53,55.45 160.66,52.32 161.95,52.32
  BOTTOM w0.165: JDIMM2.157 125.6,56.17 125.77,56.34 125.77,57.05 126.16,57.44 127.42,57.44 127.82,57.84 129.28,57.84 129.4,57.96 129.4,58.57 129.28,58.69 127.57,58.69 126.94,58.06 126.23,58.06 126.07,58.22 126.07,58.58 126.68,59.19 v2(127.08,59.19)
DDR_A_CS#2: length 70.8
  TOP w0.089: v2(164.79,46.55) 164.79,46.57 v1(166.15,47.92) 166.81,48.59 171.93,48.59 CPU1.AD2
  TOP w0.165: v2(126.45,54.89) 126.45,55.24 126.75,55.54 127.16,55.54 127.37,55.33 127.87,55.33 128,55.46 128,55.82 128.16,55.99 128.49,55.99 128.66,55.82 128.66,55.54 128.79,55.42 129.19,55.42 129.32,55.54 129.32,55.86 129.45,55.99 129.85,55.99 129.98,55.86 129.98,55.5 130.12,55.36 130.68,55.36 131.11,54.92 131.11,54.67 130.62,54.17 130.62,53.96 130.88,53.7 131.31,53.7 131.45,53.85 131.45,54.01 131.61,54.17 JDIMM1.149
  IN1 w0.089: v2(164.79,46.55) 164.79,47.6 163.64,48.75 163.64,49.26 163.21,49.69 161.95,49.69
  IN1 w0.178: v2(126.45,54.89) 124.72,54.89 124.59,55.02 124.59,56.12 124.88,56.41 125.45,56.41 125.65,56.22 125.65,55.85 125.77,55.72 127.39,55.72 128.39,56.73 128.39,56.95 129.03,57.59 133.37,57.59 134.26,57.59 134.74,58.07 136.35,58.07 136.71,58.43 141.11,58.43 141.63,58.95 147.07,58.95 149.09,56.93 150.06,56.93 154.16,52.82 156.44,52.82 159.58,49.69 161.95,49.69
