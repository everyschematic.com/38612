# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DIMM1_SA2: length 69.6
  TOP w0.102: v2(126.55,9.12) RD28.1 126.54,7.02 RD8.2 126.12,5.74 v1(125.45,5.74) ; JDIMM1.166 123.08,58.43 122.8,58.71 122.8,59.67 122.11,60.36 122.11,60.67 121.45,61.32 v2(121.45,62.34)
  IN1 w0.109: v2(121.45,62.34) 120.78,61.66 119.32,61.66 118.27,60.61 118.27,16.7 125.85,9.12 v2(126.55,9.12)
DIMM2_SA0: length 12.3
  BOTTOM w0.102: v1(127.46,90.01) 127.68,89.8 RD26.2 128.42,88.93 RD35.1 128.43,86.19 131.23,83.39 131.48,83.14 131.73,82.9 131.73,81.06 131.86,80.92 JDIMM2.256
DIMM2_SA1: length 11.3
  BOTTOM w0.102: v1(130.38,90.04) 130.14,89.8 RD20.2 129.37,88.93 RD36.1 128.76,88.32 128.76,86.19 131.7,83.24 131.73,83.21 131.96,82.99 131.96,82.04 132.07,81.92 JDIMM2.260
DIMM2_SA2: length 45.8
  TOP w0.102: v2(137.2,91.27) 137.95,90.52 137.95,89.32 140.55,86.72 141.14,86.72 141.79,86.08 141.79,85.43 143.84,83.37 143.84,82.42 141.47,80.05 141.02,80.05 138.28,77.31 138.28,74.64 v1(137.28,73.63) 136.77,73.12 v2(135.52,73.12)
  BOTTOM w0.102: v2(135.52,73.12) 137.02,71.61 137.02,61.84 135.9,60.71 135.9,59.24 135.26,58.59 133.96,58.59 133.79,58.43 JDIMM2.166 ; v2(137.2,91.27) 137.27,91.33 RD19.2 RD31.1
DIMM3_SA0: length 91.7
  TOP w0.102: v2(113.52,9.16) RD40.1 113.53,7.94 RD38.2 ; JDIMM3.256 111.61,80.92 111.83,81.15 111.83,82.44 v2(112.07,82.68)
  IN1 w0.109: v2(112.07,82.68) 111.45,82.06 109,82.06 108.06,83 106.18,83 104.95,81.77 104.95,80.97 105.77,80.16 105.77,63.27 106.6,62.44 106.6,53.42 104.71,51.54 104.71,17.67 110.93,11.45 112.04,11.45 113.52,9.97 v2(113.52,9.16)
DIMM3_SA1: length 87.9
  TOP w0.102: v2(109.24,82.56) 109.87,81.92 JDIMM3.260 ; v1(111.59,6.98) 111.68,7.07 112.57,7.07 RD37.2 112.58,7.94 RD42.1 112.59,9.05 v2(112.54,9.11)
  IN1 w0.109: v2(112.54,9.11) 112.54,9.51 104.48,17.57 104.48,51.64 106.36,53.52 106.36,62.34 105.53,63.17 105.53,79.86 104.72,80.68 104.72,81.87 106.43,83.59 108.21,83.59 v2(109.24,82.56)
DIMM3_SA2: length 73.1
  TOP w0.102: RD27.2 RD39.1 v1(117.5,7.08) 117.91,7.08 v2(119.93,9.1) ; v2(113.52,60.37) 113.52,60.1 111.85,58.43 JDIMM3.166
  IN1 w0.109: v2(119.93,9.1) 116.31,12.72 113.83,12.72 107.36,19.2 107.36,19.83 106.98,20.21 106.98,22.69 107.55,23.26 107.55,30.94 106.73,31.76 106.73,36.54 107.1,36.91 107.1,38.25 106.75,38.6 106.75,47.74 107.55,48.53 109.52,48.53 111.29,50.31 111.29,58.14 v2(113.52,60.37)
DIMM4_SA0: length 18.4
  TOP w0.102: v1(114.17,89.95) 114.47,89.64 v2(114.47,88.22)
  IN4 w0.109: v2(114.47,88.22) 114.76,87.93 114.76,84.51 114.05,83.8 113.74,83.8 v2(113.45,84.09)
  BOTTOM w0.102: v2(113.45,84.09) 113.52,84.03 114.09,84.03 114.31,84.25 117.75,84.25 118.47,83.52 118.47,83.02 117.71,82.26 117.71,81.11 117.89,80.92 JDIMM4.256 ; v2(114.47,88.22) 114.47,88.28 114.76,88.57 RD55.1 114.76,89.78 RD53.2
DIMM4_SA1: length 15.2
  IN4 w0.109: v2(113.83,88.22) 113.83,87.81 113.96,87.68 v2(113.96,84.48)
  BOTTOM w0.102: v2(113.96,84.48) 117.84,84.48 118.7,83.62 118.7,82.93 117.97,82.2 117.97,82.05 118.1,81.92 JDIMM4.260 ; v1(112.8,91.03) 112.8,90.27 113.27,89.8 RD52.2 113.83,89.78 RD56.1 v2(113.83,88.22)
DIMM4_SA2: length 47.8
  IN1 w0.109: v2(120.96,58.92) 121.65,58.24 123.57,58.24 124.39,59.07 124.39,86.03 125.07,86.71 125.07,88.11 124.44,88.74 121.97,88.74 120.76,87.53 117.24,87.53 116.88,87.89 116.88,88.22 v2(116.88,88.22)
  BOTTOM w0.102: RD51.2 RD54.1 116.88,89.47 v1(116.88,88.79) v2(116.88,88.22) ; JDIMM4.166 120.46,58.43 v2(120.96,58.92)
DIMM_TYPE: length 2.9
  TOP w0.089: UH1.AL44 112.58,117.26 112.37,117.05
  TOP w0.102: RH358.1 v1(111.82,116.73) 112.06,116.73 112.37,117.05
DISP_ON: length 25.1
  TOP w0.102: JEDP1.19 118.79,144.56 118.79,145.18 v2(118.98,145.37) v1(118.98,146.13)
  IN1 w0.109: v2(111.7,147.01) 111.7,146.62 112.63,145.69 112.63,143.91 113.45,143.09 116.69,143.09 v2(118.98,145.37)
  IN2 w0.127: v2(113.07,150.9) 113.64,150.32 113.64,149.05 112.63,148.04 112.12,148.04 111.7,147.62 v2(111.7,147.01)
  BOTTOM w0.102: R1138.1 112.45,151.52 v2(113.07,150.9) ; v2(111.7,147.01) 111.2,147.51 D69.1 D65.1 D64.1
DK_AC_OFF: length 1.9
  TOP w0.254: PU1001.25 332.7,57.49 332.45,57.74 PR1014.1
DK_AC_OFF_EN: length 2
  TOP w0.254: PU1001.22 334.2,57.39 334.43,57.62 v2(334.43,57.81) 334.42,57.82 334.42,58.24 PR1020.1
DK_CSS_GC: length 496.9
  TOP w0.102: v2(244.72,83.7) 244.72,81.99 248.03,78.68 248.03,77.8 240.66,70.43 v1(240.66,69.29) 240.66,67.25 241.79,66.12 v2(241.79,65.61)
  TOP w0.254: v2(337.59,50.82) 337.72,50.95 337.72,51.6 337.13,52.19 PU1001.11
  IN1 w0.109: v2(241.79,65.61) 242.2,65.19 242.2,53.68 245.65,50.24 246.04,50.24 249.66,50.24 249.77,50.13 253.02,50.13 256.52,46.63 256.52,40.15 253.98,37.61 252.58,37.61 251.31,36.34 251.31,34.31 251.57,34.06 255.25,34.06 256.14,33.17 259.31,33.17 259.68,32.8 264.95,32.8 265.6,32.15 265.6,30.37 264.65,29.42 264.65,23.64 263.19,22.18 263.19,19.07 258.68,14.56 253.86,14.56 253.59,14.29 251.01,14.29 250.42,14.88 249.53,14.88 248.96,14.31 248.96,10.37 244.02,5.43 243.04,5.43 241.92,6.55 228.04,6.55 226.72,5.24 182.26,5.24 180.49,7.02 180.49,8.9 179.76,9.62 179.76,11.98 178.31,13.43 177.59,13.43 176.35,12.2 176.35,10.62 175.96,10.23 173.48,10.23 171.79,8.54 170.59,8.54 169.32,7.27 160.59,7.27 160.43,7.44 159.19,7.44 158.81,7.05 157.76,7.05 157.36,7.46 157.36,7.6 156.98,7.98 156.98,8.88 156.62,9.24 145.23,9.24 145.23,9.23 144.19,9.23 143.32,8.36 141.51,8.36 141.23,8.08 136.51,8.08 134.4,5.97 130.97,5.97 130.43,5.43 113.86,5.43 107.06,12.23 90.5,12.23 88.34,14.39 77.99,14.39 76.07,12.47 57.68,12.47 54.03,16.12 54.03,17.52 52.68,18.87 52.68,24.42 49.47,27.62 43.5,27.62 42.71,28.4 41.47,28.4 39.81,26.74 39.81,25.5 38.67,24.36 34.55,24.36 33.65,23.46 32.14,23.46 31.41,24.19 31.41,25.48 31.12,25.78 v2(31.12,26.39)
  IN2 w0.127: v2(244.72,83.7) 245.09,83.33 248.06,83.33 253.44,77.95 253.44,76.74 259.25,70.93 259.25,68.61 261.24,66.62 261.24,65.71 278.09,48.86 283.03,48.86 286.09,45.8 290.68,45.8 294.98,41.5 294.98,40.76 297.81,37.92 299.65,37.92 300.85,39.12 308.23,39.12 309.72,40.62 315.28,40.62 315.84,41.18 320.5,41.18 321.35,40.33 323.44,40.33 326.77,43.66 328.96,43.66 329.51,44.21 330.5,44.21 332.41,46.12 333.89,46.12 334.39,46.62 334.39,47.84 335.08,48.53 336.17,48.53 336.56,48.93 336.56,50.31 336.86,50.61 337.39,50.61 v2(337.59,50.82)
  BOTTOM w0.254: v2(31.12,26.39) 31.12,27.05 PR714.1
DK_PWR_BAR: length 1.8
  TOP w0.254: PU1001.33 329.25,53.19 PR1007.2
DL_1.2V: length 12.1
  IN4 w1.016: 63.65,21.8 65.81,23.96 74.85,23.96
  vias: v1(61.65,20.19) v2(62.19,20.78) v2(62.19,20.15) v2(75.78,24.21) v2(75.78,23.58)
DMI_CRX_PTX_N0: length 90.1
  TOP w0.089: v2(176.4,62.44) CPU1.E8 ; 120.77,99.28 120.77,99.88 122.06,101.17 122.06,101.63 122.51,102.08 122.51,102.69 122.35,102.86 UH1.C27
  TOP w0.102: 120.77,99.28 120.77,98.97 119.96,98.15 119.96,92.82 v4(121.06,91.71) 121.47,91.3 v2(121.47,90.44)
  IN3 w0.089: v2(176.4,62.44) 176.4,62.5 176.54,62.65 176.76,62.65 177.08,62.97 177.08,63.96 176.66,64.38 172.97,64.38 172.52,63.94 167.43,63.94 167.41,63.96 167.4,63.96
  IN3 w0.127: v2(121.47,90.44) 121.47,90.37 121.91,89.93 127.11,89.93 129.14,87.9 133.93,87.9 138.91,82.93 138.91,72.45 147.4,63.96 167.4,63.96
DMI_CRX_PTX_N1: length 90.5
  TOP w0.089: UH1.B28 121.76,102.67 121.96,102.47 121.96,102.08 121.57,101.69 121.57,101.35 119.92,99.69 119.92,99.38 119.93,99.37 119.93,99.28 ; v2(175.61,61.79) CPU1.F6
  TOP w0.102: 119.93,99.28 119.93,99.2 119.88,99.15 119.88,99.15 119.3,98.56 119.3,92.16 v4(119.56,91.89) 120.27,91.19 v2(120.27,90.44)
  IN3 w0.089: 166.74,63.26 166.75,63.26 166.77,63.24 172.18,63.24 172.32,63.1 173.38,63.1 174.05,63.76 175.38,63.76 176.03,63.11 176.03,62.2 v2(175.61,61.79)
  IN3 w0.127: v2(120.27,90.44) 120.27,89.73 120.82,89.17 126.66,89.17 128.63,87.2 133.62,87.2 138.15,82.67 138.15,71.78 146.67,63.26 166.74,63.26
DMI_CRX_PTX_N2: length 90
  TOP w0.089: UH1.B29 121.08,102.74 120.91,102.74 120.84,102.67 120.84,102.57 120.97,102.45 121.06,102.45 121.12,102.39 121.12,102.19 120.88,101.96 120.88,101.56 118.62,99.29 118.61,99.29 118.6,99.28 ; v2(174.82,62.44) 174.5,62.11 CPU1.E5
  TOP w0.102: v2(118.48,90.44) 118.84,90.81 118.84,91.31 118.46,91.7 118.46,99.13 118.56,99.23 118.56,99.24 118.6,99.28
  IN3 w0.089: v2(174.82,62.44) 174.82,62.52 174.74,62.61 174.65,62.61 174.03,61.98 173.33,61.98 173.04,62.27 166.01,62.27 165.99,62.26 165.98,62.26
  IN3 w0.127: v2(118.48,90.44) 118.48,89.78 122.12,86.13 124.95,86.13 125.05,86.24 132.55,86.24 135.58,83.21 135.99,83.21 137.18,82.02 137.18,71.28 146.21,62.26 165.98,62.26
DMI_CRX_PTX_N3: length 93.9
  TOP w0.089: v2(177.26,60.46) 176.9,60.1 CPU1.J9 ; UH1.B30 120.77,102.36 120.77,102.09 120.69,102.02 120.69,101.62 119.67,100.59 119.37,100.59 v4(118.77,99.99) 118.06,99.28
  TOP w0.102: v2(117.85,90.44) 117.85,93.02 118.05,93.21 118.05,99.27 118.06,99.28
  IN3 w0.089: v2(177.26,60.46) 177.03,60.46 176.95,60.54 176.95,60.85 176.46,61.33 173.35,61.33 172.93,61.75 165.25,61.75 165.23,61.77 165.22,61.77
  IN3 w0.127: 165.22,61.77 145.65,61.77 136.75,70.67 136.75,81.81 135.81,82.76 135.36,82.76 132.32,85.8 125.23,85.8 124.92,85.49 121.84,85.49 117.7,89.62 117.7,90.29 v2(117.85,90.44)
DMI_CRX_PTX_P0: length 90.1
  TOP w0.089: v2(176.4,63.09) 176.33,63.09 CPU1.D8 ; 120.55,99.28 120.55,99.3 120.56,99.31 120.56,99.37 120.57,99.38 120.57,99.98 v4(120.81,100.22) 121.85,101.27 121.85,101.71 122.31,102.17 122.31,102.61 122.25,102.67 UH1.B27
  TOP w0.102: v2(120.89,90.44) 120.82,90.51 120.82,90.76 120.91,90.85 121.19,90.85 121.26,90.92 121.26,91.21 119.74,92.73 119.74,98.24 120.55,99.06 120.55,99.28
  IN3 w0.089: v2(176.4,63.09) 176.4,62.99 176.53,62.86 176.67,62.86 176.87,63.06 176.87,63.88 176.57,64.17 173.05,64.17 172.61,63.73 167.44,63.73 167.42,63.71 167.4,63.71
  IN3 w0.127: 167.4,63.71 147.3,63.71 138.66,72.35 138.66,82.82 133.83,87.66 129.03,87.66 127.01,89.68 121.81,89.68 121.56,89.94 121.31,89.94 120.89,90.36 v2(120.89,90.44)
DMI_CRX_PTX_P1: length 90.5
  TOP w0.089: UH1.A28 121.73,102.41 121.64,102.5 121.55,102.5 121.49,102.44 121.49,102.16 121.58,102.06 121.58,101.99 121.37,101.78 121.37,101.43 119.72,99.78 119.72,99.29 119.71,99.28 ; v2(175.61,62.44) 175.29,62.11 CPU1.E6
  TOP w0.102: 119.71,99.28 119.67,99.24 119.67,99.24 119.08,98.65 119.08,92.07 120.05,91.1 120.05,90.8 119.69,90.44 v2(119.68,90.44)
  IN3 w0.089: v2(175.61,62.44) 175.45,62.44 175.37,62.52 175.37,62.73 175.45,62.81 175.78,62.81 175.82,62.85 175.82,63.03 175.29,63.55 174.13,63.55 173.47,62.89 172.24,62.89 172.09,63.03 166.77,63.03 166.75,63.01 166.74,63.01
  IN3 w0.127: 166.74,63.01 146.57,63.01 137.9,71.68 137.9,82.57 133.52,86.95 128.53,86.95 126.56,88.93 120.72,88.93 120.02,89.62 120.02,90 119.87,90.15 119.87,90.26 v2(119.68,90.44)
DMI_CRX_PTX_P2: length 89.9
  TOP w0.089: v2(174.82,63.13) 174.45,62.76 CPU1.D5 ; UH1.C29 121.38,102.79 121.38,102.57 121.32,102.52 121.32,102.11 121.09,101.88 121.09,101.47 118.9,99.28
  TOP w0.102: 118.9,99.28 118.82,99.21 118.82,99.2 118.77,99.15 118.77,99.14 118.67,99.04 118.67,91.79 119.06,91.4 v2(119.06,90.44)
  IN3 w0.089: v2(174.82,63.13) 174.87,63.08 174.87,62.91 174.78,62.82 174.74,62.82 174.74,62.82 174.57,62.82 173.94,62.19 173.42,62.19 173.13,62.49 166.01,62.49 165.99,62.5 165.98,62.5
  IN3 w0.127: 165.98,62.5 146.32,62.5 137.43,71.39 137.43,82.12 136.09,83.46 135.68,83.46 132.65,86.48 124.95,86.48 124.85,86.38 122.23,86.38 118.73,89.88 118.73,90.03 119.06,90.36 v2(119.06,90.44)
DMI_CRX_PTX_P3: length 93.9
  TOP w0.089: CPU1.J8 176.23,60.32 v2(176.4,60.49) ; 117.83,99.28 117.83,99.3 117.84,99.31 117.84,99.37 117.96,99.49 117.97,99.49 119.28,100.79 119.58,100.79 120.49,101.7 120.49,101.92 120.44,101.98 120.36,101.98 120.31,102.03 120.31,102.23 120.37,102.29 UH1.A30
  TOP w0.102: v2(117.27,90.44) 117.27,90.74 117.33,90.8 117.56,90.8 117.64,90.88 v4(117.64,91.87) 117.64,93.1 117.83,93.3 117.83,99.28
  IN3 w0.089: v2(176.4,60.49) 176.65,60.49 176.74,60.57 176.74,60.76 176.38,61.12 173.27,61.12 172.84,61.54 165.26,61.54 165.24,61.52 165.22,61.52
  IN3 w0.127: v2(117.27,90.44) 117.45,90.26 117.45,89.52 121.73,85.24 125.02,85.24 125.34,85.55 132.21,85.55 135.26,82.51 135.7,82.51 136.5,81.71 136.5,70.57 145.55,61.52 165.22,61.52
DMI_CTX_PRX_N0: length 94.8
  TOP w0.089: CPU1.A8 175.9,64.61 175.9,64.41 175.96,64.35 176.18,64.35 176.31,64.48 176.31,65.18 175.92,65.56 175.92,67.55 175.51,67.97 174.96,67.97 174.3,68.62 174.3,68.75 174.17,68.89 173.89,68.89 173.77,68.77 v2(173.77,68.65) ; v2(121.77,106.8) 121.98,107.02 122.03,107.02 UH1.L27
  IN1 w0.089: v2(173.77,68.65) 173.56,68.85 173.52,68.85 173.27,69.11 173.27,69.49 174.03,70.25 174.33,70.25 174.83,70.76 174.83,70.88 174.82,70.89 174.82,70.91 ; 122.05,99.28 122.05,99.3 122.06,99.32 122.06,100.01 122.47,100.42 122.48,100.42 124.06,102 124.06,104.9 123.23,105.73 123.23,107.83 123.09,107.96 122.61,107.96 122.43,107.78 122.43,107.29 122.28,107.14 122.22,107.09 121.84,107.09 121.77,107.02 v2(121.77,106.8)
  IN1 w0.109: 122.05,99.28 122.05,97.42 122.51,96.96 124.69,96.96 125.14,96.51 125.14,95.1 125.38,94.86 135.84,94.86 138.36,92.35 138.36,90.06 140.56,87.86 148.51,87.86 149.73,86.63 153.32,86.63 155.99,83.97 168.41,83.97 173.08,79.29 173.08,77.38 174.77,75.69 174.77,72.24 174.82,72.19 174.82,70.91
DMI_CTX_PRX_N1: length 88.7
  TOP w0.089: v2(173.84,67.51) 174.22,67.89 174.41,67.89 174.91,67.39 v4(174.91,66.39) 174.91,65.96 175.52,65.34 175.52,63.83 175.38,63.69 175.19,63.69 175.11,63.77 175.11,63.96 CPU1.B6 ; v2(122.81,104.52) 122.98,104.52 UH1.E24
  IN1 w0.089: 173.63,70.91 173.63,70.48 172.76,69.61 172.76,68.33 173.4,67.68 173.67,67.68 v2(173.84,67.51)
  IN1 w0.109: 173.63,70.91 173.63,74.59 170.57,77.66 170.57,79.33 166.63,83.27 155.54,83.27 152.81,86 149.47,86 148.24,87.23 140.18,87.23 137.72,89.69 137.72,91.55 137.73,91.54 137.73,91.55 135.04,94.23 134.95,94.23 124.9,94.23 124.49,94.63 124.49,95.99 124.18,96.3 122.18,96.3 121.35,97.12 121.35,101.24 122.81,102.7 123.04,102.7 123.36,103.02 123.36,104.67 123.17,104.86 122.98,104.86 122.81,104.7 v2(122.81,104.52)
DMI_CTX_PRX_N2: length 88.6
  TOP w0.089: UH1.G27 122.12,104.92 v2(121.77,105.28) ; CPU1.A5 174.32,64.85 174.32,65.07 174.39,65.13 174.52,65.13 174.63,65.02 174.72,65.02 174.85,65.14 174.85,65.31 173.17,66.99 172.91,66.99 172.88,66.95 172.88,66.5 172.81,66.44 172.62,66.44 172.5,66.57 v2(172.5,66.62)
  IN1 w0.089: v2(121.77,105.28) 121.95,105.09 122.12,105.09 122.42,104.79 122.42,104.34 122.16,104.08 122.16,102.78 122.03,102.65 ; 173.21,70.91 173.21,70.89 173.2,70.88 173.2,70.6 172.44,69.85 172.44,68.28 173.27,67.46 173.27,66.82 173.07,66.62 v2(172.5,66.62)
  IN1 w0.109: 122.03,102.65 120.71,101.33 120.71,97.18 120.32,96.79 120.32,94.37 120.92,93.77 134.13,93.77 136.34,91.56 136.34,90.36 139.88,86.81 148.07,86.81 149.38,85.51 151.91,85.51 154.72,82.7 163.67,82.7 168.24,78.13 169.45,78.13 173.21,74.37 173.21,70.91
DMI_CTX_PRX_N3: length 92
  TOP w0.089: v2(120.58,107.51) 120.88,107.21 UH1.L29 ; CPU1.B4 173.52,63.74 173.38,63.88 173.38,64.16 173.46,64.23 173.61,64.23 173.66,64.18 173.66,64.12 173.71,64.07 173.84,64.07 173.93,64.15 173.93,64.54 173.97,64.58 173.97,64.85 173.95,64.87 173.95,65.45 173.35,66.05 172.16,66.05 171.97,66.24 171.79,66.24 171.69,66.14 171.69,65.92 171.63,65.86 v2(171.41,65.86)
  IN1 w0.089: 172.57,70.91 172.57,70.89 172.56,70.88 172.56,70.79 172.01,70.24 172.01,66.52 172.11,66.42 172.11,66.11 171.95,65.95 171.5,65.95 v2(171.41,65.86) ; 121.24,102.88 121.24,107.02 120.92,107.34 120.75,107.34 v2(120.58,107.51)
  IN1 w0.109: 172.57,70.91 172.57,74.09 169.21,77.45 167.01,77.45 162.5,81.96 154.46,81.96 151.54,84.88 149.11,84.88 147.81,86.18 139.56,86.18 134.6,91.14 134.6,92.15 133.63,93.11 120.63,93.11 119.32,94.42 119.32,100.76 121.24,102.67 121.24,102.88
DMI_CTX_PRX_P0: length 94.8
  TOP w0.089: v2(173.87,69.25) 174.03,69.09 174.25,69.09 174.51,68.83 174.51,68.71 175.04,68.17 175.59,68.17 176.13,67.63 v4(176.13,66.92) 176.13,65.65 176.51,65.26 176.51,64.39 176.26,64.14 176.08,64.14 CPU1.B8
  TOP w0.101: UH1.N27 v2(121.77,107.57)
  IN1 w0.089: 122.27,99.28 122.27,99.3 122.26,99.32 122.26,99.93 122.41,100.09 122.42,100.09 124.25,101.92 124.25,104.98 123.42,105.81 123.42,107.91 123.17,108.16 122.53,108.16 122.23,107.86 122.23,107.37 122.14,107.28 122.05,107.28 v2(121.77,107.57) ; 175.04,70.91 175.04,70.69 174.41,70.06 174.11,70.06 173.47,69.41 173.47,69.19 173.61,69.05 173.78,69.05 173.87,69.14 v2(173.87,69.25)
  IN1 w0.109: 175.04,70.91 175.04,72.28 174.98,72.33 174.98,75.78 173.3,77.46 173.3,79.38 168.5,84.18 156.08,84.18 153.41,86.84 149.82,86.84 148.6,88.07 140.65,88.07 138.57,90.15 138.57,92.44 135.93,95.08 125.47,95.08 125.35,95.19 125.35,96.6 124.78,97.18 122.6,97.18 122.27,97.51 122.27,99.28
DMI_CTX_PRX_P1: length 88.7
  TOP w0.089: v2(173.84,68.09) 174.49,68.09 v4(174.88,67.7) 175.11,67.47 175.11,66.04 175.73,65.43 175.73,63.75 175.47,63.49 175.29,63.49 CPU1.C6
  TOP w0.101: UH1.G24 v2(122.81,105.28)
  IN1 w0.089: 173.84,70.91 173.84,70.89 173.83,70.88 173.83,70.82 173.82,70.81 173.82,70.4 172.95,69.53 172.95,68.41 173.48,67.88 173.77,67.88 173.84,67.95 v2(173.84,68.09)
  IN1 w0.109: 173.84,70.91 173.84,74.68 170.78,77.74 170.78,79.42 166.72,83.48 155.63,83.48 152.9,86.21 149.56,86.21 148.33,87.44 140.27,87.44 137.93,89.78 137.93,90.83 137.94,90.82 137.94,91.64 135.13,94.44 134.86,94.44 124.99,94.44 124.71,94.72 124.71,96.08 124.27,96.51 122.27,96.51 121.57,97.21 121.57,101.15 122.9,102.48 123.13,102.48 123.58,102.93 123.58,104.76 123.26,105.08 123.01,105.08 v2(122.81,105.28)
DMI_CTX_PRX_P2: length 88.5
  TOP w0.089: v2(172.5,67.19) 173.25,67.19 175.05,65.4 175.05,65.06 174.79,64.8 174.79,64.58 174.43,64.21 CPU1.B5
  TOP w0.101: UH1.E26 v2(121.77,104.52)
  IN1 w0.089: 172.99,70.91 172.99,70.89 173,70.88 173,70.68 172.25,69.93 172.25,68.2 173.07,67.38 173.07,66.9 172.99,66.81 172.87,66.81 v2(172.5,67.19) ; v2(121.77,104.52) 121.62,104.66 121.62,104.82 121.7,104.9 122.04,104.9 122.23,104.71 122.23,104.42 121.96,104.16 121.96,102.89 121.81,102.74
  IN1 w0.109: 172.99,70.91 172.99,74.28 169.36,77.91 168.15,77.91 163.58,82.48 154.63,82.48 151.82,85.3 149.29,85.3 147.98,86.6 139.79,86.6 136.12,90.27 136.12,91.47 134.04,93.56 120.83,93.56 120.11,94.28 120.11,96.88 120.49,97.26 120.49,101.42 121.81,102.74
DMI_CTX_PRX_P3: length 92
  TOP w0.089: v2(171.41,66.44) 172.05,66.44 172.24,66.25 173.43,66.25 174.15,65.53 174.15,64.47 174.13,64.45 174.13,63.61 CPU1.D4
  TOP w0.101: UH1.K29 120.88,106.45 v2(120.58,106.75)
  IN1 w0.089: 121.02,102.88 121.03,102.89 121.03,102.96 121.04,102.97 121.04,106.94 120.84,107.14 120.53,107.14 120.41,107.03 120.41,106.86 120.53,106.75 v2(120.58,106.75) ; 172.36,70.91 172.36,70.86 171.81,70.32 171.81,66.44 171.92,66.33 171.92,66.19 171.87,66.14 171.63,66.14 171.41,66.37 v2(171.41,66.44)
  IN1 w0.109: 121.02,102.88 121.02,102.76 119.1,100.85 119.1,94.33 120.54,92.9 133.54,92.9 134.38,92.06 134.38,91.05 139.47,85.97 147.72,85.97 149.02,84.67 151.45,84.67 154.37,81.74 162.41,81.74 166.92,77.24 169.12,77.24 172.36,74 172.36,70.91
DMIC0: length 320.2
  TOP w0.102: JIO1.49 317.38,36.3 v2(317.8,35.88) ; v2(122.98,145.69) 122.98,145.5 121.61,144.13 121.61,143.4 JEDP1.13 ; v2(252.52,85.97) 252.65,85.85 R362.1
  IN1 w0.109: v2(317.8,35.88) 317.8,35.69 316.74,34.63 310.24,34.63 309,35.87 305.67,35.87 301.45,40.09 297.52,40.09 296.4,41.21 289.46,41.21 287.71,42.97 283.13,42.97 280.81,45.29 275.65,45.29 266.77,54.17 265.27,54.17 257.25,62.19 257.25,65.13 251.52,70.86 251.52,73.38 248.5,76.39 248.5,78.77 245.45,81.82 245.45,85.37 243.8,87.02 v2(243.8,87.02) 243.8,87.02 242.06,88.76 242.06,97.79 242.74,98.47 242.74,98.53 v2(242.75,98.53)
  IN3 w0.127: v2(243.8,87.02) 243.8,87.02 244.9,87.02 244.96,87.08 250.3,87.08 251.49,85.88 252.43,85.88 v2(252.52,85.97)
  IN4 w0.109: v2(114.89,144.83) 115.74,143.97 117.64,143.97 118.22,144.55 118.22,145.88 118.6,146.26 122.41,146.26 v2(122.98,145.69) 122.98,145.44 123.36,145.05 123.87,145.05 124.31,144.61 124.31,143.4 125.55,142.16 127.09,142.16 127.6,141.65 129.75,141.65 130.26,142.16 134.2,142.16 137.15,143.46 138.89,143.46 139.46,144.02 142.44,144.02 142.99,144.56 147.52,144.56 150.09,147.14 150.09,156.15 150.93,156.98 153.28,156.98 155.05,155.21 168.7,155.21 169.26,154.65 172.32,154.65 172.99,153.98 174.08,152.89 183.15,152.89 184.76,151.28 186.33,151.28 190.27,147.34 191.3,147.34 193.4,145.24 212.83,145.24 219.18,138.89 226.64,138.89 240.62,124.92 240.62,123.98 241.06,123.54 241.06,109.98 242.38,108.67 242.38,106.32 242.9,105.79 242.9,102.33 243.25,101.98 243.25,99.04 v2(242.75,98.53)
  BOTTOM w0.102: C1468.1 112.5,141.55 114.24,143.29 114.7,143.29 D22.3 114.7,144.63 v2(114.89,144.83)
DMIC0_R: length 2.8
  TOP w0.102: v1(253.36,83.14) 252.89,83.62 252.89,84.16 R362.2 252.39,84.4 C365.2
DMIC_CLK: length 315
  TOP w0.089: v2(316.72,36.72) 316.64,36.8 JIO1.47
  TOP w0.102: R361.1 239.65,90.69 v2(239.06,91.28) ; v2(123.79,145.7) 123.79,145.1 122.6,143.91 122.6,143.13 JEDP1.11
  IN1 w0.109: v2(243.95,96.34) 243.94,96.34 243.71,96.1 243.71,89.81 247.09,86.42 247.09,84.2 248.04,83.26 248.04,81.47 250.08,79.43 250.08,77.05 253.1,74.03 253.1,71.51 258.83,65.79 258.83,62.85 265.63,56.04 267.14,56.04 276.31,46.87 281.59,46.87 282.83,45.63 284.1,45.63 285.04,44.69 288.29,44.69 290.18,42.79 301.61,42.79 306.33,38.07 308.71,38.07 309.05,37.73 311.73,37.73 313.51,35.95 314.02,35.95 315.94,35.95 v2(316.72,36.72)
  IN4 w0.109: v2(116.88,144.61) 117.33,144.61 117.58,144.86 117.58,146.13 118.34,146.9 122.98,146.9 123.79,146.09 v2(123.79,145.7) 123.8,145.69 124.44,145.69 124.99,145.14 124.99,143.59 125.81,142.77 127.35,142.77 127.85,142.27 129.5,142.27 130,142.77 134.07,142.77 137.02,144.07 138.64,144.07 139.2,144.64 142.19,144.64 142.73,145.18 147.26,145.18 149.48,147.39 149.48,156.4 150.31,157.24 150.67,157.6 153.53,157.6 155.16,155.98 169.41,155.98 170.11,156.68 171.17,156.68 172.58,155.27 172.76,155.09 173.27,154.57 174.34,153.51 183.4,153.51 185.02,151.89 186.59,151.89 187.92,150.56 188.59,149.89 190.32,149.89 191.49,148.72 191.49,148.02 193.65,145.87 213.09,145.87 219.44,139.52 226.89,139.52 241.23,125.18 241.23,124.28 241.68,123.83 241.68,110.24 242.99,108.92 242.99,106.57 243.52,106.05 243.52,102.58 243.86,102.24 243.86,98.78 243.5,98.41 243.5,97.08 243.95,96.62 v2(243.95,96.34)
  BOTTOM w0.102: v2(116.88,144.61) 116.63,144.35 D22.2 116.63,143.29 116.07,143.29 114.95,142.17 114.05,142.17 113.45,141.57 C1467.1 ; v2(243.95,96.34) 243.62,96.34 v1(242.41,95.12) 242.08,94.8 242.08,92.64 240.72,91.28 v2(239.06,91.28)
DMIC_CLK_R: length 3.1
  TOP w0.102: R361.2 241.24,90.67 v2(241.26,90.69) 241.47,90.91 241.47,91.55 241.74,91.81 U8.30
DOCK_5V_IS: length 216.1
  TOP w0.102: v2(174.48,118.26) 174.07,118.66 172.99,118.66 172.37,118.04 172.37,115.09 172.9,114.56 172.9,112.35 172.36,111.82 172.08,111.82 171.3,111.04 171.3,110.27 171.06,110.03 171.06,109.59 171.4,109.25 171.4,108.08 170.9,107.57 170.9,106.73 170.53,106.37 170.53,105.1 171.43,104.21 172.47,104.21 172.99,103.69 172.99,102.66 173.4,102.26 v1(174.32,102.26) 174.99,102.26 175.58,101.67 175.58,100.64 177.83,98.38 177.83,95.47 178.31,94.99 v2(178.31,94.52) ; JIO2.65 56.64,38.35 56.78,38.21 57.08,38.21 v2(57.32,38.46)
  IN2 w0.127: v2(57.32,38.46) 57.32,38.29 58.16,37.45 59.46,37.45 60.02,38 61.28,38 61.39,37.89 67.17,37.89 68.75,39.48 68.75,40.22 74.78,46.25 74.78,46.48 75.41,47.11 78.47,47.11 94.04,62.68 94.04,72.45 95.14,73.56 95.14,75.19 99.62,79.67 100.13,79.67 103.24,82.79 105.6,82.79 106.26,83.45 107.06,83.45 108.44,84.83 111.65,84.83 112.4,85.58 116.42,85.58 117.59,84.41 125.68,84.41 126.73,85.46 130.99,85.46 131.76,84.7 135.88,84.7 136.81,83.76 137.82,83.76 139.95,81.63 143.65,81.63 144.88,82.87 152.32,82.87 156.57,87.12 157.42,87.12 158.41,86.13 159.78,86.13 161.43,84.48 166.56,84.48 167.23,83.8 168.1,83.8 169.26,84.96 174.43,84.96 174.87,84.53 177.92,84.53 178.22,84.22 180.06,84.22 180.7,84.86 180.7,86.15 179.94,86.91 179.94,88.64 181.26,89.96 181.62,89.96 184.54,92.88 184.54,94.41 v2(184.89,94.76)
  IN4 w0.109: v2(184.89,94.76) 184.89,94.18 184.24,93.53 183.4,93.53 183.18,93.74 179.03,93.74 178.31,94.46 v2(178.31,94.52)
  BOTTOM w0.102: U46.A3 176.55,116.91 175.87,117.59 175.15,117.59 174.74,118 174.73,118 v2(174.48,118.26)
DOCK_AC_OFF: length 285.3
  TOP w0.102: PD1010.1 340.43,55.8 v1(340.43,55.96) ; v2(246.89,90.44) 248.17,91.72 249.4,91.72 249.65,91.46 251.99,91.46 252.99,92.47 v2(252.99,93.11)
  TOP w0.254: PR1031.2 341.15,53.26 v2(341.15,54.25) 341.26,54.36 PD1010.1
  IN2 w0.127: v2(241.85,124.73) 241.47,124.35 241.47,110.62 244.23,107.86 249.33,107.86 252.9,104.29 252.9,100.1 253.53,99.46 253.53,96.12 252.55,95.14 252.55,93.55 v2(252.99,93.11) ; v2(341.15,54.25) 341.15,52.98 340.05,51.88 337.06,51.88 336.31,51.13 336.31,49.03 336.06,48.79 334.98,48.79 334.13,47.94 334.13,46.73 333.77,46.37 332.3,46.37 330.39,44.46 329.41,44.46 328.85,43.91 326.66,43.91 324.11,41.36 322.77,41.36 322.3,41.83 321.31,41.83 320.92,41.43 315.74,41.43 315.18,40.88 309.62,40.88 308.12,39.38 300.74,39.38 299.56,38.2 297.9,38.2 295.32,40.77 295.32,41.52 290.78,46.06 286.19,46.06 283.14,49.11 278.19,49.11 261.49,65.81 261.49,66.73 259.5,68.72 259.5,71.03 253.71,76.83 253.71,78.04 248.2,83.55 248.2,89.13 v2(246.89,90.44)
  IN4 w0.109: v2(157.75,157.69) 158.59,156.85 168.62,156.85 169.44,157.67 169.92,157.67 170.28,157.31 171.41,157.31 171.6,157.13 174.59,154.13 183.66,154.13 185.28,152.51 186.84,152.51 187.15,152.2 188.84,150.51 190.58,150.51 190.76,150.33 191.12,149.97 192.43,149.97 193.15,149.25 193.15,148.67 193.91,147.91 195.32,147.91 196.51,146.72 203.38,146.72 204.83,148.17 211.83,148.17 218.3,141.69 225.59,141.69 241.85,125.43 v2(241.85,124.73)
  BOTTOM w0.102: v2(157.75,157.69) JDOCK1.2
DOCK_AC_OFF_EC: length 234.1
  TOP w0.254: v2(333.53,60.03) 333.72,60.22 PR1018.1 334.21,59.35 PR1020.2
  IN2 w0.127: v2(333.53,60.03) 330.03,56.54 330.03,51.31 327.97,49.25 325.65,49.25 323.42,47.01 321.38,47.01 320.76,46.39 319.58,46.39 318.96,47.01 318.61,47.01 315.92,49.7 312.66,49.7 310.38,47.43 296.07,47.43 294.78,48.72 285.88,48.72 283.85,50.76 278.88,50.76 263.14,66.5 263.14,67.41 261.15,69.4 261.15,71.74 258,74.89 258,77.35 254.84,80.51 254.84,85.12 253.7,86.27 253.7,89.05 250.99,91.76 250.99,91.99 250.24,92.74 250.09,92.74 249.53,93.29 249.53,96.05 248.33,97.26 248.33,101.3 v2(247.5,102.13) ; v2(171.25,116.16) 171.68,116.59 171.68,117.33 173.62,119.26 179.03,119.26 179.18,119.42 180.02,119.42 180.7,120.09 180.7,120.46 181.03,120.79 184.29,120.79 184.77,121.27 187.71,121.27 188.59,122.14 191.17,122.14 192.65,123.63 193.83,123.63 194.58,124.38 196.39,124.38 196.59,124.58 200.66,124.58 201.73,125.65 205.54,125.65 206.19,125 215.2,125 216.34,126.14 220,126.14 220.92,125.22 222.7,125.22 225.94,121.98 225.94,117.92 228.87,114.99 229.37,114.99 231.25,113.11 231.25,110.21 232.78,108.67 v2(232.78,108.34)
  BOTTOM w0.102: v2(247.5,102.13) 247.33,102.13 246.08,103.37 245.51,103.37 244.53,104.35 244.53,105.76 241.53,108.76 233.2,108.76 v2(232.78,108.34) ; v2(171.25,116.16) 172.26,116.16 v1(172.51,115.91) 172.51,115.01 173.5,114.01 U46.A63
DOCK_DCIN_IS+: length 300.1
  TOP w0.102: v2(55.83,66.02) 55.83,63.74 56.41,63.16 62.46,63.16 89.3,90 89.3,101.02 90.78,102.51 90.78,103.33 90.53,103.59 89.97,103.59 v2(89.8,103.77)
  IN3 w0.127: v2(35.16,32.79) 35.09,32.85 34.18,32.85 31.37,35.66 27.21,35.66 24.38,38.49 24.38,44.97 23.13,46.22 23.13,52 25.58,54.45 25.58,61.49 29.91,65.82 55.63,65.82 v2(55.83,66.02)
  IN4 w0.109: v2(89.8,103.77) 89.97,103.59 92.56,103.59 94.02,105.05 94.02,106.48 93.15,107.36 91.04,107.36 89.47,108.93 89.47,123.98 97.35,131.87 97.35,136.56 99.65,138.86 99.65,140.94 100.49,141.79 106.1,141.79 107.97,143.65 107.97,146.07 111.25,149.34 119.96,149.34 121.14,148.16 124.19,148.16 125.84,146.51 125.84,144.13 126.35,143.63 133.89,143.63 136.85,144.93 138.28,144.93 140.63,147.28 140.63,149.31 149.78,158.45 160.77,158.45 160.83,158.39 174.35,158.39 174.98,157.75 174.98,156.61 175.87,155.72 180.26,155.72 180.92,155.06 183.5,155.06 184.79,156.36 192.43,156.36 192.88,156.81 192.88,157.47 v2(192.71,157.64)
  BOTTOM w0.102: JDOCK1.134 192.75,157.02 192.86,157.13 192.86,157.49 v2(192.71,157.64)
  BOTTOM w0.254: PQ703.1 35.98,31.58 35.35,32.21 34.71,32.21 34.47,32.46 PR715.1 35.04,32.91 v2(35.16,32.79)
DOCK_DCIN_IS-: length 293.7
  TOP w0.102: v2(89.8,103.18) 89.97,103.36 90.44,103.36 90.56,103.24 90.56,102.6 89.07,101.12 89.07,90.09 62.37,63.39 56.5,63.39 56.06,63.83 56.06,65.37 v2(56.25,65.56)
  IN3 w0.127: v2(56.25,65.56) 30.02,65.56 25.84,61.38 25.84,54.35 23.39,51.9 23.39,46.32 24.63,45.08 24.63,38.59 27.31,35.91 31.47,35.91 34.28,33.1 34.71,33.1 v2(35.03,33.42)
  IN4 w0.109: v2(193.29,157.64) 193.12,157.47 193.12,156.71 192.53,156.12 184.89,156.12 183.6,154.83 180.82,154.83 180.16,155.49 175.78,155.49 174.75,156.51 174.75,157.66 174.25,158.15 160.74,158.15 160.67,158.22 149.87,158.22 140.87,149.21 140.87,147.18 138.38,144.69 136.9,144.69 133.94,143.39 126.25,143.39 125.61,144.03 125.61,146.41 124.09,147.92 121.04,147.92 119.86,149.11 111.35,149.11 108.21,145.97 108.21,143.56 106.2,141.55 100.59,141.55 99.88,140.85 99.88,138.76 97.59,136.46 97.59,131.77 89.7,123.88 89.7,109.03 91.14,107.6 93.24,107.6 94.26,106.58 94.26,104.95 92.66,103.35 89.97,103.35 v2(89.8,103.18)
  BOTTOM w0.102: v2(193.29,157.64) 193.11,157.46 193.11,157.19 193.25,157.05 JDOCK1.136
  BOTTOM w0.254: v2(35.03,33.42) 34.52,33.93 PR713.2
DOCK_DET#: length 47.4
  TOP w0.102: v2(182.05,123.62) 182.05,123.63 182.05,126.91 183.11,127.97 183.11,129.24 184.22,130.35 184.22,132.44 185.13,133.36 185.83,133.36 187.52,135.05 187.52,137.12 v1(188.77,138.37) 189.09,138.69 v2(190.02,138.69)
  IN1 w0.109: v2(180.75,106.85) 181.19,107.29 181.19,108.27 180.92,108.53 180.92,113.15 181.18,113.41 181.18,115.49 182.46,116.77 182.46,118.07 183.02,118.62 183.02,122.33 182.05,123.3 v2(182.05,123.62)
  BOTTOM w0.102: v2(180.75,106.85) 180.55,106.85 180.3,106.6 U46.B41 ; R755.2 D32.2 192.76,139.58 191.32,138.13 191.04,138.13 190.48,138.69 v2(190.02,138.69)
DOCK_DET_R#: length 18
  TOP w0.102: v2(194.97,154.77) 194.39,155.35 v1(193.9,155.35) 193.45,155.35 v2(192.81,154.71)
  BOTTOM w0.102: JDOCK1.142 194.75,154.99 v2(194.97,154.77) 195.25,155.05 JDOCK1.144 ; v2(192.81,154.71) 192.81,151.85 195.77,148.89 195.77,146.16 194.16,144.55 D32.1
DOCK_HP_DET: length 211.7
  TOP w0.102: JIO1.85 316.93,27.3 v2(317.35,26.88)
  IN1 w0.109: v2(317.35,26.88) 317.16,27.07 316.53,27.07 316.15,26.69 312.61,26.69 312.4,26.48 303.54,26.48 300.15,29.87 299.52,29.87 298.72,30.67 298.72,31.6 294.52,35.79 288.19,35.79 285.16,38.83 281.42,38.83 279.1,41.15 273.94,41.15 265.88,49.2 264.38,49.2 262.25,51.33 261.66,51.33 258.8,54.19 257.23,54.19 254.44,56.98 254.44,56.98 254.29,57.12 251.82,57.12 246.74,62.21 246.74,71.86 242.87,75.73 242.87,77.6 242.04,78.42 242.04,79.2 241.53,79.71 240.55,79.71 235.15,85.12 235.15,88.15 234.26,89.03 232.22,89.03 227.29,93.97 227.29,99 226.13,100.16 224.13,100.16 223.66,100.63 223.66,100.64 v2(223.37,100.93)
  IN2 w0.127: v2(221.72,120.35) 221.28,120.35 219.21,122.42 218.86,122.42 218.71,122.28 212.98,122.28 211.95,121.24 209.82,121.24 208.88,120.3 205.93,120.3 205.36,119.73 201.07,119.73 200.91,119.58 196.33,119.58 195.86,120.04 195.86,120.47 195.58,120.75 193.26,120.75 192.34,119.83 192.34,119.56 190.96,118.18 186.43,118.18 185.97,118.64 183.67,118.64 182.85,117.83 182.85,116.78 182.33,116.26 179.35,116.26 179.05,116.57 179.05,117.08 v2(178.58,117.54)
  IN3 w0.127: v2(223.37,100.93) 223.56,101.12 223.56,106.49 222.88,107.17 222.88,108.43 223.18,108.73 223.18,114.89 222.72,115.35 222.72,119.35 v2(221.72,120.35)
  BOTTOM w0.102: v2(178.58,117.54) 178.87,117.26 178.87,116.8 178.55,116.49 U46.A7
DOCK_LOM_ACTLED_YEL#: length 79.4
  TOP w0.102: v2(239.18,118.79) U32.19
  IN2 w0.127: v2(239.18,118.79) 240.47,120.07 240.47,128.69 226.37,142.79 213.74,142.79 210.61,145.92 203.46,145.92 203.06,146.31 198.66,146.31 194.88,150.09 192.03,150.09 191.51,150.62 189.13,150.62 v2(185.05,154.69)
  BOTTOM w0.102: v2(185.05,154.69) 184.53,154.69 184.25,154.97 JDOCK1.100
DOCK_LOM_SPD10LED_GRN#: length 100.8
  TOP w0.102: v2(228.39,119.59) 228.69,119.29 U32.40
  IN1 w0.109: v2(228.39,119.59) 229.02,120.23 229.02,122.06 229.05,122.09 229.05,122.35 230.23,123.53 231.74,123.53 231.96,123.31 v2(233.91,123.31)
  IN2 w0.127: v2(158.61,146.03) 159.58,146.03 159.83,146.28 165.25,146.28 166.22,145.31 168.42,145.31 169.5,144.23 176.25,144.23 177.11,143.37 177.11,143.35 177.3,143.15 181.56,143.15 181.86,142.84 190.02,142.84 192.16,140.71 199.68,140.71 200.51,139.89 206.82,139.89 207.75,138.96 225.44,138.96 233.84,130.56 233.84,123.37 v2(233.91,123.31)
  BOTTOM w0.102: v2(158.61,146.03) 158.25,146.39 JDOCK1.3
DOCK_LOM_SPD100LED_ORG#: length 110.3
  TOP w0.102: v2(239.76,118.7) 239.76,118.89 239.36,119.29 U32.20
  IN2 w0.127: v2(158.3,154.33) 159.12,155.15 168.7,155.15 170.16,153.69 185.34,153.69 188.92,150.11 190.55,150.11 191.97,148.69 195.57,148.69 198.45,145.8 202.8,145.8 204.04,144.56 204.04,143.65 204.29,143.4 204.84,143.4 206.5,145.07 211.11,145.07 213.63,142.54 225.97,142.54 240.21,128.3 240.21,121.38 238.76,119.93 238.76,118.62 239.01,118.37 239.43,118.37 v2(239.76,118.7)
  BOTTOM w0.102: v2(158.3,154.33) 158.25,154.37 JDOCK1.4
DOCK_MIC_DET: length 210.8
  TOP w0.102: JIO1.87 316.61,26.8 v2(316.78,26.63)
  IN1 w0.109: v2(316.78,26.63) 316.61,26.45 312.71,26.45 312.5,26.25 303.44,26.25 300.14,29.55 299.33,29.55 298.29,30.59 298.29,31.45 294.8,34.94 288.71,34.94 285.06,38.59 281.32,38.59 279,40.91 272.08,40.91 269.35,43.64 269.35,45.4 265.78,48.97 263.69,48.97 258.71,53.95 257.13,53.95 254.2,56.89 251.73,56.89 246.5,62.11 246.5,71.76 242.63,75.63 242.63,77.3 234.91,85.02 234.91,88.05 234.17,88.79 232.13,88.79 226.87,94.05 v2(226.87,94.13)
  IN2 w0.127: v2(179.04,114.62) 179.04,115.12 179.67,115.76 183.43,115.76 183.59,115.76 184.45,116.61 184.45,116.78 184.84,117.17 185.64,117.17 185.86,116.95 188.41,116.95 189.06,117.6 191.1,117.6 192.91,119.4 192.91,119.67 193.22,119.98 193.98,119.98 194.39,119.57 195.62,119.57 196.12,119.07 201.12,119.07 201.28,119.23 205.57,119.23 205.99,119.64 209.92,119.64 210,119.73 211.2,119.73 211.56,119.37 211.75,119.37 212.39,120.01 212.39,120.65 213.26,121.51 215.62,121.51 216.98,120.15 216.98,118.3 217.3,117.98 221.96,117.98 224.57,115.37 224.57,114.02 225.82,112.78 226.47,112.78 230.99,108.26 230.99,103.05 228.1,100.16 228.1,97.95 226.98,96.83 226.98,94.23 v2(226.87,94.13)
  BOTTOM w0.102: v2(179.04,114.62) 178.8,114.86 U46.B8
DOCK_POR_RST#: length 91.6
  IN3 w0.127: v2(193.52,154.71) 195.72,156.9 202.61,156.9 207.54,151.98 208.32,151.98 209.4,150.89 209.4,146.39 212.13,143.66 212.13,142.51 211.92,142.3 211.92,132.38 211.32,131.78 210.9,131.78 210.57,131.45 210.57,130.68 213,128.25 213,125.04 212.52,124.57 212.52,112.39 211.33,111.2 209.33,111.2 209.33,111.2 208.71,111.2 208.48,110.97 208.48,110.32 207.91,109.75 204.09,109.75 203.6,109.26 203.6,108.78 203.8,108.58 203.8,108.07 203.84,108.03 203.84,106.88 204.19,106.53 204.19,104.41 205.4,103.21 205.4,102.21 205.39,102.21 v2(205.39,102.19)
  BOTTOM w0.102: RP7.8 205.89,100.11 204.98,101.02 204.73,101.02 204.49,101.25 v1(204.49,101.42) 204.49,101.6 204.58,101.68 204.88,101.68 v2(205.39,102.19) 205.46,102.27 205.46,103.43 205.23,103.67 204.58,103.67 C737.1 204.06,103.59 203.66,103.98 202.76,103.98 202.25,104.49 U51.A21 ; v2(193.52,154.71) 193.89,154.71 194.25,155.07 JDOCK1.140
DOCK_PSID: length 303.8
  TOP w0.102: PD6.2 13.43,16.91 15.03,16.91 17.9,19.78 v1(19.46,19.78) 20.48,19.78 v2(21.95,21.25)
  TOP w0.254: PD6.2 PD6.3 10,16.14 10.77,16.91 10.77,18.24 10.39,18.63 PU1.1
  IN2 w0.127: v2(21.95,21.25) 22.81,22.12 22.81,28.42 23.88,29.48 23.88,33.55 23.25,34.19 23.25,35.75 23.88,36.39 23.88,45.9 22.65,47.13 22.65,51.7 25.46,54.51 25.46,62.1 28.36,65.01 54.99,65.01 56.96,63.03 75.11,63.03 83.51,71.43 83.51,79.21 90.95,86.65 90.95,97.6 97.15,103.8 97.15,109.51 97.64,110 97.64,112.27 101.67,116.3 103.84,116.3 104.45,116.91 104.45,121.16 104.2,121.41 104.2,127.09 107.83,130.71 107.83,132.97 110.45,135.59 117.35,135.59 118.96,137.21 125.26,137.21 129.55,141.5 134.74,141.5 136.52,143.28 142.81,143.28 143.37,143.84 149.25,143.84 149.5,143.59 153.46,143.59 153.71,143.34 156.78,143.34 158.37,141.75 163.16,141.75 165.05,139.86 165.97,139.86 166.02,139.91 171.18,139.91 171.66,139.43 174.44,139.43 174.64,139.23 178.42,139.23 181.08,139.23 182.62,140.77 186.72,140.77 188.28,139.21 190.67,139.21 v2(191.24,138.64)
  BOTTOM w0.102: JDOCK1.135 193.25,146.08 192.25,145.08 190.19,145.08 189.69,144.58 189.69,143.37 192.16,140.9 192.16,139.56 v2(191.24,138.64)
DOCK_PWR_BTN#: length 44.3
  IN4 w0.109: v2(193.78,146.59) 194.34,147.15 195.75,147.15 196.41,146.48 203.69,146.48 204.61,147.4 v2(204.77,147.4)
  BOTTOM w0.102: R825.2 209.2,121.27 209.21,121.26 C733.1 210.23,121.26 210.7,121.73 210.7,121.84 210.93,122.07 210.93,122.58 210.7,122.8 210.7,124.23 v1(210.19,124.73) 209.87,125.05 209.87,133.47 208,135.34 207.19,135.34 206.48,136.05 206.48,140.74 205.37,141.85 205.37,143.93 204.83,144.47 204.83,147.34 v2(204.77,147.4) ; v2(193.78,146.59) 194.25,147.06 JDOCK1.139
DOCK_PWR_SW#: length 11.6
  BOTTOM w0.102: U51.A63 203.75,117.21 203.82,117.28 203.82,117.77 204.21,118.16 204.76,118.16 204.86,118.07 205.4,118.07 205.57,118.23 205.57,118.37 205.57,118.37 205.57,118.77 205.4,118.94 205.4,121.24 205.9,121.74 206.92,121.74 v1(207.06,121.61) 207.48,121.18 207.48,120.88 R819.2 R825.1 C734.1
DOCK_TNY_SMB_CLK: length 281.9
  TOP w0.102: JIO2.73 56.7,40.35 56.85,40.5 57.98,40.5 59.99,42.51 59.99,43.71 59.52,44.18 59.52,46.27 59.1,46.69 59.1,47.2 66.88,54.98 66.88,66.35 66.95,66.41 66.95,66.45 89.87,89.37 89.87,100.75 91.8,102.68 91.8,104.07 v2(91.98,104.25)
  IN2 w0.127: v2(100.75,140.7) 100.59,140.53 99.7,140.53 99.01,139.85 99.01,137.46 97.69,136.14 97.69,131.85 90.63,124.79 90.63,116.31 89.39,115.06 89.39,104.56 89.69,104.26 90.05,104.26 90.89,103.42 91.47,103.42 91.85,103.8 91.85,104.13 v2(91.98,104.25)
  IN3 w0.127: v2(191.1,145.79) 191.24,145.64 191.24,144.82 195.07,140.99 198.44,140.99 200.13,139.3 200.13,132.5 205.78,126.85 206.04,126.85 207.77,125.12 207.77,114.57 207.59,114.39 v2(207.33,114.39) 207.33,114.74 206.98,115.09 206.57,115.09 205,113.52 204.44,113.52 204.38,113.58 v2(204.37,113.58)
  IN4 w0.109: v2(191.1,145.79) 191.3,145.59 191.3,145.46 191.17,145.33 190.48,145.33 190.2,145.61 190.2,146.04 189.17,147.07 188.61,147.07 187.29,148.39 187.29,149.52 186.05,150.77 179.32,150.77 178.07,152.02 174.26,152.02 172.12,154.16 164.66,154.16 164.51,154.01 161.69,154.01 158.81,151.13 158.81,149.59 156.68,147.46 153.78,147.46 152.53,146.2 152.47,146.14 152.47,145.35 151.73,144.61 150.09,144.61 149.52,144.04 144.17,144.04 143.1,142.97 137.37,142.97 134.79,141.65 130.44,141.65 129.95,141.16 127.39,141.16 126.91,141.65 123.78,141.65 120.27,145.16 119.51,145.16 118.66,144.31 118.66,144.05 118.01,143.4 113.31,143.4 112.05,144.66 109.23,144.66 108.78,144.21 108.78,143.42 106.38,141.02 102.67,141.02 102.18,140.53 100.92,140.53 v2(100.75,140.7)
  BOTTOM w0.102: JDOCK1.127 191.25,145.94 191.25,145.94 v2(191.1,145.79) ; U51.B4 204.43,113.61 204.4,113.58 v2(204.37,113.58) ; R841.2 207.33,114.4 v2(207.33,114.39)
DOCK_TNY_SMB_DAT: length 278.4
  TOP w0.102: JIO2.75 56.63,40.85 56.75,40.73 57.89,40.73 59.76,42.6 59.76,43.61 59.29,44.08 59.29,46.18 58.87,46.6 58.87,47.29 66.65,55.08 66.65,66.45 66.72,66.51 66.72,66.54 89.64,89.47 89.64,100.85 91.57,102.78 91.57,104.07 v2(91.39,104.25)
  IN2 w0.127: v2(100.75,140.11) 100.59,140.28 99.8,140.28 99.27,139.75 99.27,137.36 97.95,136.04 97.95,131.74 90.89,124.68 90.89,116.2 89.64,114.96 89.64,104.67 89.79,104.52 90.15,104.52 90.99,103.68 91.37,103.68 91.6,103.91 91.6,104.05 v2(91.39,104.25)
  IN3 w0.127: v2(206.66,113.86) 206.72,113.86 206.8,113.94 207.5,113.94 208.02,114.46 208.02,125.23 206.14,127.11 205.89,127.11 200.38,132.61 200.38,139.4 198.54,141.24 195.18,141.24 191.49,144.93 191.49,145.6 v2(191.68,145.79)
  IN4 w0.109: v2(191.68,145.79) 191.53,145.64 191.53,145.36 191.27,145.1 190.38,145.1 189.96,145.51 189.96,145.94 189.07,146.83 188.51,146.83 187.05,148.29 187.05,149.43 185.95,150.53 179.22,150.53 177.97,151.79 174.16,151.79 172.02,153.93 164.76,153.93 164.61,153.77 161.79,153.77 159.05,151.03 159.05,149.49 156.78,147.22 153.88,147.22 152.76,146.1 152.71,146.05 152.71,145.25 151.83,144.37 150.19,144.37 149.62,143.8 144.27,143.8 143.2,142.73 137.43,142.73 134.85,141.41 130.53,141.41 130.05,140.93 127.3,140.93 126.81,141.41 123.69,141.41 120.17,144.93 119.61,144.93 118.9,144.21 118.9,143.96 118.11,143.17 113.21,143.17 111.95,144.42 109.33,144.42 109.02,144.11 109.02,143.33 106.47,140.78 102.77,140.78 102.28,140.29 100.93,140.29 v2(100.75,140.11)
  BOTTOM w0.102: JDOCK1.129 191.75,146.95 191.75,146.95 191.48,146.68 191.48,145.99 191.63,145.84 v2(191.68,145.79) ; U51.A3 v2(206.66,113.86) 207.38,113.86 207.68,114.16 R838.2
DOCK_TNY_SMBUS_ALRT#: length 442.5
  TOP w0.102: PQ1.3 246.11,8.57 244.58,8.57 244.24,8.23 244.24,7.58 244.63,7.2 247.82,7.2 v2(248.63,6.38) ; v2(171.17,105.74) 171.17,105.11 171.61,104.67 172.7,104.67 173.97,103.4 175.11,103.4 175.86,102.65 175.86,100.68 178.06,98.48 178.06,95.63 178.73,94.95 178.73,93.87 178.35,93.49 178.35,92.69 v2(178.2,92.54) ; v2(58.78,40.41) 58.22,39.85 JIO2.71 ; v2(178.29,121.27) 178.29,121.51 178.95,122.17 179.6,122.17 180.24,122.81 180.24,125.82 181.39,126.97 181.39,130.89 v1(181.28,131) 182.9,132.61 183.94,132.61 185.11,133.78 185.93,133.78 187.29,135.14 187.29,137.8 v2(190.25,140.76)
  IN1 w0.109: v2(172.62,81.17) 172.8,81.35 172.8,86.16 173.94,87.3 173.94,87.98 175.9,89.95 175.9,92.41 176.29,92.8 176.67,93.18 177.82,93.18 178.2,92.8 v2(178.2,92.54) ; v2(171.17,105.74) 171.17,108.21 172.42,109.47 172.42,110.48 172.9,110.95 173.37,110.95 174.72,112.3 174.72,114.87 175.49,115.64 179.14,115.64 179.97,116.47 179.97,119.45 178.29,121.13 v2(178.29,121.27)
  IN2 w0.127: v2(178.2,92.54) 178.2,92.7 177.79,93.11 177.23,93.11 176.36,92.24 176.36,91.11 174.17,88.92 155.86,88.92 151.58,84.64 144.45,84.64 143.7,85.39 139.03,85.39 138.56,85.87 137.22,85.87 136.46,86.63 132.4,86.63 131.76,87.27 125.86,87.27 124.77,86.19 124.05,86.19 123.23,87.02 117.5,87.02 117.13,87.38 111.16,87.38 110.46,86.68 107.75,86.68 106.29,85.22 105.52,85.22 104.86,84.56 102.5,84.56 100.93,82.99 99.65,82.99 99.44,82.99 91.38,74.94 91.38,62.54 78.33,49.49 74.49,49.49 71.95,46.95 71.95,45.93 71.17,45.15 69.53,45.15 64.95,40.57 60.54,40.57 60.05,40.09 59.4,40.09 59.18,40.31 58.88,40.31 v2(58.78,40.41)
  IN4 w0.109: v2(172.62,81.17) 174.11,79.69 179.72,79.69 180.67,80.64 190.64,80.64 191.72,81.72 196.8,81.72 198.46,80.06 203.19,80.06 204.3,78.95 207.15,78.95 210.89,75.2 214.13,75.2 214.59,75.66 220.19,75.66 220.69,76.17 233.19,76.17 236.03,73.33 239.91,73.33 240.9,72.35 243.44,72.35 244.92,70.86 244.92,60.92 244.92,60.07 248.52,56.47 248.52,55.12 249.24,54.41 250.43,54.41 250.79,54.76 254.15,54.76 255.9,53.01 255.9,52.57 259.07,49.41 259.07,48.78 263.45,44.4 263.88,44.4 264.24,44.03 264.24,43.25 265.18,42.32 267.87,42.32 269.35,40.84 269.35,39.2 273.16,35.39 275.06,35.39 275.47,34.98 275.47,31.29 273.35,29.17 273.35,19.9 261.66,8.22 256.11,8.22 253.84,5.95 249.06,5.95 v2(248.63,6.38)
  BOTTOM w0.102: v2(190.25,140.76) 190.25,142.49 189.46,143.28 189.46,144.67 190.1,145.31 192.16,145.31 192.41,145.56 192.41,146.01 192.75,146.35 JDOCK1.133 ; v2(171.17,105.74) 171.17,106.26 171.57,106.66 R763.2 171.76,107.08 172.03,107.08 172.32,107.37 172.35,107.37 172.59,107.61 172.59,107.64 172.96,108.01 U46.A51
DOCKED: length 84.9
  TOP w0.102: v2(236.33,115.72) 235.83,116.22 U32.13
  IN3 w0.127: v2(240.01,101.81) 239.63,101.81 236.33,105.11 v2(236.33,115.72)
  IN4 w0.109: v2(240.01,101.81) 238.77,101.81 238.06,102.52 226.55,102.52 225.23,103.84 223.73,103.84 222.9,104.67 221.18,104.67 220.6,105.25 219.4,105.25 219.19,105.04 216.02,105.04 215.33,104.35 206.76,104.35 204.35,101.94 204.35,101.61 203.36,100.62 198.44,100.62 196.99,102.08 196.99,102.49 196.67,102.81 194.9,102.81 194.13,102.03 193.51,102.03 193.16,102.03 193.16,102.03 190.39,102.03 190.22,102.2 189.72,102.2 189.22,102.7 184.75,102.7 184.25,103.2 180.74,103.2 179.96,103.98 v2(179.95,103.98)
  BOTTOM w0.102: v2(179.95,103.98) 180.43,104.45 180.43,104.95 180.55,105.08 U46.A38
DP1_DEMUX_CFG0: length 4.6
  TOP w0.102: RV42.2 164.77,113.58 164.62,113.74 v1(164.39,113.74) 164.28,113.74 v2(163.44,112.9)
  BOTTOM w0.102: UV2.59 162.78,114.29 163.06,114 163.06,113.98 163.44,113.59 v2(163.44,112.9)
DP1_DEMUX_PC10: length 5.9
  TOP w0.102: RV33.2 166.83,114.06 166.55,113.79 v1(166.35,113.79) 166.12,113.79 165.71,114.19 164.76,114.19 RV39.1 163.91,114.67 v2(163.43,115.15)
  BOTTOM w0.102: UV2.56 163.09,115.49 v2(163.43,115.15)
DP1_DEMUX_PC11: length 6.9
  TOP w0.102: RV32.2 166.57,115.69 166.07,115.18 164.79,115.18 RV37.1 163.99,115.99 v2(163.68,115.99) 163.38,115.69 162.28,115.69 v1(162.06,115.92)
  BOTTOM w0.102: v2(163.68,115.99) 163.58,115.88 UV2.55
DP1_DEMUX_PC20: length 5
  TOP w0.102: RV31.2 166.08,116.7 165.6,117.18 164.76,117.18 RV38.1 164.07,116.48 v2(163.21,116.48)
  BOTTOM w0.102: v2(163.21,116.48) 163.02,116.29 UV2.54
DP1_DEMUX_PC21: length 7.3
  TOP w0.102: v2(163.87,118.41) 163.87,118.13 RV36.1 165.34,118.77 v1(165.89,118.77) 166.45,118.77 166.83,118.39 RV30.2
  BOTTOM w0.102: UV2.53 162.8,116.69 163.19,117.08 163.19,117.43 163.87,118.12 v2(163.87,118.41)
DP1_DEMUX_PEQ: length 3.4
  TOP w0.102: RV29.2 158.84,111.61 v2(158.84,112.21) 158.84,112.75 RV35.1
  BOTTOM w0.102: v2(158.84,112.21) 158.89,112.26 UV2.8
DP1_DEMUX_PI0: length 2.6
  TOP w0.102: v2(162.86,112.9) 162.86,112.86 163.15,112.57 RV44.2
  BOTTOM w0.102: v2(162.86,112.9) 162.95,112.98 162.95,113.72 162.78,113.88 UV2.60
DP1_DEMUX_PI1: length 4.7
  BOTTOM w0.102: UV2.1 161.69,112.57 162.22,112.03 v1(162.87,112.03) 163.72,112.03 RV34.2 RV40.1
DP1_DEMUX_SW: length 3.8
  BOTTOM w0.102: RV43.2 153.06,110.94 153.92,111.79 154.6,111.79 154.86,112.05 154.86,112.42 154.89,112.45 UV2.18
DP1_GPU_SEL#: length 37
  IN2 w0.127: v2(176.83,103.16) 176.43,103.16 176.23,103.36 175.34,103.36 174.86,103.84 173.4,103.84 172.95,104.29 170.73,104.29 169.75,103.31 168.5,103.31 167.83,102.64 166.82,102.64 166.08,103.37 163.43,103.37 160.55,106.25 157.46,106.25 155.18,103.97 150.19,103.97 149.55,104.62 v2(149.55,104.67)
  IN3 w0.127: v2(176.08,106.91) 176.08,106.86 176.83,106.11 v2(176.83,103.16)
  BOTTOM w0.102: v2(176.08,106.91) 176.08,106.81 176.3,106.59 U46.B49 ; v2(149.55,104.67) 149.71,104.5 U631.54
DP1_MUX_CEXT: length 3.8
  TOP w0.102: v2(181.4,140.67) 181.26,140.53 v1(181.26,140.18) 181.26,139.28 C97.2
  BOTTOM w0.102: U629.47 180.79,139.56 181.4,140.17 v2(181.4,140.67)
DP1_MUX_IN1_AEQ#: length 2.9
  BOTTOM w0.102: U629.59 184.08,134.91 R117.1 v1(184.46,133.57)
DP1_MUX_IN1_PEQ: length 4.4
  TOP w0.102: v2(185.08,139.34) 185.55,138.87 R121.1
  BOTTOM w0.102: U629.52 183.27,137.71 183.9,138.34 R119.1 184.46,138.72 v2(185.08,139.34)
DP1_MUX_IN2_AEQ#: length 4.2
  BOTTOM w0.102: U629.58 183.24,135.31 183.33,135.21 184.19,135.21 R118.1 184.94,135.96 185.78,135.96 186.03,135.71 v1(186.41,135.71)
DP1_MUX_IN2_PEQ: length 4.5
  TOP w0.102: R122.1 184.5,140.09 v2(183.94,139.53)
  BOTTOM w0.102: R120.1 184.43,140.02 v2(183.94,139.53) 183.94,138.83 183.21,138.11 U629.51
DP1_MUX_PC0: length 4.3
  TOP w0.102: v2(177.19,140.55) 177.5,140.23 v1(177.5,139.97) R98.1 R115.1
  BOTTOM w0.102: U629.38 v2(177.19,140.55)
DP1_MUX_PC1: length 4.1
  TOP w0.102: R116.1 v1(184.16,137.98) 184,137.98 183.85,137.83 v2(183.85,137.39)
  BOTTOM w0.102: U629.55 183.37,136.51 183.85,136.99 v2(183.85,137.39) 183.89,137.39 183.89,137.39 R99.1
DP1_MUX_PI0: length 3.2
  TOP w0.102: v2(183.81,136.29) 183.88,136.22 R123.1
  BOTTOM w0.102: R124.1 183.95,136.43 v2(183.81,136.29) 183.75,136.23 183.2,136.23 183.08,136.11 U629.56
DP1_MUX_REXT: length 4.7
  TOP w0.102: v2(174.88,140.93) 174.95,140.93 175.26,140.61 175.26,140 v1(175.14,139.87) 174.88,139.62 174.88,139.05 R96.2
  BOTTOM w0.102: U629.34 175.59,139.49 175.37,139.71 175.37,140.12 175.3,140.19 175.3,140.51 v2(174.88,140.93)
DP2_GPU_SEL#: length 52.9
  TOP w0.102: v2(175.62,124.63) 175.35,124.9 172.76,124.9 171.48,123.62 171.48,121.95 170.64,121.11 170.64,120.29 168.84,118.5 168.84,113.57 165.17,109.89 165.17,108.98 164.44,108.25 164.44,107.33 163.07,105.96 163.07,104.31 162.28,103.53 162.28,98.06 v1(162.03,97.81) 162.03,96.84 162.75,96.12 163.07,96.12 163.53,95.66 163.53,94.36 v2(163.05,93.87)
  IN3 w0.127: v2(175.62,124.63) 176.22,124.04 176.22,121.1 177.55,119.77 177.55,117.42 177.39,117.25 177.39,116.63 178.57,115.44 178.57,114.59 v2(178.45,114.48)
  BOTTOM w0.102: U46.B7 178.3,114.63 v2(178.45,114.48) ; U636.54 163.21,94.04 v2(163.05,93.87)
DP2_MUX_CEXT: length 3.9
  TOP w0.102: C99.2 147.07,101.85 146.44,101.85 146.17,102.11 v1(146.17,102.47) 146.59,102.47 v2(146.75,102.31)
  BOTTOM w0.102: v2(146.75,102.31) 146.75,102.23 147.08,101.9 U631.47
DP2_MUX_IN1_AEQ#: length 4.6
  TOP w0.102: v2(152,104.65) 152.18,104.84 152.18,104.92 152.44,105.18 152.79,105.18 153.04,104.92 153.04,104.69 153.29,104.44 v1(153.5,104.44) 153.7,104.64 153.7,105.52 R149.1
  BOTTOM w0.102: v2(152,104.65) 151.71,104.37 U631.59
DP2_MUX_IN1_PEQ: length 4.2
  TOP w0.102: v2(148.39,104.85) 148.39,105.49 R146.1 R125.1
  BOTTOM w0.102: U631.52 148.91,105.24 148.81,105.34 v1(148.67,105.34) 148.5,105.34 148.39,105.24 v2(148.39,104.85)
DP2_MUX_IN2_AEQ#: length 3.6
  TOP w0.102: v2(151.41,104.67) 151.41,104.91 151.74,105.24 152.12,105.24 152.39,105.51 v1(152.64,105.51) 152.66,105.53 R151.1
  BOTTOM w0.102: U631.58 151.31,104.57 v2(151.41,104.67)
DP2_MUX_IN2_PEQ: length 5.3
  TOP w0.102: v2(147.81,104.86) 147.62,105.05 146.68,105.05 146.44,105.29 R126.1 145.65,105.67 v1(145.56,105.76) 145.43,105.89 R147.1
  BOTTOM w0.102: U631.51 148.51,104.26 148.4,104.37 148.3,104.37 147.81,104.86 v2(147.81,104.86)
DP2_MUX_PC0: length 4.6
  TOP w0.102: v1(150.45,97.76) R128.1 148.53,97.76 R102.1 147.96,98.3 v2(146.96,98.3)
  BOTTOM w0.102: U631.38 v2(146.96,98.3)
DP2_MUX_PC1: length 6.6
  TOP w0.102: v2(150.23,104.67) 150.23,106.13 R150.1 149.99,108.43 v1(149.87,108.55) 149.76,108.67 R104.1
  BOTTOM w0.102: U631.55 150.11,104.55 v2(150.23,104.67)
