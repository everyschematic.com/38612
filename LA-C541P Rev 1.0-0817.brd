# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D54: length 72.2
  TOP w0.089: CPU1.R1 170.21,54.99 169.27,55.93 v2(168.51,55.93)
  TOP w0.14: JDIMM1.225 131.94,73.17 131.71,72.94 131.53,72.94 131.24,73.23 131.24,73.41 131.65,73.81 131.65,73.99 131.43,74.2 131.25,74.2 130.87,73.82 130.69,73.82 130.51,74.01 130.51,74.19 130.9,74.58 130.9,74.82 130.68,75.04 130.37,75.04 130.24,74.91 130.24,74.54 129.96,74.27 129.74,74.27 129.61,74.4 129.61,74.75 129.74,74.87 v2(129.79,74.87)
  IN1 w0.089: v2(168.51,55.93) 168.51,57.06 166.35,59.22 166.35,62.83 165.87,63.31
  IN1 w0.147: v2(129.79,74.87) 129.92,74.87 133.48,78.43 133.79,78.43 133.96,78.26 134.53,78.26 134.7,78.43 135.93,78.43 136.07,78.29 136.07,78.15 136.2,78.03 136.54,78.03 136.66,78.15 136.66,78.31 136.79,78.43 137.12,78.43 137.25,78.31 137.25,78.15 137.38,78.03 137.71,78.03 137.84,78.15 137.84,78.29 137.99,78.43 138.2,78.43 138.64,78 138.85,78 138.87,78.02 139.08,78.02 139.29,77.81 139.29,77.61 139.26,77.58 139.26,77.37 139.58,77.06 139.93,77.06 140.08,77.2 140.08,77.93 140.21,78.06 140.54,78.06 140.67,77.93 140.67,77.18 140.8,77.06 141.13,77.06 141.26,77.18 141.26,77.81 141.39,77.94 141.72,77.94 141.85,77.81 141.85,77.2 142,77.06 144.83,77.06 145.2,76.68 150.89,76.68 153.01,74.56 153.01,74.21 155.73,71.49 157,71.49 161.59,66.9 162.28,66.9 165.87,63.31
  BOTTOM w0.14: JDIMM2.224 131.62,72.92 130.75,73.8 130.75,73.91 v2(129.79,74.87)
DDR_A_D55: length 73
  TOP w0.089: CPU1.P1 171.69,55.87 v2(171.37,56.19)
  TOP w0.14: JDIMM1.228 125.49,73.92 125.69,74.12 125.69,74.7 126,75.01 126,75.39 126.13,75.52 126.61,75.52 126.73,75.65 126.73,76.31 126.86,76.44 127.06,76.44 127.19,76.31 127.19,75.46 127.31,75.33 128.3,75.33 128.42,75.46 128.42,75.75 128.3,75.88 127.91,75.88 127.79,76 127.79,76.21 127.91,76.33 128.04,76.33 128.17,76.46 v2(128.17,76.6)
  IN1 w0.089: 167.42,60.23 167.42,59.59 170.82,56.19 v2(171.37,56.19)
  IN1 w0.147: 167.42,60.23 167.42,63.36 162.75,68.03 162.06,68.03 157.16,72.93 157.16,73.31 156.61,73.86 155.31,73.86 151.34,77.82 150.68,77.82 149.3,79.21 148.04,79.21 147.72,78.89 147.72,78.21 147.33,77.82 146.46,77.82 145.07,79.21 139.19,79.21 138.84,79.56 136.33,79.56 135.85,80.04 133.5,80.04 129.6,76.15 128.62,76.15 v2(128.17,76.6)
  BOTTOM w0.14: v2(128.17,76.6) 128.17,76.42 127.81,76.06 127.1,76.06 126.4,75.37 126.4,75.05 125.53,74.17 JDIMM2.229
DDR_A_D56: length 74.8
  TOP w0.089: CPU1.M4 173.12,56.98 170.54,56.98 v2(170.01,57.51)
  TOP w0.14: JDIMM1.232 125.54,74.92 125.74,75.12 125.74,75.69 127.22,77.17 128.01,77.17 v2(128.61,77.77)
  IN1 w0.089: 168.33,60.33 170.55,58.11 170.55,57.69 170.37,57.51 v2(170.01,57.51)
  IN1 w0.147: v2(128.61,77.77) 128.2,78.18 128.2,78.3 128.34,78.45 128.98,78.45 129.2,78.22 129.55,78.22 129.78,78.45 130.18,78.45 132.98,81.25 135.9,81.25 136.39,81.73 140.38,81.73 140.77,81.35 140.77,80.82 140.87,80.72 141.4,80.72 141.7,80.42 143.92,80.42 144.03,80.54 144.03,80.99 144.15,81.11 149.8,81.11 155.85,75.06 157.17,75.06 157.63,74.61 158.87,74.61 159.18,74.3 159.18,73.97 159.78,73.36 159.78,72.01 162.04,69.75 162.73,69.75 168.33,64.15 168.33,60.33
  BOTTOM w0.14: JDIMM2.233 125.79,75.17 126.78,76.17 126.78,76.64 127.48,77.33 128.17,77.33 v2(128.61,77.77)
DDR_A_D57: length 73.1
  TOP w0.089: CPU1.M1 170.85,57.5 169.49,58.86 v2(168.66,58.86)
  TOP w0.14: JDIMM1.233 131.97,75.17 130.54,76.6 v2(129.41,76.6)
  IN1 w0.089: v2(168.66,58.86) 168.66,59.38 167.73,60.32
  IN1 w0.147: 167.73,60.32 167.73,63.69 162.94,68.48 162.25,68.48 158.32,72.41 158.32,72.62 158.44,72.74 158.44,72.95 158.23,73.16 158.03,73.16 157.9,73.04 157.7,73.04 157.61,73.12 157.61,73.49 156.8,74.31 155.5,74.31 150.98,78.83 150.77,78.83 150.64,78.69 150.46,78.69 150.22,78.93 150.22,79.11 150.36,79.24 150.36,79.45 150.15,79.66 147.39,79.66 147.27,79.53 147.27,78.4 147.14,78.27 146.8,78.27 146.68,78.4 146.68,79.54 146.55,79.67 146.16,79.67 146.03,79.54 146.03,79.4 145.9,79.27 145.65,79.27 145.26,79.66 141.37,79.66 141.1,79.93 140.76,79.93 140.49,79.66 140.14,79.66 140.01,79.79 140.01,80.59 139.88,80.72 139.51,80.72 139.39,80.59 139.39,80.13 139.26,80.01 138.93,80.01 138.8,80.13 138.8,80.59 138.67,80.72 138.34,80.72 138.21,80.59 138.21,80.14 138.08,80.01 137.75,80.01 137.62,80.14 137.62,80.59 137.49,80.72 137.16,80.72 137.03,80.59 137.03,80.14 136.9,80.01 136.57,80.01 136.44,80.14 136.44,80.35 136.29,80.5 133.31,80.5 129.92,77.11 129.73,77.11 129.48,77.36 129.14,77.36 129.01,77.24 129.01,77.02 129.41,76.62 v2(129.41,76.6)
  BOTTOM w0.14: v2(129.41,76.6) 130.33,75.68 131.16,75.68 131.92,74.92 JDIMM2.232
DDR_A_D58: length 74.1
  TOP w0.089: v2(173.31,58.69) 173.64,58.36 CPU1.L4
  TOP w0.14: v2(130.79,82.48) 130.79,79.76 131.37,79.18 JDIMM1.249
  IN1 w0.089: 171.84,60.16 v2(173.31,58.69)
  IN1 w0.147: 171.84,60.16 170.2,61.8 170.2,65.52 165.02,70.69 164.35,71.37 164.35,75.63 162.56,77.42 162.56,78.01 162.43,78.14 162.1,78.14 161.97,78.01 161.97,76.66 161.84,76.53 161.51,76.53 161.38,76.66 161.38,77.57 161.25,77.7 160.92,77.7 160.79,77.57 160.79,77.04 160.64,76.89 160.22,76.89 160,77.12 159.26,77.12 159.03,76.89 158.58,76.89 158.12,77.35 156.8,77.35 150.75,83.4 148.68,83.4 147.25,84.83 134.46,84.83 133.71,84.07 131.15,84.07 130.79,83.71 v2(130.79,82.48)
  BOTTOM w0.14: v2(130.79,82.48) 130.73,82.42 130.73,80.3 131.6,79.43 JDIMM2.250
DDR_A_D59: length 74.3
  TOP w0.089: CPU1.L2 172.34,58.36 v2(172.01,58.69)
  TOP w0.14: JDIMM1.246 125.47,78.43 126.64,79.6 127.04,79.6 128.28,80.84 128.28,81.15 v2(128.29,81.15)
  IN1 w0.089: 170.58,60.84 171.64,59.78 171.64,59.06 v2(172.01,58.69)
  IN1 w0.147: 170.58,60.84 169.84,61.58 169.84,65.34 162.49,72.7 162.49,74.06 160.04,76.52 158.42,76.52 157.96,76.97 156.64,76.97 150.59,83.02 148.24,83.02 148.14,83.12 148.14,83.41 148.01,83.54 147.64,83.54 147.51,83.41 147.51,83.15 147.39,83.02 146.98,83.02 146.85,83.15 146.85,84.33 146.73,84.45 146.39,84.45 146.26,84.33 146.26,83.68 146.12,83.54 145.82,83.54 145.67,83.68 145.67,84.33 145.55,84.45 145.21,84.45 145.09,84.33 145.09,83.68 144.94,83.54 144.57,83.54 143.85,84.25 136.37,84.25 135.82,83.7 132.2,83.7 131.54,83.04 131.54,82.52 130.6,81.58 128.46,81.58 128.29,81.41 v2(128.29,81.15)
  BOTTOM w0.14: v2(128.29,81.15) 128.28,81.15 128.28,80.8 125.66,78.17 JDIMM2.245
DDR_A_D60: length 72.3
  TOP w0.089: CPU1.M5 174.29,57.45 v2(173.97,57.13)
  TOP w0.14: JDIMM1.236 125.5,75.92 v2(127.36,77.78)
  IN1 w0.089: 168.57,60.4 171.83,57.13 v2(173.97,57.13)
  IN1 w0.147: v2(127.36,77.78) 127.07,77.78 126.94,77.91 126.94,78.7 127.07,78.82 130.02,78.82 132.82,81.62 133.92,81.62 134.41,82.11 140.54,82.11 141.86,80.79 143.22,80.79 143.92,81.49 149.96,81.49 156,75.44 157.33,75.44 157.78,74.98 159.4,74.98 160.16,74.23 160.16,72.17 161.42,70.9 161.63,70.9 161.78,71.05 161.96,71.05 162.2,70.82 162.2,70.64 162.05,70.49 162.05,70.28 162.2,70.13 162.89,70.13 168.57,64.45 168.57,60.4
  BOTTOM w0.14: v2(127.36,77.78) 125.75,76.17 JDIMM2.237
DDR_A_D61: length 72.9
  TOP w0.089: v2(169.11,58.41) 169.7,58.41 170.96,57.15 171.99,57.15 CPU1.M2
  TOP w0.14: JDIMM1.237 131.52,76.17 v2(129.88,77.82)
  IN1 w0.089: 168.1,60.25 169.11,59.24 v2(169.11,58.41)
  IN1 w0.147: v2(129.88,77.82) 130.08,77.82 133.14,80.87 136.06,80.87 136.28,81.1 136.82,81.1 137.08,81.35 137.41,81.35 137.67,81.1 138,81.1 138.25,81.35 138.59,81.35 138.84,81.1 139.18,81.1 139.44,81.36 140.23,81.36 140.4,81.19 140.4,80.46 140.51,80.35 141.24,80.35 141.54,80.04 144.26,80.04 144.41,80.19 144.41,80.61 144.54,80.73 144.87,80.73 145,80.61 145,80.16 145.13,80.04 145.46,80.04 145.59,80.16 145.59,80.61 145.72,80.73 146.05,80.73 146.18,80.61 146.18,80.19 146.33,80.04 146.67,80.04 146.82,80.19 146.82,80.61 146.95,80.73 147.28,80.73 147.41,80.61 147.41,80.19 147.56,80.04 147.85,80.04 148,80.19 148,80.61 148.13,80.73 148.46,80.73 148.59,80.61 148.59,80.16 148.71,80.04 149.05,80.04 149.18,80.16 149.18,80.61 149.3,80.73 149.64,80.73 149.77,80.61 149.77,80.19 149.91,80.04 150.34,80.04 155.69,74.69 156.95,74.69 157.69,73.95 157.85,73.95 158.14,74.23 158.49,74.23 158.59,74.14 158.59,73.98 158.35,73.73 158.35,73.58 158.57,73.36 158.8,73.36 158.92,73.48 159.13,73.48 159.4,73.21 159.4,72.95 159.26,72.8 158.94,72.8 158.81,72.67 158.81,72.45 159.05,72.21 159.33,72.21 159.4,72.14 159.4,71.86 161.89,69.38 162.57,69.38 168.1,63.85 168.1,60.25
  BOTTOM w0.14: v2(129.88,77.82) 129.86,77.82 131.75,75.92 JDIMM2.236
DDR_A_D62: length 75.7
  TOP w0.089: v2(173.96,58.69) 174.29,58.36 CPU1.L5
  TOP w0.14: JDIMM1.245 131.55,78.17 129.62,80.1 v2(129.62,82.45)
  IN1 w0.089: v2(173.96,58.69) 172.22,60.42 172.22,60.42
  IN1 w0.147: v2(129.62,82.45) 129.62,83.22 131.35,84.95 132.81,84.95 132.96,84.8 132.96,84.61 133.1,84.46 133.4,84.46 133.54,84.61 133.54,84.8 133.95,85.21 147.41,85.21 148.84,83.77 150.9,83.77 155.54,79.14 162.34,79.14 163.03,78.45 163.03,77.48 164.72,75.79 164.72,71.52 170.49,65.76 170.49,62.16 172.22,60.42
  BOTTOM w0.14: JDIMM2.246 131.49,78.43 131.15,78.76 131.15,79.33 129.62,80.87 v2(129.62,82.45)
DDR_A_D63: length 72.6
  TOP w0.089: v2(171.36,58.7) 171.69,58.37 CPU1.L1
  TOP w0.14: v2(127.11,81.15) 127.11,80.41 126.13,79.43 JDIMM1.250
  IN1 w0.089: v2(171.36,58.7) 171.36,59.57 170.47,60.46
  IN1 w0.147: 170.47,60.46 169.5,61.43 169.5,65.15 162.37,72.28 161.79,72.28 161.31,72.76 161.31,74.71 159.88,76.14 158.26,76.14 157.81,76.6 156.48,76.6 150.44,82.64 146.17,82.64 146.04,82.77 146.04,82.94 145.91,83.07 145.62,83.07 145.5,82.94 145.5,82.77 145.37,82.64 144.99,82.64 144.86,82.77 144.86,83.03 144.73,83.16 144.38,83.16 144.25,83.03 144.25,82.77 144.12,82.64 143.75,82.64 143.62,82.77 143.62,83.75 143.5,83.88 141.59,83.88 141.45,83.73 141.45,83.37 141.32,83.24 140.98,83.24 140.86,83.37 140.86,83.73 140.71,83.88 140.42,83.88 140.27,83.73 140.27,83.4 140.14,83.27 139.81,83.27 139.68,83.4 139.68,83.73 139.53,83.88 139.24,83.88 139.09,83.73 139.09,83.47 138.96,83.35 138.63,83.35 138.5,83.47 138.5,83.73 138.35,83.88 136.53,83.88 135.97,83.32 132.35,83.32 131.92,82.89 131.92,82.36 130.28,80.72 127.54,80.72 127.11,81.14 v2(127.11,81.15)
  BOTTOM w0.14: JDIMM2.249 125.66,79.18 127.11,80.63 v2(127.11,81.15)
DDR_A_DQS0: length 75.2
  TOP w0.089: v2(173.42,25.8) 173.62,25.8 CPU1.BP5
  TOP w0.14: v2(130.01,16.52) 130.01,16.54 129.81,16.75 129.73,16.75 129.6,16.87 129.6,17 129.8,17.2 129.98,17.2 130.17,17 130.33,17 130.54,17.21 130.54,18.61 130.8,18.87 130.89,18.87 131.19,18.87 131.46,18.6 131.46,18 131.53,17.93 131.81,17.93 131.86,17.99 131.86,18.11 131.93,18.17 JDIMM1.13
  IN1 w0.089: v2(173.42,25.8) 173.42,25.62 173.06,25.26 173.06,23.83 173.15,23.74 173.15,22.52 172.09,21.46 172.08,21.47 172.06,21.47 172.05,21.46
  IN1 w0.147: v2(130.01,16.52) 129.86,16.52 129.7,16.37 129.7,16.09 129.82,15.97 131.5,15.97 131.65,16.11 131.65,16.55 131.92,16.82 132.62,16.82 132.89,16.55 132.89,15.68 133.21,15.36 135.83,15.36 137.04,14.15 164.75,14.15 167.29,11.61 170.51,11.61 172.79,13.89 172.79,17.11 171.6,18.3 171.6,21.01 172.05,21.46
  BOTTOM w0.14: JDIMM2.13 125.86,18.17 126.08,17.96 126.08,17.64 126.49,17.23 129.74,17.23 129.95,17.03 129.95,16.58 v2(130.01,16.52)
DDR_A_DQS1: length 66.2
  TOP w0.089: CPU1.BK3 172.7,27.83 172.21,27.83 171.86,28.18 171.42,28.18 168.24,25.01 168.24,24 168.57,23.67 168.57,23.62 v2(168.41,23.47)
  TOP w0.14: JDIMM1.34 126.19,23.42 126.43,23.19 126.43,22.7 126.05,22.33 126.05,22.15 126.22,21.98 126.4,21.98 126.77,22.36 128.47,22.36 128.73,22.1 128.73,21.49 v2(128.8,21.43)
  IN1 w0.089: v2(168.41,23.47) 168.43,23.49 168.7,23.49 168.77,23.42 168.77,23.23 167.87,22.33 167.83,22.33 167.81,22.31
  IN1 w0.147: 167.81,22.31 167.55,22.05 166.1,22.05 164.36,20.31 153.37,20.31 152.58,19.52 152.01,19.52 151.69,19.83 150.84,19.83 150.53,19.52 145.14,19.52 144.7,19.07 140.96,19.07 140.08,19.95 136.84,19.95 136.1,20.68 134.41,20.68 134.22,20.87 128.49,20.87 128.38,20.98 128.38,21.13 128.48,21.23 128.48,21.29 128.62,21.43 v2(128.8,21.43)
  BOTTOM w0.14: v2(128.8,21.43) 128.58,21.43 128.5,21.34 128.5,21.25 128.39,21.15 128.39,21.02 128.5,20.91 130.25,20.91 130.71,21.37 130.71,22.35 131.55,23.18 131.7,23.18 131.76,23.24 131.76,23.34 131.84,23.42 JDIMM2.34
DDR_A_DQS2: length 64.8
  TOP w0.089: CPU1.BF3 172.71,30.3 171.56,30.3 171.31,30.55 170.33,30.55 167.15,27.37 167.15,26.13 167.42,25.86 167.42,25.62 v2(167.36,25.55)
  TOP w0.14: v2(127.77,26.94) 127.77,27.48 128.11,27.81 130.18,27.81 131.04,28.68 JDIMM1.55
  IN1 w0.089: 161.95,23.93 161.96,23.93 161.99,23.96 163.46,23.96 165.62,26.12 167.1,26.12 167.36,25.86 v2(167.36,25.55)
  IN1 w0.147: 161.95,23.93 145.1,23.93 144.74,23.56 139.44,23.56 137.17,25.84 128.9,25.84 128.73,25.66 127.92,25.66 127.66,25.92 127.66,26.41 127.77,26.53 v2(127.77,26.94)
  BOTTOM w0.14: v2(127.77,26.94) 127.98,26.94 128.07,26.85 128.07,26.75 128.22,26.6 128.22,26.4 128.07,26.25 127.07,26.25 126.52,26.8 126.52,27.64 125.48,28.68 JDIMM2.55
DDR_A_DQS3: length 64.8
  TOP w0.089: CPU1.BC3 172.71,32.81 171.13,32.81 171.12,32.8 169.14,32.8 168.03,31.69 168.03,31.3 168.19,31.13 v2(168.19,30.82)
  TOP w0.14: v2(128.59,32.04) 128.7,32.04 129.04,31.7 129.04,31.56 128.92,31.45 127.16,31.45 126.18,32.42 126.18,33.42 125.92,33.68 125.69,33.68 125.63,33.74 125.63,33.85 125.56,33.93 JDIMM1.76
  IN1 w0.089: 161.95,27.79 161.96,27.79 161.99,27.82 163.27,27.82 165.71,30.25 166.39,30.25 167.31,31.17 168.05,31.17 168.19,31.03 v2(168.19,30.82)
  IN1 w0.147: v2(128.59,32.04) 128.68,31.96 128.68,31.57 128.99,31.26 130.51,31.26 130.8,31.55 130.8,32 130.93,32.13 131.46,32.13 131.59,32 131.59,31.53 131.85,31.26 138.48,31.26 141.96,27.79 161.95,27.79
  BOTTOM w0.14: JDIMM2.76 131.2,33.93 130.74,33.46 130.74,33.14 131.12,32.75 131.12,32.53 130.91,32.32 130.75,32.32 130.2,32.87 128.83,32.87 128.59,32.64 128.59,32.04 v2(128.59,32.04)
DDR_A_DQS4: length 69.6
  TOP w0.089: v2(167.07,49.97) 167.58,50.48 168.56,50.48 168.79,50.25 172.77,50.25 172.99,50.03 CPU1.AB3
  TOP w0.14: JDIMM1.179 131.95,61.68 131.03,62.6 131.03,63.32 130.08,64.27 128.53,64.27 127.85,63.59 v2(127.83,63.59)
  IN1 w0.089: 160.85,56.76 160.86,56.75 160.86,56.71 162.06,55.51 162.32,55.51 167.26,50.56 167.26,50.31 167.07,50.11 v2(167.07,49.97)
  IN1 w0.147: v2(127.83,63.59) 128.01,63.77 128.01,64 128.48,64.48 131.1,64.48 134.01,67.39 136.55,67.39 137.09,66.86 139.57,66.86 139.87,66.56 139.87,66.1 140,65.97 140.48,65.97 140.61,66.1 140.61,66.5 140.86,66.76 141.59,66.76 141.85,66.5 141.85,66.12 142,65.97 148.45,65.97 151.22,63.19 153.72,63.19 158.2,58.72 158.89,58.72 160.85,56.76
  BOTTOM w0.14: JDIMM2.179 125.52,61.68 125.58,61.62 125.58,61.5 125.64,61.43 125.75,61.33 126.24,61.33 126.5,61.59 126.5,62.85 126.77,63.12 128.2,63.12 128.26,63.18 128.26,63.34 128.2,63.4 128.2,63.58 128.07,63.71 127.95,63.71 v2(127.83,63.59)
DDR_A_DQS5: length 73.1
  TOP w0.089: CPU1.V3 172.78,52.68 172.58,52.68 172.5,52.76 170.46,52.76 169.56,53.65 167.33,53.65 167.24,53.56 v2(167.24,53.39)
  TOP w0.14: JDIMM1.200 125.49,66.92 125.54,66.87 125.54,66.75 125.6,66.68 125.91,66.68 125.93,66.71 125.93,67.39 126.19,67.65 126.58,67.65 126.87,67.36 126.87,67.25 126.94,67.17 128.43,67.17 128.53,67.28 128.53,67.43 128.43,67.53 127.37,67.53 127.11,67.79 127.11,67.86 126.96,68.02 126.96,68.13 126.9,68.18 v2(126.69,68.18)
  IN1 w0.089: v2(167.24,53.39) 167.24,53.61 167.35,53.73 167.35,54.35 163.35,58.35 163.35,59.72 162.81,60.26
  IN1 w0.147: v2(126.69,68.18) 126.81,68.31 126.81,68.6 127.61,69.41 130.56,69.41 132.94,71.79 140.87,71.79 141.05,71.6 149.01,71.6 153.44,67.18 155.21,67.18 159.8,62.58 160.49,62.58 162.81,60.26
  BOTTOM w0.14: v2(126.69,68.18) 126.79,68.29 126.79,68.67 127.07,68.95 130.2,68.95 130.73,68.42 130.73,68.15 131.95,66.92 JDIMM2.200
DDR_A_DQS6: length 72
  TOP w0.089: CPU1.R3 172.7,55.27 170.33,55.27 168.28,57.33 167.91,57.33 167.58,56.99 v2(167.58,56.8)
  TOP w0.14: v2(126.95,73.11) 126.95,73.7 127.26,74 130.09,74 131.47,72.62 131.47,72.24 131.54,72.17 JDIMM1.221
  IN1 w0.089: 165.55,63 165.56,62.99 165.56,62.95 165.59,62.91 165.59,62.87 166.06,62.4 166.06,59.18 167.72,57.51 167.72,57.19 167.58,57.04 v2(167.58,56.8)
  IN1 w0.147: 165.55,63 162.1,66.45 161.41,66.45 156.81,71.04 155.54,71.04 152.56,74.03 152.56,74.37 150.7,76.23 145.01,76.23 144.64,76.6 139.32,76.6 138.35,77.58 133.26,77.58 130.05,74.37 127.86,74.37 127.09,73.6 127.09,73.25 v2(126.95,73.11)
  BOTTOM w0.14: v2(126.95,73.11) 127.12,73.11 127.19,73.04 127.19,72.94 127.25,72.88 127.25,72.75 127.18,72.68 126.55,72.68 125.8,71.93 125.66,71.93 125.59,72 125.59,72.09 125.51,72.17 JDIMM2.221
DDR_A_DQS7: length 76.6
  TOP w0.089: CPU1.M3 172.7,57.79 170.98,57.79 169.8,58.96 169.8,59.48 170.02,59.7 v2(170.02,60.03)
  TOP w0.14: v2(128.35,79.28) 128.46,79.28 128.55,79.19 128.55,79.08 128.71,78.92 128.71,78.78 128.51,78.58 127.55,78.58 127.07,79.06 126.52,79.06 126.15,78.68 126.15,77.46 125.87,77.18 125.66,77.18 125.6,77.24 125.6,77.36 125.53,77.43 JDIMM1.242
  IN1 w0.089: 169.14,60.83 169.14,60.82 169.11,60.79 169.11,60.74 169.08,60.71 169.08,60.42 169.71,59.8 169.9,59.8 170.02,59.92 v2(170.02,60.03)
  IN1 w0.147: v2(128.35,79.28) 128.36,79.28 128.71,79.63 128.71,79.95 129.03,80.27 130.47,80.27 132.53,82.33 133.61,82.33 134.09,82.82 136.79,82.82 136.94,82.96 136.94,83.15 137.22,83.43 137.91,83.43 138.19,83.15 138.19,82.96 138.33,82.82 140.83,82.82 142.15,81.5 142.84,81.5 143.53,82.19 150.25,82.19 156.3,76.14 157.62,76.14 158.08,75.69 159.69,75.69 160.86,74.52 160.86,72.58 161.68,71.76 162.25,71.76 169.14,64.87 169.14,60.83
  BOTTOM w0.14: JDIMM2.242 131.48,77.43 130.58,78.33 130.58,79.27 129.75,80.1 128.61,80.1 128.35,79.84 v2(128.35,79.28)
DDR_A_DQS8: length 66.3
  TOP w0.089: v2(166.2,31.66) 166.4,31.85 166.4,32.03 166.16,32.26 166.16,33.14 168.36,35.34 171.3,35.34 171.32,35.33 172.61,35.33 172.71,35.23 172.88,35.23 172.99,35.33 CPU1.AY3
  TOP w0.14: JDIMM1.97 132,39.17 131.76,38.93 131.45,38.93 131.08,38.56 131.08,37.59 130.82,37.33 129.19,37.33 129.05,37.47 129.05,37.68 129.14,37.77 v2(129.43,37.77)
  IN3 w0.17: v2(166.2,31.66) 166.36,31.81 166.55,31.81 166.69,31.67 166.69,31.39 165.94,30.65 164.48,30.65 163.56,31.58 163.22,31.58 163.05,31.75 163.05,32.27 162.71,32.61 161.95,32.61 161.61,32.27 161.61,31.75 161.44,31.58 160.93,31.58 160.76,31.75 160.76,32.35 160.41,32.69 159.66,32.69 159.31,32.35 159.31,31.75 159.14,31.58 147.34,31.58 142,36.92 137.38,36.92 137.28,37.01 129.42,37.01 129.17,37.27 129.17,37.64 129.3,37.77 v2(129.43,37.77)
  BOTTOM w0.14: JDIMM2.97 125.9,39.17 126.57,38.5 128.95,38.5 129.28,38.18 129.28,37.92 v2(129.43,37.77)
DDR_A_DQS#0: length 75.2
  TOP w0.089: v2(173.62,25.18) 173.85,24.94 CPU1.BR5
  TOP w0.14: JDIMM1.11 131.42,17.68 131.2,17.9 131.2,18.5 131.09,18.61 130.91,18.61 130.8,18.5 130.8,17.1 130.45,16.76 130.45,16.3 130.25,16.1 129.76,16.1 129.33,16.52 v2(129.3,16.52)
  IN1 w0.089: 172.23,21.28 172.24,21.29 172.24,21.33 173.35,22.44 173.35,23.82 173.26,23.91 173.26,25.18 173.34,25.26 173.53,25.26 v2(173.62,25.18)
  IN1 w0.147: 172.23,21.28 171.86,20.9 171.86,18.41 173.05,17.22 173.05,13.78 170.62,11.35 167.18,11.35 164.64,13.89 136.93,13.89 135.72,15.1 133.11,15.1 132.64,15.57 132.64,16.44 132.51,16.57 132.03,16.57 131.9,16.44 131.9,16 131.61,15.71 129.72,15.71 129.45,15.98 129.45,16.37 v2(129.3,16.52)
  BOTTOM w0.14: v2(129.3,16.52) 129.52,16.52 129.59,16.59 129.59,16.7 129.69,16.8 129.69,16.92 129.63,16.97 126.38,16.97 125.82,17.54 125.82,17.85 125.76,17.92 125.56,17.92 125.49,17.85 125.49,17.75 125.41,17.68 JDIMM2.11
DDR_A_DQS#1: length 66.2
  TOP w0.089: v2(168.86,23.91) 168.62,23.91 168.45,24.08 168.45,24.92 171.51,27.98 171.81,27.98 172.17,27.62 172.69,27.62 CPU1.BL3
  TOP w0.14: v2(128.08,21.44) 128.12,21.39 128.23,21.39 128.4,21.56 128.4,21.62 128.47,21.7 128.47,21.99 128.37,22.1 126.88,22.1 126.5,21.73 126.11,21.73 125.79,22.04 125.79,22.44 126.17,22.81 126.17,23.08 126.08,23.17 125.65,23.17 125.58,23.1 125.58,22.99 125.51,22.93 JDIMM1.32
  IN1 w0.089: 167.99,22.13 168,22.14 168,22.18 168.03,22.22 168.97,23.15 168.97,23.5 168.86,23.61 v2(168.86,23.91)
  IN1 w0.147: 167.99,22.13 167.66,21.8 166.2,21.8 164.46,20.06 153.48,20.06 152.68,19.27 151.9,19.27 151.59,19.58 150.95,19.58 150.64,19.27 145.25,19.27 144.8,18.82 140.85,18.82 139.97,19.7 136.73,19.7 136,20.43 134.3,20.43 134.11,20.62 128.39,20.62 128.13,20.87 128.13,21.38 v2(128.08,21.44)
  BOTTOM w0.14: JDIMM2.32 131.65,22.93 130.97,22.24 130.97,21.26 130.36,20.65 128.39,20.65 128.13,20.91 128.13,21.38 v2(128.08,21.44)
DDR_A_DQS#2: length 64.8
  TOP w0.089: CPU1.BG3 173.2,30.06 173.2,30.16 173.1,30.26 172.97,30.26 172.83,30.13 171.44,30.13 171.22,30.34 170.42,30.34 167.36,27.28 167.36,26.22 167.57,26 v2(167.81,26)
  TOP w0.14: v2(128.49,26.94) 128.38,26.94 128.03,27.28 128.03,27.37 128.22,27.55 130.29,27.55 131.15,28.42 131.65,28.42 131.72,28.34 131.72,28.25 131.8,28.17 JDIMM1.53
  IN1 w0.089: v2(167.81,26) 167.49,26 167.18,26.31 165.54,26.31 163.38,24.15 161.99,24.15 161.96,24.18 161.95,24.18
  IN1 w0.147: 161.95,24.18 145,24.18 144.63,23.82 139.55,23.82 137.27,26.09 128.8,26.09 128.62,25.91 128.03,25.91 127.91,26.03 127.91,26.31 128.17,26.56 128.17,26.76 128.34,26.94 v2(128.49,26.94)
  BOTTOM w0.14: JDIMM2.53 125.61,28.17 126.26,27.53 126.26,26.7 126.97,25.99 128.18,25.99 128.49,26.3 v2(128.49,26.94)
DDR_A_DQS#3: length 64.7
  TOP w0.089: v2(168.64,31.27) 168.35,31.27 168.24,31.39 168.24,31.6 169.23,32.59 171.21,32.59 171.25,32.63 172.82,32.63 172.9,32.71 173.03,32.71 173.12,32.62 173.12,32.49 CPU1.BD3
  TOP w0.14: JDIMM1.74 125.82,33.42 125.92,33.32 125.92,32.31 127.05,31.19 129.03,31.19 129.3,31.45 v2(129.3,32.04)
  IN1 w0.089: 161.95,28.05 161.96,28.05 161.99,28.02 163.19,28.02 165.63,30.45 166.31,30.45 167.23,31.37 168.13,31.37 168.35,31.15 168.52,31.15 v2(168.64,31.27)
  IN1 w0.147: 161.95,28.05 142.06,28.05 138.59,31.52 131.96,31.52 131.84,31.63 131.84,32.11 131.57,32.38 130.82,32.38 130.55,32.11 130.55,31.66 130.41,31.52 129.09,31.52 128.94,31.67 128.94,31.79 129.19,32.04 v2(129.3,32.04)
  BOTTOM w0.14: JDIMM2.74 131.85,33.42 131.8,33.47 131.8,33.6 131.73,33.67 131.31,33.67 130.99,33.35 130.99,33.25 131.38,32.86 131.38,32.42 131.02,32.06 130.64,32.06 130.09,32.61 128.93,32.61 128.85,32.53 128.85,32.39 129.21,32.04 v2(129.3,32.04)
DDR_A_DQS#4: length 69.5
  TOP w0.089: v2(166.62,50.42) 166.7,50.33 167.13,50.33 167.49,50.69 168.64,50.69 168.88,50.45 171.38,50.45 171.42,50.42 172.86,50.42 172.9,50.38 173.01,50.38 173.1,50.47 173.1,50.58 CPU1.AA3
  TOP w0.14: v2(128.62,63.57) 128.48,63.57 128.41,63.63 128.41,63.7 128.41,63.78 128.64,64.01 129.97,64.01 130.77,63.21 130.77,62.49 131.79,61.47 131.79,61.23 131.85,61.17 JDIMM1.177
  IN1 w0.089: v2(166.62,50.42) 166.77,50.26 166.85,50.26 166.92,50.33 167.01,50.33 167.07,50.39 167.07,50.48 162.24,55.31 161.98,55.31 160.72,56.57 160.68,56.57 160.67,56.58
  IN1 w0.147: 160.67,56.58 158.78,58.46 158.09,58.46 153.61,62.94 151.12,62.94 148.34,65.72 141.89,65.72 141.6,66.01 141.6,66.4 141.49,66.5 140.97,66.5 140.86,66.4 140.86,65.99 140.58,65.71 139.89,65.71 139.61,65.99 139.61,66.45 139.47,66.6 136.98,66.6 136.45,67.13 134.12,67.13 131.21,64.22 128.59,64.22 128.26,63.9 128.26,63.75 128.44,63.57 v2(128.62,63.57)
  BOTTOM w0.14: v2(128.62,63.57) 128.52,63.47 128.52,63.07 128.31,62.86 126.87,62.86 126.76,62.74 126.76,61.48 126.34,61.07 125.64,61.07 125.54,61.17 JDIMM2.177
DDR_A_DQS#5: length 73.1
  TOP w0.089: v2(166.79,53.84) 166.9,53.72 167.11,53.72 167.24,53.86 169.65,53.86 170.54,52.97 171.37,52.97 171.4,52.93 172.57,52.93 172.64,52.86 173.04,52.86 173.1,52.92 173.1,53.1 CPU1.U3
  TOP w0.14: v2(127.38,68.2) 127.38,67.89 127.47,67.79 128.53,67.79 128.79,67.54 128.79,67.17 128.53,66.91 126.83,66.91 126.61,67.14 126.61,67.26 126.47,67.39 126.29,67.39 126.19,67.29 126.19,66.6 126.02,66.43 JDIMM1.198
  IN1 w0.089: 162.63,60.08 162.64,60.07 162.66,60.07 162.67,60.09 162.72,60.04 163.15,59.6 163.15,58.27 167.16,54.27 167.16,53.81 167.04,53.69 166.93,53.69 v2(166.79,53.84)
  IN1 w0.147: v2(127.38,68.2) 127.25,68.2 127.06,68.39 127.06,68.5 127.72,69.15 130.67,69.15 133.05,71.53 140.76,71.53 140.95,71.34 148.91,71.34 153.33,66.92 155.1,66.92 159.7,62.33 160.39,62.33 162.63,60.08
  BOTTOM w0.14: JDIMM2.198 131.93,66.43 131.83,66.53 131.83,66.68 130.47,68.04 130.47,68.32 130.09,68.69 127.18,68.69 127.05,68.56 127.05,68.4 127.09,68.37 127.09,68.32 127.21,68.2 v2(127.38,68.2)
DDR_A_DQS#6: length 72.1
  TOP w0.089: CPU1.P3 172.99,55.71 173.1,55.6 173.1,55.41 173.02,55.33 172.9,55.33 172.78,55.45 171.5,55.45 171.46,55.48 170.42,55.48 168.36,57.54 167.83,57.54 167.42,57.13 167.25,57.13 v2(167.13,57.25)
  TOP w0.14: v2(127.61,73.11) 127.44,73.11 127.38,73.18 127.38,73.29 127.21,73.46 127.21,73.59 127.37,73.74 129.98,73.74 131.21,72.52 131.21,72.14 131.43,71.92 131.7,71.92 131.79,71.83 131.79,71.71 131.82,71.67 JDIMM1.219
  IN1 w0.089: v2(167.13,57.25) 167.22,57.16 167.42,57.16 167.52,57.27 167.52,57.43 165.86,59.09 165.86,62.32 165.37,62.82
  IN1 w0.147: v2(127.61,73.11) 127.52,73.11 127.34,73.29 127.34,73.49 127.96,74.11 130.16,74.11 133.37,77.32 138.24,77.32 139.21,76.35 144.53,76.35 144.91,75.97 150.6,75.97 152.3,74.27 152.3,73.92 155.44,70.79 156.71,70.79 161.3,66.19 161.99,66.19 165.37,62.82
  BOTTOM w0.14: v2(127.61,73.11) 127.51,73.02 127.51,72.64 127.29,72.42 126.66,72.42 125.91,71.67 JDIMM2.219
DDR_A_DQS#7: length 76.7
  TOP w0.089: CPU1.L3 173.19,58.24 173.32,58.11 173.32,57.94 173.2,57.82 172.93,57.82 172.8,57.96 171.47,57.96 171.44,58 171.06,58 170,59.06 170,59.4 170.18,59.58 v2(170.47,59.58)
  TOP w0.14: JDIMM1.240 125.98,76.92 126.41,77.36 126.41,78.58 126.63,78.8 126.97,78.8 127.44,78.32 128.62,78.32 128.96,78.67 v2(128.96,79.28)
  IN1 w0.089: v2(170.47,59.58) 170.38,59.67 170.06,59.67 169.99,59.6 169.62,59.6 168.89,60.34 168.89,60.83
  IN1 w0.147: v2(128.96,79.28) 128.96,79.84 129.14,80.01 130.57,80.01 132.64,82.08 133.71,82.08 134.2,82.56 136.9,82.56 137.19,82.86 137.19,83.04 137.32,83.17 137.8,83.17 137.93,83.04 137.93,82.86 138.23,82.56 140.73,82.56 142.04,81.25 142.95,81.25 143.64,81.94 150.14,81.94 156.19,75.89 157.52,75.89 157.97,75.44 159.59,75.44 160.61,74.41 160.61,72.47 161.57,71.51 162.15,71.51 168.89,64.77 168.89,60.83
  BOTTOM w0.14: JDIMM2.240 131.82,76.92 131.77,76.97 131.77,77.11 131.72,77.17 131.38,77.17 130.32,78.22 130.32,79.16 129.64,79.84 128.71,79.84 128.61,79.73 128.61,79.64 128.77,79.48 128.77,79.35 128.84,79.28 v2(128.96,79.28)
DDR_A_DQS#8: length 66.4
  TOP w0.089: v2(166.74,32.16) 166.56,32.16 166.37,32.35 166.37,33.06 168.45,35.14 171.3,35.14 171.32,35.15 172.49,35.15 172.62,35.02 172.84,35.02 CPU1.BA3
  TOP w0.14: v2(128.57,37.77) 128.79,37.55 128.79,37.36 129.08,37.07 130.93,37.07 131.34,37.49 131.34,38.46 131.56,38.68 JDIMM1.95
  IN3 w0.17: v2(128.57,37.77) 128.87,37.48 128.87,37.15 129.3,36.72 137.16,36.72 137.25,36.62 141.88,36.62 147.22,31.28 159.26,31.28 159.61,31.62 159.61,32.22 159.78,32.39 160.29,32.39 160.46,32.22 160.46,31.62 160.8,31.28 161.56,31.28 161.9,31.62 161.9,32.15 162.08,32.32 162.59,32.32 162.76,32.15 162.76,31.62 163.1,31.28 163.44,31.28 164.36,30.35 166.07,30.35 166.98,31.27 166.98,31.8 166.74,32.05 v2(166.74,32.16)
  BOTTOM w0.14: v2(128.57,37.77) 128.66,37.69 128.81,37.69 129.02,37.9 129.02,38.07 128.85,38.24 126.46,38.24 125.79,38.92 125.57,38.92 125.33,38.68 JDIMM2.95
DDR_A_DRAMRST#: length 31.7
  TOP w0.102: RD6.2 CD122.1 107.29,40.45 107.2,40.55 CD92.1 107.96,40.93 v2(108.34,40.56) ; v2(122.43,43.7) 122.43,42.93 123.44,41.92 JDIMM1.108 125.46,41.92 v2(125.87,41.51)
  IN2 w0.127: v2(130.97,41.51) 130.97,41.51 130.39,42.1 126.45,42.1 v2(125.87,41.51) ; v2(108.34,40.56) 108.34,41.38 109.96,43.01 121.96,43.01 122.43,43.47 v2(122.43,43.7)
  BOTTOM w0.102: v2(130.97,41.51) 130.98,41.51 131.56,41.51 131.97,41.92 JDIMM2.108
DDR_A_MA0: length 65.5
  TOP w0.089: v2(167.33,44.04) 167.33,44.05 167.73,44.46 168.75,44.46 169.51,45.22 172.7,45.22 CPU1.AH3
  TOP w0.203: JDIMM1.144 125.91,50.92 126.47,51.48 127.95,51.48 128.08,51.61 128.08,52.03 127.95,52.15 127.61,52.15 127.48,52.28 127.48,52.7 127.61,52.83 128.19,52.83 128.31,52.95 128.31,53.36 128.3,53.37 v2(128.3,53.36)
  IN1 w0.089: v2(167.33,44.04) 166.92,44.45 164.79,44.45 164.58,44.24 161.52,44.24 161.23,44.52
  IN1 w0.208: v2(128.3,53.36) 128.3,53.36 128.29,53.35 128.78,53.84 130.08,53.84 130.14,53.78 146.11,53.78 152.96,46.92 153.14,46.92 153.44,47.21 153.61,47.21 154.02,46.8 154.02,46.62 153.73,46.33 153.73,46.15 154.14,45.74 154.32,45.74 154.66,46.08 154.84,46.08 155.21,45.7 155.21,45.52 154.88,45.19 154.88,45.02 155.07,44.83 155.64,44.83 155.92,45.11 156.24,45.11 156.52,44.83 160.93,44.83 161.23,44.52
  BOTTOM w0.203: JDIMM2.144 131.66,50.92 130.66,51.93 130.66,53.16 130,53.82 128.76,53.82 128.3,53.36 v2(128.3,53.36)
DDR_A_MA1: length 65.9
  TOP w0.089: CPU1.AP4 173.64,39.83 v2(173.96,39.5)
  TOP w0.203: v2(126.73,47.86) 126.73,47.95 127.66,48.88 131.18,48.88 131.88,48.17 JDIMM1.133
  IN1 w0.208: v2(173.96,39.5) 173.59,39.87 161.43,39.87 161.28,39.72 150.91,39.72 142.59,48.04 137.12,48.04 136.91,48.26 134.56,48.26 133.91,48.91 128.08,48.91 127.81,48.63 127.49,48.63 126.73,47.88 v2(126.73,47.86)
  BOTTOM w0.203: v2(126.73,47.86) 126.73,48.22 126.86,48.34 128.32,48.34 128.49,48.51 128.49,48.82 128.36,48.95 126.71,48.95 125.93,48.17 JDIMM2.133
DDR_A_MA2: length 65.1
  TOP w0.089: v2(173.31,41.13) 173.64,40.81 CPU1.AN4
  TOP w0.203: v2(130.06,49.64) 130.06,49.56 129.68,49.18 126.94,49.18 125.68,47.92 JDIMM1.132
  IN1 w0.208: v2(130.06,49.64) 130.23,49.46 134.14,49.46 134.75,48.85 137.1,48.85 137.35,48.6 142.82,48.6 151.14,40.27 172.6,40.27 172.72,40.4 172.72,41.26 172.6,41.38 171.9,41.38 171.77,41.51 171.77,43.61 171.9,43.73 172.61,43.73 172.74,43.61 172.74,42.27 172.86,42.15 173.18,42.15 173.31,42.02 v2(173.31,41.13)
  BOTTOM w0.203: v2(130.06,49.64) 130.28,49.41 130.28,48.98 130.61,48.65 131.31,48.65 132.03,47.92 JDIMM2.132
DDR_A_MA3: length 63.2
  TOP w0.089: v2(169.01,39.02) 169.42,39.44 172.99,39.44 173.32,39.76 173.32,40.11 173.49,40.29 174,40.29 174.29,40.01 CPU1.AP5
  TOP w0.203: v2(128,47.86) 128,47.91 128.66,48.57 131.05,48.57 131.95,47.68 JDIMM1.131
  IN1 w0.089: 163.55,39.57 169.05,39.57 169.18,39.45 169.18,39.15 169.05,39.02 v2(169.01,39.02)
  IN1 w0.208: v2(128,47.86) 128,47.88 128.48,48.35 133.6,48.35 134.66,47.29 136.2,47.29 136.25,47.34 142.51,47.34 150.68,39.17 161.94,39.17 162.35,39.57 163.55,39.57
  BOTTOM w0.203: JDIMM2.131 126.2,47.68 126.49,47.38 127.29,47.38 127.91,46.76 128.28,46.76 128.41,46.88 128.41,47.28 128.28,47.4 128.13,47.4 128,47.53 v2(128,47.86)
DDR_A_MA4: length 66.1
  TOP w0.089: CPU1.AP2 172.05,39.61 169.12,39.61 168.96,39.45 167.88,39.45 167.61,39.19 v2(167.61,39.02)
  TOP w0.203: JDIMM1.128 125.58,46.92 126.06,47.4 128.83,47.4 129.15,47.72 129.15,47.98 129.44,48.27 130.67,48.27 131.02,47.92 v2(131.02,47.8)
  IN1 w0.089: v2(167.61,39.02) 167.61,39.26 167.51,39.36 166.04,39.36 165.92,39.23 165.92,38.87
  IN1 w0.208: v2(131.02,47.8) 133.37,47.8 134.44,46.74 136.53,46.74 136.58,46.78 137.81,46.78 138.32,46.27 139.01,46.27 139.13,46.4 139.13,46.66 139.26,46.79 140.02,46.79 140.15,46.66 140.15,46.4 140.28,46.27 140.91,46.27 141.04,46.4 141.04,46.66 141.16,46.79 141.75,46.79 141.88,46.66 141.88,46.4 142,46.27 142.8,46.27 144.45,44.62 144.45,44.33 144.36,44.24 144.36,44.06 144.76,43.65 144.94,43.65 145.09,43.8 145.27,43.8 145.68,43.39 145.68,43.21 145.53,43.06 145.53,42.88 145.94,42.47 146.12,42.47 146.27,42.62 146.45,42.62 146.86,42.21 146.86,42.03 146.71,41.88 146.71,41.7 147.12,41.29 147.3,41.29 147.45,41.44 147.63,41.44 148.04,41.03 148.04,40.85 147.89,40.7 147.89,40.52 148.3,40.11 148.48,40.11 148.63,40.26 148.81,40.26 149.22,39.85 149.22,39.67 149.07,39.52 149.07,39.34 149.48,38.93 149.66,38.93 149.75,39.03 150.05,39.03 150.47,38.6 162.4,38.6 162.6,38.8 164.33,38.8 164.46,38.93 164.46,39.03 164.58,39.16 165.16,39.16 165.28,39.03 165.28,38.93 165.41,38.8 165.85,38.8 165.92,38.87
  BOTTOM w0.203: v2(131.02,47.8) 131.22,48 131.46,48 131.72,47.73 131.72,47.58 131.31,47.16 130.94,47.16 130.78,47.32 129.87,47.32 129.74,47.19 129.74,46.88 129.87,46.76 130.5,46.76 131.08,46.18 131.34,46.18 131.62,46.46 131.62,46.58 131.97,46.92 JDIMM2.128
DDR_A_MA5: length 63.5
  TOP w0.089: CPU1.AP1 168.95,39.9 168.75,39.7 167.57,39.7 166.98,39.11 v2(166.98,39)
  TOP w0.203: v2(129.65,47.72) 129.02,47.1 126.29,47.1 125.61,46.42 JDIMM1.126
  IN1 w0.089: v2(166.98,39) 167.14,39 167.26,38.87 167.26,38.04 167.14,37.92 166.83,37.92 166.7,38.04 166.7,38.22 166.39,38.54 162.79,38.54 162.31,38.05 160.67,38.05
  IN1 w0.208: 160.67,38.05 149.58,38.05 144.2,43.44 143.6,43.44 143.45,43.59 143.45,43.82 143.66,44.03 143.79,44.15 143.79,44.46 143.48,44.78 143.26,44.78 142.87,44.38 142.64,44.38 142.35,44.68 142.35,44.93 142.66,45.24 142.66,45.6 142.54,45.72 141.92,45.72 141.6,45.4 140.99,45.4 140.66,45.72 137.79,45.72 137.66,45.85 137.66,46.11 137.53,46.23 136.81,46.23 136.68,46.11 136.68,45.85 136.55,45.73 136.05,45.73 135.92,45.85 135.92,46.11 135.84,46.18 134.21,46.18 133.18,47.21 129.91,47.21 129.65,47.48 v2(129.65,47.72)
  BOTTOM w0.203: v2(129.65,47.72) 129.3,47.72 129.08,47.51 129.08,46.58 129.21,46.45 130.38,46.45 130.96,45.87 131.46,45.87 132.01,46.42 JDIMM2.126
DDR_A_MA6: length 66.9
  TOP w0.089: CPU1.AP3 172.71,40.18 167,40.18 165.92,39.1 165.92,38.06 v2(166.23,37.75)
  TOP w0.203: v2(126.72,45.64) 127.75,46.68 JDIMM1.127
  IN1 w0.089: v2(166.23,37.75) 166.26,37.75 166.39,37.88 166.39,38.17 166.26,38.29 162.84,38.29 162.05,37.5 160.67,37.5
  IN1 w0.208: 160.67,37.5 149.35,37.5 143.97,42.89 143.36,42.89 142.02,44.22 141.06,44.22 140.11,45.17 134.44,45.17 132.96,46.66 127.73,46.66 v2(126.72,45.64)
  BOTTOM w0.203: v2(126.72,45.64) 126.54,45.64 126.12,46.06 126.12,46.18 126.4,46.46 126.71,46.46 127.05,46.12 127.47,46.12 127.66,46.31 127.66,46.58 127.17,47.07 126.37,47.07 126.31,47.13 125.94,47.13 125.48,46.68 JDIMM2.127
DDR_A_MA7: length 65.4
  TOP w0.089: v2(164.32,37.75) 164.32,38.7 166.26,40.64 CPU1.AN1
  TOP w0.203: v2(129.43,45.63) 129.43,45.54 129.03,45.14 126.18,45.14 125.9,45.42 JDIMM1.122
  IN1 w0.208: v2(129.43,45.63) 129.23,45.43 129.23,45.24 129.5,44.98 132.3,44.98 133.76,43.52 133.76,43.52 134.2,43.07 134.42,43.07 134.55,42.94 134.55,42.82 134.68,42.69 135.4,42.69 135.59,42.89 135.59,43.39 135.72,43.52 136.29,43.52 136.42,43.39 136.42,42.85 136.54,42.72 137.12,42.72 137.25,42.85 137.25,43.39 137.38,43.52 137.96,43.52 138.08,43.39 138.08,42.85 138.21,42.72 138.79,42.72 138.92,42.85 138.92,43.39 139.04,43.52 139.42,43.52 139.79,43.14 139.79,42.86 139.97,42.68 140.26,42.68 140.58,42.36 140.58,42.13 140.84,41.86 141.14,41.86 141.45,42.18 141.73,42.18 142.08,41.83 142.08,41.63 141.67,41.22 141.67,41.04 146.86,35.85 147.95,35.85 148.19,36.09 148.43,36.09 148.67,35.85 162.78,35.85 164.32,37.39 v2(164.32,37.75)
  BOTTOM w0.203: v2(129.43,45.63) 129.39,45.63 129.26,45.76 129.26,46.02 129.39,46.15 130.25,46.15 130.55,45.85 130.55,45.1 130.71,44.94 131.44,44.94 131.93,45.42 JDIMM2.122
DDR_A_MA8: length 65.8
  TOP w0.089: CPU1.AN3 172.7,40.35 166.71,40.35 v1(165.49,39.14) 164.96,38.6 v2(164.96,37.75)
  TOP w0.203: JDIMM1.125 128.63,46.17 v2(128.08,45.63)
  IN1 w0.089: v2(164.96,37.75) 164.96,38.03 164.87,38.11 162.98,38.11 162.79,37.93 162.79,37.15 162.59,36.95 162.26,36.95 162.13,37.08 162.13,37.14 162.01,37.27 161.8,37.27 161.68,37.14 161.68,37.08 161.55,36.95 160.67,36.95
  IN1 w0.208: 160.67,36.95 149.12,36.95 146.11,39.96 145.82,39.96 145.46,39.6 145.28,39.6 144.87,40.01 144.87,40.19 145.23,40.55 145.23,40.85 144.87,41.2 144.58,41.2 143.99,40.61 143.69,40.61 143.4,40.91 143.4,41.2 143.99,41.79 143.99,42.09 143.74,42.33 143.46,42.33 143.4,42.27 143.19,42.27 142.82,42.65 141.8,43.67 140.83,43.67 139.88,44.62 134.22,44.62 132.73,46.1 128.13,46.1 127.96,45.94 127.96,45.75 v2(128.08,45.63)
  BOTTOM w0.203: v2(128.08,45.63) 128.19,45.63 128.3,45.52 128.3,45.27 128.14,45.12 126.57,45.12 126.21,45.48 125.85,45.48 125.73,45.6 125.73,46.05 125.6,46.17 JDIMM2.125
DDR_A_MA9: length 67
  TOP w0.089: v2(173.31,38.57) 173.64,38.24 CPU1.AT4
  TOP w0.203: v2(126.86,43.57) 127.83,44.53 129.5,44.53 130.14,45.17 JDIMM1.121
  IN1 w0.089: 168.97,38.31 170.17,38.31 171.25,39.39 172.95,39.39 173.31,39.03 v2(173.31,38.57)
  IN1 w0.208: v2(126.86,43.57) 126.86,44.02 127.26,44.43 132.07,44.43 133.53,42.97 134.42,42.08 135.48,42.08 135.57,42.17 139.76,42.17 146.63,35.3 162.75,35.3 164.69,37.23 166.82,37.23 167.9,38.31 168.97,38.31
  BOTTOM w0.203: v2(126.86,43.57) 126.86,43.84 127.05,44.02 128.35,44.02 128.47,44.15 128.47,44.69 128.35,44.81 126.44,44.81 126.08,45.17 JDIMM2.121
DDR_A_MA10: length 64.8
  TOP w0.089: v2(169.23,44.04) 169.83,44.64 172.04,44.64 CPU1.AH2
  TOP w0.203: v2(130.48,54.88) 130.48,54.78 129.82,54.12 126.18,54.12 125.49,53.43 JDIMM1.146
  IN1 w0.089: v2(169.23,44.04) 169.37,44.04 169.5,44.17 169.5,44.72 169.37,44.85 169.17,44.85 169.04,44.72 169.04,44.62 168.91,44.5 168.65,44.5 168.52,44.62 168.52,44.72 168.39,44.85 162.25,44.85 161.08,46.02 160.67,46.02
  IN1 w0.208: 160.67,46.02 156.98,46.02 156.58,46.41 156.11,46.41 153.87,48.65 153.57,48.65 153.3,48.38 153.12,48.38 152.71,48.79 152.71,48.97 153.04,49.3 153.04,49.48 152.63,49.89 152.45,49.89 152.1,49.54 151.92,49.54 151.51,49.95 151.51,50.13 151.86,50.48 151.86,50.66 151.45,51.07 151.27,51.07 150.92,50.72 150.74,50.72 150.33,51.13 150.33,51.3 150.68,51.66 150.68,51.84 150.27,52.25 150.09,52.25 149.74,51.89 149.56,51.89 149.56,51.89 146.58,54.88 130.49,54.88 v2(130.48,54.88)
  BOTTOM w0.203: JDIMM2.146 131.99,53.43 131.86,53.3 131.86,52.12 131.74,51.99 131.09,51.99 130.96,52.12 130.96,53.28 130.06,54.19 130.06,54.42 130.48,54.83 v2(130.48,54.88)
DDR_A_MA11: length 66.5
  TOP w0.089: v2(163.21,37.43) 163.21,38.02 166.16,40.97 v1(167.31,40.97) 172,40.97 CPU1.AN2
  TOP w0.203: JDIMM1.120 125.77,44.92 125.85,44.84 129.36,44.84 130.06,45.55 130.06,45.62 v2(130.09,45.65)
  IN1 w0.208: v2(163.21,37.43) 163.21,36.79 162.83,36.4 148.9,36.4 148.41,36.88 148.21,36.88 147.72,36.4 147.09,36.4 146.94,36.55 146.94,36.85 147.6,37.51 147.6,37.69 147.19,38.1 147.01,38.1 146.35,37.44 146.05,37.44 145.76,37.73 145.76,38.03 146.38,38.65 146.38,38.83 146.01,39.2 145.83,39.2 145.25,38.61 144.87,38.61 144.61,38.88 144.61,39.45 144.31,39.75 143.74,39.75 142.63,40.86 142.63,41.18 142.91,41.45 142.91,41.78 141.96,42.73 140.99,42.73 139.65,44.07 133.99,44.07 132.52,45.54 130.2,45.54 v2(130.09,45.65)
  BOTTOM w0.203: JDIMM2.120 132,44.92 131.6,44.52 129.15,44.52 129.02,44.65 129.02,45.05 129.15,45.17 129.94,45.17 130.06,45.3 130.06,45.62 v2(130.09,45.65)
DDR_A_MA12: length 65.4
  TOP w0.089: v2(169.84,36.84) 170.7,36.84 170.8,36.94 173.2,36.94 CPU1.AU4
  TOP w0.203: JDIMM1.119 130.07,44.68 129.63,44.23 128.64,44.23 128.21,43.8 v2(128.21,43.57)
  IN1 w0.089: v2(169.84,36.84) 169.85,36.82 169.85,36.22 169.07,35.43 166.28,35.43
  IN1 w0.208: v2(128.21,43.57) 128.21,43.24 128.08,43.11 127.69,43.11 127.56,42.98 127.56,42.64 127.69,42.51 128.38,42.51 128.5,42.64 128.5,42.74 128.63,42.87 129.02,42.87 129.15,42.74 129.15,42.64 129.28,42.51 131.6,42.51 133.04,41.07 133.04,39.95 134.62,38.36 134.62,38.36 135.07,37.91 138.64,37.91 143.86,32.69 162.75,32.69 165.49,35.43 166.28,35.43
  BOTTOM w0.203: v2(128.21,43.57) 127.75,43.11 126.66,43.11 126.34,43.43 126.34,44.48 125.96,44.86 125.72,44.86 125.53,44.68 JDIMM2.119
DDR_A_MA13: length 70.4
  TOP w0.089: CPU1.AE3 172.71,47.72 168.5,47.72 v2(167.33,46.55)
  TOP w0.203: JDIMM1.158 125.5,56.43 125.91,56.84 125.91,57.59 126.73,58.41 129.51,58.41 130.19,59.09 v2(130.19,59.2)
  IN1 w0.089: v2(167.33,46.55) 167.57,46.8 167.57,46.98 167.42,47.13 167.24,47.13 167.02,46.91 166.77,46.91 166.39,47.29 165.93,47.29 164.25,48.97 164.25,50.49 163.44,51.3 161.95,51.3
  IN1 w0.208: 161.95,51.3 160.24,51.3 157.11,54.43 156.42,54.43 151.94,58.91 149.38,58.91 147.73,60.56 143.44,60.56 143.31,60.69 143.31,61.02 143.19,61.15 142.61,61.15 142.48,61.02 142.48,60.69 142.35,60.56 141.77,60.56 141.65,60.69 141.65,61.01 141.52,61.14 140.94,61.14 140.81,61.01 140.81,60.41 140.44,60.04 140.16,60.04 139.74,60.46 139.4,60.46 138.98,60.04 137.72,60.04 137.4,60.36 136.89,60.36 136.57,60.04 135.53,60.04 135.45,60.12 134.12,60.12 133.95,59.95 133.95,59.56 133.59,59.2 133.22,59.2 133.09,59.32 133.09,60.03 132.96,60.16 132.38,60.16 132.26,60.03 132.26,59.32 132.13,59.2 v2(130.19,59.2)
  BOTTOM w0.203: JDIMM2.158 131.92,56.43 131.69,56.66 131.69,57.61 131.56,57.74 130.16,57.74 130.04,57.87 130.04,58.3 130.16,58.43 131.09,58.43 131.22,58.55 131.22,59.07 131.09,59.2 v2(130.19,59.2)
DDR_A_MA14: length 68.3
  TOP w0.089: v2(173.94,46.14) 173.64,45.84 CPU1.AG4
  TOP w0.203: JDIMM1.151 131.9,54.68 131.66,54.91 131.66,55.14 131.03,55.78 131.03,56.07 131.18,56.22 131.18,56.89 130.79,57.29 130.79,57.37 130.42,57.74 130.07,57.74 129.95,57.61 129.95,57.15 130.07,57.02 130.24,57.02 130.62,56.65 v2(130.62,56.49)
  IN1 w0.208: v2(173.94,46.14) 173.94,45.05 174.14,44.85 175.07,44.85 175.28,45.05 175.28,46.71 174.96,47.02 174.32,47.02 174.08,46.78 172.65,46.78 171.52,45.65 164.09,45.65 162.05,47.69 158.22,47.69 154.73,51.17 153.69,51.17 149.51,55.35 148.47,55.35 147.28,56.55 130.68,56.55 v2(130.62,56.49)
  BOTTOM w0.203: v2(130.62,56.49) 130.62,56.42 130.24,56.04 129.19,56.04 128.53,55.39 126.08,55.39 125.37,54.68 JDIMM2.151
DDR_A_MA15: length 67.6
  TOP w0.089: v2(165.42,46.55) 167.2,48.33 171.53,48.33 CPU1.AD1
  TOP w0.203: JDIMM1.156 125.6,55.92 126.11,56.43 127.25,56.43 127.7,56.88 v2(127.7,56.97)
  IN1 w0.089: v2(165.42,46.55) 165.42,47.26 163.89,48.79 163.89,49.55 163.22,50.23 161.95,50.23
  IN1 w0.208: v2(127.7,56.97) 127.14,57.52 127.14,57.84 127.43,58.12 127.87,58.12 128.21,57.78 128.47,57.78 128.81,58.12 133.59,58.12 134.04,58.12 134.52,58.61 136.13,58.61 136.49,58.97 140.88,58.97 141.41,59.49 147.29,59.49 149.31,57.46 150.18,57.46 150.56,57.84 151.14,57.84 151.34,57.64 151.34,57.46 151.17,57.3 151.17,57.12 151.52,56.77 151.7,56.77 152.04,57.11 152.22,57.11 152.63,56.7 152.63,56.52 152.28,56.17 152.28,55.99 152.69,55.58 152.87,55.58 153.22,55.93 153.4,55.93 153.81,55.52 153.81,55.35 153.47,55 153.47,54.82 153.88,54.41 154.06,54.41 154.4,54.76 154.58,54.76 154.99,54.35 154.99,54.17 154.72,53.9 154.72,53.6 154.96,53.36 156.67,53.36 159.8,50.23 161.95,50.23
  BOTTOM w0.203: v2(127.7,56.97) 128.04,57.31 130.92,57.31 131.38,56.85 131.38,56.38 131.84,55.92 JDIMM2.156
DDR_A_MA16: length 62.9
  TOP w0.089: CPU1.AH4 173.34,45.22 173.34,46.08 v2(173.29,46.14)
  TOP w0.203: v2(129.41,56.53) 127.96,56.53 127.5,56.07 126.53,56.07 125.39,54.92 JDIMM1.152
  IN1 w0.089: 163.13,46.06 163.85,45.34 171.95,45.34 172.2,45.09 172.99,45.09 173.29,45.39 v2(173.29,46.14)
  IN1 w0.208: 163.13,46.06 162.06,47.13 157.99,47.13 155.51,49.61 155.25,49.61 154.95,49.31 154.77,49.31 154.35,49.73 154.35,49.96 154.61,50.22 154.61,50.45 154.45,50.62 153.47,50.62 149.28,54.8 148.24,54.8 147.06,55.98 129.9,55.98 129.41,56.47 v2(129.41,56.53)
  BOTTOM w0.203: JDIMM2.152 131.66,54.92 131.08,55.51 131.08,56.73 130.8,57.01 129.44,57.01 129.31,56.88 129.31,56.63 v2(129.41,56.53)
DDR_A_ODT0: length 64.7
  TOP w0.089: v2(166.69,46.55) 166.69,46.72 v1(167.92,47.95) 171.38,47.95 171.43,47.9 172.7,47.9 CPU1.AD3
  IN1 w0.089: 161.95,50.76 163.24,50.76 164.07,49.94 164.07,48.89 165.92,47.05 166.2,47.05 v2(166.69,46.55)
  IN1 w0.178: 161.95,50.76 160.02,50.76 156.89,53.9 156.2,53.9 151.72,58.37 149.16,58.37 147.51,60.02 141.18,60.02 140.66,59.5 135.33,59.5 135.24,59.59 134.74,59.59 133.81,58.66 126.18,58.66 125.94,58.41 125.94,57.43 v2(126.44,56.92)
  BOTTOM w0.165: JDIMM2.155 125.62,55.68 125.86,55.92 128.32,55.92 128.72,56.32 128.72,56.5 128.43,56.78 128.25,56.78 127.91,56.44 126.15,56.44 126.03,56.56 126.03,56.8 126.16,56.92 v2(126.44,56.92)
DDR_A_ODT1: length 63
  TOP w0.089: v2(173.34,48.58) 173.34,48 173.64,47.71 CPU1.AE4
  IN1 w0.089: v2(173.34,48.58) 173.02,48.26 166.03,48.26 164.99,49.3 164.99,51.01 162.72,53.28 161.95,53.28
  IN1 w0.178: 161.95,53.28 161.06,53.28 157.93,56.42 157.24,56.42 152.77,60.89 150.27,60.89 147.62,63.55 141.26,63.55 140.85,63.13 133.26,63.13 132.3,62.18 131.6,62.18 130.6,61.18 126.89,61.18 126.6,60.89 126.6,60.66 126.76,60.5 127.18,60.5 v2(127.38,60.7)
  BOTTOM w0.165: v2(127.38,60.7) 127.39,60.68 127.39,60.28 125.8,58.69 125.8,57.46 125.52,57.17 JDIMM2.161
DDR_A_ODT2: length 67.4
  TOP w0.089: v2(168.6,46.55) 169.49,47.44 CPU1.AE1
  TOP w0.165: v2(128.92,59.14) 128.92,59.7 129.29,60.07 130.04,60.07 130.71,59.39 130.71,58.87 130.44,58.6 130.44,58.4 130.59,58.25 130.68,58.25 131.44,57.49 131.44,57.38 131.71,57.11 131.71,55.84 131.87,55.68 JDIMM1.155
  IN1 w0.089: 161.95,51.84 163.25,51.84 164.43,50.66 164.43,49.04 165.94,47.53 166.6,47.53 166.69,47.44 166.69,47.24 166.8,47.13 166.95,47.13 167.05,47.24 167.05,47.49 167.15,47.59 167.3,47.59 167.5,47.39 167.71,47.39 167.85,47.53 168.03,47.53 168.6,46.96 v2(168.6,46.55)
  IN1 w0.178: 161.95,51.84 160.46,51.84 157.33,54.97 156.64,54.97 152.17,59.45 149.67,59.45 148.02,61.1 145.32,61.1 145.03,61.39 144.61,61.39 144.32,61.1 143.94,61.1 143.81,61.22 143.81,61.56 143.68,61.68 140.42,61.68 140.29,61.56 140.29,61.12 140.16,60.99 139.7,60.99 139.58,61.12 139.58,61.56 139.45,61.68 138.99,61.68 138.87,61.56 138.87,61.07 138.74,60.94 138.28,60.94 138.15,61.07 138.15,61.56 138.03,61.68 137.6,61.68 137.47,61.56 137.47,61.02 137.34,60.89 136.92,60.89 136.8,61.02 136.8,61.56 136.67,61.68 136.48,61.68 135.96,61.16 135.53,61.16 135.4,61.03 135.4,60.79 135.23,60.62 134.65,60.62 134.48,60.79 134.48,61.11 134.36,61.24 133.74,61.24 133.61,61.11 133.61,60.85 133.45,60.69 132.16,60.69 131.72,60.25 131.72,59.88 131.57,59.73 128.36,59.73 128.23,59.61 128.23,59.27 128.36,59.14 v2(128.92,59.14)
DDR_A_ODT3: length 70.5
  TOP w0.089: v2(169.87,46.55) 169.87,46.85 169.94,46.92 170.29,46.92 170.38,46.83 170.38,46.32 170.46,46.23 170.64,46.23 170.73,46.32 170.73,46.83 170.82,46.92 172.3,46.92 172.39,47.01 172.39,47.08 172.48,47.17 172.66,47.17 172.75,47.08 172.75,47.01 172.84,46.92 173.01,46.92 173.1,47.01 173.1,47.12 173.2,47.22 173.35,47.22 173.45,47.12 173.45,47.01 173.54,46.92 173.68,46.92 173.96,47.2 173.96,47.64 173.64,47.97 CPU1.AD4
  TOP w0.165: v2(130.15,60.7) 130.15,60.32 130.43,60.05 130.53,60.05 130.63,60.15 130.81,60.15 131.1,59.86 131.1,59.68 130.98,59.56 130.98,59.31 131.1,59.19 131.34,59.19 131.53,59 131.53,58.71 131.41,58.58 131.17,58.58 131.07,58.48 131.07,58.24 131.34,57.97 131.58,57.97 131.71,57.85 131.71,57.61 131.71,57.6 131.71,57.49 132.02,57.17 JDIMM1.161
  IN1 w0.089: 161.95,52.8 162.91,52.8 164.81,50.9 164.81,49.16 165.93,48.04 168.38,48.04 169.35,47.07 169.77,47.07 170.46,47.77 170.73,47.77 171.17,47.33 171.17,47.16 170.57,46.55 v2(169.87,46.55)
  IN1 w0.178: v2(130.15,60.7) 130.8,60.7 131.8,61.69 132.82,61.69 133.1,61.97 133.1,62.29 133.46,62.65 133.66,62.65 133.79,62.52 133.79,62.33 133.91,62.2 134.43,62.2 134.55,62.33 134.55,62.52 134.68,62.65 141.65,62.65 141.77,62.78 141.77,62.94 141.9,63.06 142.36,63.06 142.48,62.94 142.48,62.78 142.61,62.65 143.07,62.65 143.19,62.78 143.19,62.94 143.32,63.06 143.78,63.06 143.91,62.94 143.91,62.83 144.38,62.35 144.56,62.35 144.68,62.48 144.68,62.94 144.81,63.06 145.27,63.06 145.39,62.94 145.39,62.38 145.56,62.22 145.98,62.22 146.11,62.35 146.11,62.94 146.23,63.06 146.69,63.06 146.82,62.94 146.82,62.19 146.94,62.06 147.4,62.06 147.53,62.19 147.53,62.52 147.65,62.65 147.83,62.65 150.07,60.41 152.57,60.41 157.04,55.93 157.73,55.93 160.86,52.8 161.95,52.8
DDR_A_PARITY: length 77.4
  TOP w0.089: CPU1.AG3 172.71,45.39 168.9,45.39 168.81,45.3 168.81,44.78 168.71,44.68 168.56,44.68 168.46,44.78 168.46,45.43 168.35,45.53 168.2,45.53 168.07,45.4 v1(168.07,45.21) 168.07,44.79 167.96,44.68 167.81,44.68 167.7,44.79 167.7,45.38 167.58,45.5 167.4,45.5 167.27,45.38 167.27,44.68 167.14,44.56 166.57,44.56 166.45,44.43 166.45,44.17 166.57,44.04 v2(166.69,44.04)
  TOP w0.203: JDIMM1.143 131.62,50.68 131.38,50.91 131.38,51.4 131.51,51.53 133.51,51.53 133.64,51.66 133.64,52.33 133.51,52.46 130.63,52.46 130.5,52.33 130.5,51.56 130.38,51.43 129.71,51.43 129.56,51.58 129.56,53.16 129.73,53.34 v2(129.73,53.36)
  IN1 w0.089: v2(166.69,44.04) 166.77,44.04 166.9,43.91 166.9,43.71 166.77,43.58 165.7,43.58 165.62,43.66 165.62,44.06 165.49,44.19 164.99,44.19 164.79,43.99 160.94,43.99 160.67,44.27
  IN1 w0.208: v2(129.73,53.36) 129.73,53.34 129.85,53.22 133.7,53.22 134.08,52.85 136.22,52.85 136.58,53.21 145.89,53.21 154.84,44.27 160.67,44.27
  BOTTOM w0.203: JDIMM2.143 125.5,50.68 125.59,50.77 125.59,51.31 125.76,51.47 127.85,51.47 127.98,51.6 127.98,52.67 128.13,52.83 128.55,52.83 128.7,52.67 128.7,51.59 128.82,51.47 130.1,51.47 130.2,51.56 130.2,51.95 130.07,52.08 129.53,52.08 129.37,52.24 129.37,52.56 129.53,52.73 130.07,52.73 130.2,52.85 130.2,53.19 130.07,53.31 129.78,53.31 v2(129.73,53.36)
DDR_B_ACT#: length 79.4
  TOP w0.089: CPU1.AT9 v2(177.22,38.74)
  TOP w0.203: JDIMM3.114 111.98,43.42 112.5,42.91 114.81,42.91 115.11,42.61 v2(115.11,42.45)
  IN4 w0.089: v2(177.22,38.74) 176.86,39.1 175.77,39.1 175.52,38.84 175.52,38.44 174.53,37.45 173.94,36.86 170.49,36.86 169.46,35.83 165.42,35.83 162.86,33.28 162.56,33.28
  IN4 w0.208: 162.56,33.28 143.79,33.28 142.88,34.19 139.15,37.91 133.92,37.91 133.57,38.26 126.18,38.26 125.59,38.85 124.06,38.85 123.88,39.03 122.28,39.03 121.81,39.5 121.81,39.5 121.8,39.5 118.68,39.5 118.45,39.74 118.45,40.15 116.86,41.74 115.97,41.74 115.87,41.84 115.73,41.84 v2(115.11,42.45)
  BOTTOM w0.203: JDIMM4.114 117.69,43.42 117.06,42.8 117.06,42.17 116.89,42 115.57,42 115.57,41.99 v2(115.11,42.45)
DDR_B_ALERT#: length 76.1
  TOP w0.089: CPU1.AR8 v2(176.57,39.65)
  TOP w0.102: JDIMM3.116 111.84,43.92 112.61,43.16 115.38,43.16 v2(115.7,43.48)
  IN4 w0.089: 162.69,34.93 163.21,34.93 164.9,36.62 167.31,36.62 168.47,37.78 173.12,37.78 173.79,38.45 173.97,38.45 174.58,39.06 174.88,39.06 174.96,39.14 174.96,39.22 175.76,40.03 176.08,40.03 176.45,39.65 v2(176.57,39.65)
  IN4 w0.208: v2(115.7,43.48) 115.71,43.47 117.47,43.47 119.78,41.16 124.36,41.16 125.01,40.5 129.7,40.5 130.21,39.99 139.42,39.99 144.48,34.93 162.69,34.93
  BOTTOM w0.203: JDIMM4.116 117.66,43.92 117.19,43.45 115.73,43.45 v2(115.7,43.48)
DDR_B_BA0: length 80.5
  TOP w0.089: CPU1.AH8 v2(176.57,45.14)
  TOP w0.203: v2(115.38,54.7) 114.76,54.08 112.45,54.08 112.1,54.43 JDIMM3.150
  IN4 w0.089: v2(176.57,45.14) 176.52,45.14 176.03,45.64 175.21,45.64 175.16,45.58 175.16,45.46 175.1,45.4 172.11,45.4 172.05,45.46 172.05,45.61 171.91,45.75 164.57,45.75 163.51,46.81 163.13,46.81 163.02,46.92 163.02,47.3
  IN4 w0.208: 163.02,47.3 162.64,47.69 154.01,47.69 148.22,53.48 143.48,53.48 143.21,53.21 142.86,53.21 142.6,53.48 142.11,53.48 141.89,53.26 141.19,53.26 140.97,53.48 139.83,53.48 137.81,55.49 133.65,55.49 133.48,55.66 133.48,56.04 133.09,56.43 132.53,56.43 132.28,56.18 131.83,56.18 131.58,56.43 131.17,56.43 131.04,56.31 131.04,56.03 130.92,55.91 129.26,55.91 129.01,56.16 129.01,56.31 128.88,56.43 128.61,56.43 128.41,56.24 128.41,56 128.32,55.91 125.73,55.91 125.18,55.35 125.05,55.35 124.93,55.24 124.93,55.11 124.81,54.98 124.38,54.98 124.25,55.11 124.25,55.23 124.12,55.36 123.63,55.36 123.5,55.23 123.5,55.11 123.38,54.98 120.99,54.98 120.74,55.24 115.53,55.24 115.38,55.08 v2(115.38,54.7)
  BOTTOM w0.203: JDIMM4.150 117.4,54.43 117.2,54.62 117.2,54.87 116.59,55.48 116.16,55.48 116.04,55.35 115.32,55.35 115.15,55.18 115.15,54.94 v2(115.38,54.7)
