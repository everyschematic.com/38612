# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 23.2
  TOP w0.508: v2(241.34,140.04) R574.2 R572.2 ; R573.2 R571.2 v2(250.87,139.35) ; v2(254.11,133.56) 255.55,132.12 C485.2
  BOTTOM w0.762: v2(241.34,140.04) v1(242.1,140.04) 245.22,140.04 245.9,139.35 v2(250.87,139.35) 251.76,138.46 251.76,135.91 v2(254.11,133.56)
GNDA_CHG: length 11.1
  TOP w0.381: PR718.2 272.83,38.51 273.18,38.16 273.18,37.9 273.66,37.43 PR720.2
  TOP w0.508: v2(271.04,39.01) 270.81,38.77 PC721.1 271.31,38.39 271.44,38.51 PC711.2 PR718.2 ; v2(276.71,29.36) 277.17,28.9 v1(277.17,28.37) 276.83,28.04 PC712.1 ; PC720.1 v2(267.84,36.1) 267.31,36.1 266.7,35.48 PR744.2 ; v2(272.41,28.53) 272.9,28.04 PC713.2
  vias: v2(271.3,35.01) v2(271.36,34.37) v2(272.19,33.55) v2(272.19,31.77) v2(273.08,32.66) v2(273.86,33.55) v2(273.86,31.77)
VCC_EDRAM_SENSE: length 128.3
  TOP w0.089: v2(181.68,27.01) 181.35,27.34 CPU1.BL15
  TOP w0.254: PR506.1 71.5,13.19 71.5,13.63 71.5,15.61 72.73,16.85 v1(74.05,16.85) 90.68,16.85 91.8,15.72 91.8,13.72 v2(91.84,13.68)
  BOTTOM w0.089: v2(181.68,27.01) 181.27,26.6 181.27,26.23 180.91,25.86 180.32,25.86 178.99,24.53 170.5,24.53 167.94,21.97 v1(163.36,21.97) 160.79,21.97 160.71,22.05 160.67,22.05
  BOTTOM w0.254: v2(91.84,13.68) 91.76,13.61 91.76,12.91 94.36,10.31 106.53,10.31 107.74,11.51 144.25,11.51 145.71,12.97 145.71,17.44 150.33,22.05 160.67,22.05
VCC_EDRAM_SENSE_ED2: length 16.1
  TOP w0.254: CPU1.BL22 186.88,27.34 v2(187.18,27.04)
  TOP w0.508: RC174.2 184.63,16.27 184.87,16.5 v1(184.87,16.81) 184.87,17.24 184.5,17.61 v2(183.75,17.61)
  IN3 w0.089: 185.94,17.89 187.18,19.13 187.18,23.58 187.55,23.96 187.55,26.67 v2(187.18,27.04)
  IN3 w0.127: 185.94,17.89 185.65,17.61 v2(183.75,17.61)
VCC_EOPIO_SENSE: length 149.4
  TOP w0.254: PR1806.1 53.46,13.22 v2(53.45,13.23) ; CPU1.BN15 181.22,26.04 v2(180.89,26.36)
  IN3 w0.254: v2(53.45,13.23) 54.02,13.23 54.97,14.18 55.99,14.18 56.59,13.58 57.54,13.58 58.09,14.12 65.98,14.12 68.2,16.34 91.49,16.34 94.7,13.13 106.82,13.13 109.88,10.06 133.66,10.06 134.94,8.78 136.69,8.78 141.08,13.16 154.2,13.16 154.9,12.47 162.27,12.47 164.35,10.39 171.13,10.39 174.42,13.67 177.43,13.67 180.75,17 180.75,21.58 181.91,22.73 181.91,25.35 v2(180.89,26.36)
VCC_EOPIO_SENSE_ED3: length 14.3
  TOP w0.254: RC176.2 183.65,12.03 183.75,12.12 v2(183.75,12.72) ; CPU1.BP17 183.29,24.96 183.29,23.97 183.19,23.87 183.19,21.67 v2(182.62,21.1)
  IN3 w0.089: 182.62,17.89 v2(182.62,21.1)
  IN3 w0.127: v2(183.75,12.72) 183.75,16.34 182.62,17.46 182.62,17.89
VCC_IO_SENSE: length 232.8
  TOP w0.089: v2(180.34,60.49) 180.35,60.49 CPU1.H14
  TOP w0.254: PR314.2 330.24,24.53 329.71,25.06 v2(329.71,25.17)
  IN3 w0.254: v2(180.34,60.49) 180.56,60.26 186.42,60.26 186.97,59.71 187.08,59.71 187.08,59.7 191.8,59.7 191.85,59.65 192.12,59.65 192.89,58.88 192.89,57.78 193.49,57.18 197.18,57.18 197.83,57.83 197.83,59.59 198.35,60.1 206.24,60.1 209.08,62.95 209.81,62.95 212.62,65.76 214.98,65.76 219.61,70.38 222.53,70.38 222.99,70.84 222.99,77.04 225.57,79.62 231.07,79.62 236.5,74.19 237.6,74.19 237.91,73.87 240.69,73.87 242.61,75.8 242.61,77.19 243.69,78.27 243.69,78.81 244.21,79.33 245.22,79.33 246.23,78.32 246.23,78.1 246.91,77.43 246.91,75.09 249.84,72.16 249.84,62.07 252.9,59.01 259.54,59.01 262.36,56.19 262.36,54.84 263.88,53.31 263.88,51.22 267.71,47.39 270.22,47.39 276.97,40.65 276.97,37.55 275.86,36.44 275.86,33.93 275.25,33.32 275.25,30.71 275.58,30.38 275.58,28.06 274.36,26.84 274.36,22.86 273.46,21.96 273.46,18.37 274.73,17.1 282.05,17.1 282.67,17.72 291.54,17.72 292.34,18.52 298.26,18.52 301.11,15.68 307.51,15.68 312.26,20.43 312.26,20.71 313.25,21.7 325.66,21.7 329.13,25.17 v2(329.71,25.17)
VCC_SA_SENSE: length 83.1
  TOP w0.254: v2(257.12,55.29) 256.9,55.07 256.9,54.88 257.71,54.07 259.3,54.07 259.66,53.72 261.34,53.72 PR1108.1 ; PR1111.2 200.13,56.79 199.41,57.51 v2(199.08,57.51) 198.96,57.39 CPU1.M38
  IN3 w0.254: v2(257.12,55.29) 256.71,54.88 249.62,54.88 249.09,55.42 249.09,55.63 249.09,56.27 244.45,60.9 244.45,69.2 243.87,69.78 236.69,69.78 235.38,68.47 231.19,68.47 230.79,68.07 230.78,68.07 230,67.28 229.79,67.28 225.14,67.28 218.6,60.74 208.85,60.74 205.62,57.51 v2(199.08,57.51)
VCC_SENSE: length 84.2
  TOP w0.089: v2(197.99,45.18) 197.66,45.5 CPU1.AG37
  IN2 w0.254: v2(215.35,42.63) 215.42,42.69 220.83,42.69 223.86,45.73 223.86,55.63 226.17,57.93 231.8,57.93 232.62,57.11 236.58,57.11 237.09,57.61 238.51,57.61 239.53,56.6 239.78,56.6 241.37,55.01 241.37,54.15 243.75,51.77 v2(247.54,51.77)
  IN3 w0.089: v2(197.99,45.18) 197.99,45.16 198.35,44.79 198.95,44.79 199.77,43.96 199.9,43.96
  IN3 w0.254: 199.9,43.96 201.45,43.96 201.86,43.56 203.51,43.56 204.22,42.84 205.5,42.84 207.5,44.85 208.05,44.85 208.68,44.22 212.11,44.22 213.64,42.69 215.29,42.69 v2(215.35,42.63)
  BOTTOM w0.254: PR1119.2 216,42.37 RC221.2 215.62,42.36 v2(215.35,42.63) ; PR1121.1 258.85,51.33 257.53,52.65 256.56,52.65 v1(256.21,53) 254.83,54.38 251.38,54.38 248.78,51.77 v2(247.54,51.77)
VCCGT_SENSE: length 81.7
  TOP w0.089: 199.9,44.41 198.65,44.41 v2(198.64,44.39) 198.31,44.71 CPU1.AH38
  TOP w0.254: PR1126.2 261.57,36.7 261.57,35.66 262,35.23 263.05,35.23 264.92,33.35 v1(264.92,32.06) v2(264.92,31.52) ; PR1124.1 199.9,44.41
  IN1 w0.089: v2(198.64,44.39) 199.09,43.94 199.78,43.94 199.86,44.03 199.9,44.03
  IN1 w0.254: 199.9,44.03 203.71,44.03 204.51,43.23 205.71,43.23 207.49,41.45 207.89,41.45 208.37,41.93 214.77,41.93 215.8,40.9 217.37,39.33 225.51,39.33 226.15,38.69 230.01,38.69 231.3,37.4 234.58,37.4 236.04,35.93 248.54,35.93 251.23,33.24 254.91,33.24 255.8,32.35 258.98,32.35 259.34,31.99 261.55,31.99 261.82,31.71 264.73,31.71 v2(264.92,31.52)
VCCGTX_SENSE: length 127.7
  TOP w0.089: v2(197.33,44.39) 197.01,44.71 CPU1.AH36
  TOP w0.254: v2(266.38,21.23) 266.36,21.21 266.36,21.06 266.17,20.86 PC1640.1 265.55,21.29 265.82,21.56 265.82,21.89 ; 265.82,21.89 v1(265.83,21.89) ; 265.82,21.89 264.83,21.89 PC1627.2 264.69,21.75 PR1618.1 ; v2(205.11,44.41) 205.07,44.44 PR1621.2
  IN4 w0.089: 199.9,44.41 199.16,44.41 198.78,44.79 197.73,44.79 v2(197.33,44.39)
  IN4 w0.254: 199.9,44.41 201.09,44.41 201.41,44.09 203.36,44.09 203.68,44.41 v2(205.11,44.41) 205.21,44.41 206.48,43.14 206.48,42.59 207.52,41.55 208.2,41.55 208.45,41.8 210.59,41.8 211.85,40.54 220.76,40.54 221.88,39.42 225.81,39.42 226.55,38.68 229.94,38.68 231.24,37.38 231.24,17.22 231.87,16.59 234.27,16.59 234.95,17.27 236.34,17.27 236.98,16.63 239.58,16.63 241.21,18.25 241.21,25.03 245.47,29.29 245.47,31.6 252.03,38.16 259.24,38.16 262.16,35.24 262.16,32.8 261.66,32.3 261.66,29.97 264.44,27.19 264.44,22.94 266.36,21.02 266.36,21.21 v2(266.38,21.23)
VCCST_PWRGD: length 127.6
  TOP w0.102: v2(218.35,106.27) 218.96,106.27 219.29,106.6 UC6.4 ; RC159.1 RC164.1 157.75,68.27 162.28,72.81 162.28,74.05 v2(163.12,74.88)
  IN4 w0.109: v2(191.54,112.81) 191.79,112.81 192.33,113.35 193.96,113.35 194.1,113.22 197.46,113.22 198.19,113.94 198.19,114.62 199.39,115.83 204.77,115.83 205.49,116.55 208.71,116.55 210,115.26 210.79,115.26 211.09,115.56 212.08,115.56 213.68,113.96 214.38,113.96 214.51,114.1 218.6,114.1 219.43,113.27 219.43,111.08 219.64,110.87 219.64,107.24 218.79,106.39 218.47,106.39 v2(218.35,106.27)
  BOTTOM w0.102: v2(163.12,74.88) 163.3,75.06 163.3,75.84 163.03,76.11 163.03,78.01 165.03,80 172.99,80 174.84,81.85 183.26,81.85 185.95,84.54 188.89,84.54 191.62,87.27 205.57,87.27 208.56,90.26 208.56,90.45 v1(209.03,90.92) 210.07,91.97 212.83,91.97 213.55,92.69 213.55,95.74 213.56,95.74 213.56,96.79 214.81,98.05 214.81,98.94 215.28,99.42 215.28,100.6 215.69,101.01 215.69,101.39 216.87,102.57 216.87,102.94 217.31,103.38 217.73,103.38 218.24,103.89 218.24,105.61 218.35,105.71 v2(218.35,106.27) ; R43.2 191.85,112.51 v2(191.54,112.81)
VCCST_PWRGD_CPU: length 37.6
  TOP w0.102: RC159.2 155.88,67.13 155.73,67.28 v1(155.73,67.43) 155.73,67.76 156.52,68.55 157.45,68.55 v2(161.79,72.89)
  TOP w0.203: v2(179.55,60.49) 179.92,60.11 CPU1.H13
  BOTTOM w0.089: 167.92,66.83 170.17,66.83 170.35,67.01 170.35,67.46 170.79,67.9 171.75,67.9 172,67.65 172,65.29 172.51,64.78 175.88,64.78 177.59,63.08 177.59,61.62 178.34,60.86 179.17,60.86 v2(179.55,60.49)
  BOTTOM w0.102: 167.92,66.83 166.21,66.83 161.79,71.25 v2(161.79,72.89)
VCCST_PWRGD_EC: length 2
  BOTTOM w0.102: U51.A44 194.28,112.86 193.93,112.51 R43.1
VDD_1.2V: length 10.3
  TOP w0.508: v2(61.14,22.42) 61.14,21.76 v1(59.66,20.29) 58.98,19.6 v2(58.25,19.6)
  BOTTOM w0.254: PU200.11 58.98,19.27 58.65,19.6 v2(58.25,19.6) ; v2(61.14,22.42) 61.14,22.21 60.29,21.37 PR201.1
  BOTTOM w0.508: PR203.2 PC210.1 57,20.21 57.61,19.6 v2(58.25,19.6)
VDDP_1.2V: length 8.2
  BOTTOM w0.102: PR210.1 59.21,22.6 59.64,23.03 61.73,23.03 v1(63,21.76)
  BOTTOM w0.254: PR210.1 PC213.1 59.38,20.74 PU200.12
VIN_EDRAMP: length 3
  TOP w0.102: v1(67.44,12.44) 68.42,11.46 68.81,11.46 PL500.2
VIN_EOPIOP:
  vias: v1(54.26,9.52)
VSS_EDRAM_SENSE: length 127.2
  TOP w0.203: v2(181.68,26.36) 182.01,26.69 CPU1.BM16
  TOP w0.254: PR508.1 72,13.14 72,13.84 72,13.84 72,15.4 72.94,16.34 90.47,16.34 91.29,15.51 91.29,13.72 v2(91.25,13.68)
  BOTTOM w0.089: 160.67,21.55 160.71,21.55 160.79,21.63 v1(165.4,21.63) 168.08,21.63 170.64,24.19 179.13,24.19 180.46,25.52 181.05,25.52 181.68,26.15 v2(181.68,26.36)
  BOTTOM w0.254: 160.67,21.55 150.54,21.55 146.22,17.23 146.22,12.76 144.46,11 107.95,11 106.74,9.8 94.15,9.8 91.25,12.7 v2(91.25,13.68)
VSS_EDRAM_SENSE_ED2: length 12.9
  TOP w0.089: CPU1.BM22 186.86,26.69 v2(187.19,26.36)
  TOP w0.508: RC223.2 182.44,17.03 v2(183.05,17.63)
  IN3 w0.089: v2(187.19,26.36) 187.18,26.34 187.18,24.66 186.48,23.96 186.48,20.73 185.81,20.06 185.8,20.06 185.59,19.85 185.59,19.84 183.96,18.21 183.46,18.21 183.14,17.89
  IN3 w0.127: 183.14,17.89 183.05,17.8 v2(183.05,17.63)
VSS_EOPIO_SENSE: length 153.6
  TOP w0.254: v2(180.89,27.01) 181.22,26.69 CPU1.BM15 ; PR1808.1 54.5,12.99 v2(54.77,13.25)
  IN3 w0.254: v2(180.89,27.01) 181.97,28.09 183.43,28.09 183.75,27.77 183.75,26.18 182.29,24.72 182.29,22.63 181.13,21.47 181.13,16.84 177.59,13.29 174.58,13.29 171.29,10.01 164.17,10.01 162.09,12.09 154.56,12.09 153.87,12.78 141.23,12.78 136.85,8.4 134.78,8.4 133.5,9.68 109.72,9.68 106.66,12.75 94.36,12.75 91.28,15.83 68.23,15.83 66.14,13.74 58.34,13.74 57.76,13.16 56.43,13.16 55.8,13.8 55.31,13.8 v2(54.77,13.25)
VSS_EOPIO_SENSE_ED3: length 14.7
  TOP w0.089: CPU1.BN16 182.14,26.04 182.35,25.83 182.35,22.89 181.8,22.34 v1(181.8,18.31) 181.8,17.89
  TOP w0.102: RC224.2 181.8,12.66 181.8,17.89
VSS_IO_SENSE: length 233.6
  TOP w0.089: v2(180.25,59.69) 180.5,59.69 CPU1.J14
  TOP w0.254: v2(330.48,25.8) 330.86,25.42 PR316.2
  IN3 w0.254: v2(180.25,59.69) 180.32,59.75 186.21,59.75 186.76,59.2 186.87,59.2 186.87,59.19 191.59,59.19 191.64,59.14 191.91,59.14 192.38,58.67 192.38,57.57 193.28,56.67 197.4,56.67 198.34,57.62 198.34,59.38 198.56,59.6 206.45,59.6 209.29,62.44 210.02,62.44 212.83,65.25 215.19,65.25 219.82,69.87 222.74,69.87 223.5,70.63 223.5,76.83 225.78,79.12 230.85,79.12 236.29,73.68 237.39,73.68 237.7,73.36 240.9,73.36 243.12,75.59 243.12,76.98 244.2,78.06 244.2,78.6 244.42,78.82 245.01,78.82 245.72,78.11 245.72,77.89 246.4,77.22 246.4,74.88 249.33,71.95 249.33,61.86 252.69,58.5 259.33,58.5 261.85,55.98 261.85,54.63 263.38,53.1 263.38,51.01 267.5,46.88 270.01,46.88 276.46,40.44 276.46,37.76 275.35,36.65 275.35,34.14 274.74,33.53 274.74,30.5 275.07,30.17 275.07,28.27 273.85,27.05 273.85,23.07 272.95,22.17 272.95,18.16 274.52,16.59 282.26,16.59 282.88,17.22 291.75,17.22 292.55,18.02 298.05,18.02 300.9,15.17 307.72,15.17 312.77,20.22 312.77,20.5 313.46,21.19 325.87,21.19 329.33,24.65 330.18,24.65 330.48,24.95 v2(330.48,25.8)
VSS_SA_SENSE: length 83.3
  TOP w0.254: PR1106.1 261.32,54.22 259.87,54.22 259.51,54.58 v1(258.6,54.58) 257.97,54.58 v2(257.61,54.93) ; CPU1.M37 198.07,56.98 199.07,56.98 v2(199.17,56.88) 200.22,55.84 PR1100.2
  IN3 w0.254: v2(257.61,54.93) 257.61,54.74 257.24,54.38 249.83,54.38 249.41,54.38 248.58,55.21 248.58,55.84 248.58,56.06 243.95,60.69 243.95,68.99 243.66,69.27 236.9,69.27 235.59,67.97 231.4,67.97 231,67.56 230.99,67.56 230.21,66.77 229.58,66.77 225.35,66.77 218.81,60.23 209.06,60.23 206.62,57.79 205.83,57 199.29,57 v2(199.17,56.88)
VSS_SENSE: length 81.8
  TOP w0.089: CPU1.AG38 198.31,45.5 v2(198.64,45.18)
  IN2 w0.254: v2(247.54,52.36) 247.46,52.28 243.96,52.28 241.88,54.36 241.88,55.22 239.99,57.11 239.74,57.11 238.72,58.12 236.88,58.12 236.37,57.61 232.83,57.61 232.01,58.44 225.96,58.44 223.35,55.84 223.35,45.94 220.62,43.2 215.42,43.2 v2(215.35,43.26)
  IN3 w0.089: v2(198.64,45.18) 199.04,45.18 199.75,44.47 199.9,44.47
  IN3 w0.254: v2(215.35,43.26) 215.29,43.2 213.85,43.2 212.32,44.72 208.89,44.72 208.26,45.36 207.29,45.36 205.29,43.35 204.43,43.35 203.72,44.06 202.07,44.06 201.66,44.47 199.9,44.47
  BOTTOM w0.254: v2(215.35,43.26) 215.37,43.28 RC221.1 216.9,43.28 PR1125.2 ; v2(247.54,52.36) 247.61,52.28 248.56,52.28 251.17,54.88 v1(253.27,54.88) 255.04,54.88 256.77,53.16 PR1122.1
VSSGT_SENSE: length 85.4
  TOP w0.089: v2(197.99,44.39) 197.66,44.71 CPU1.AH37 197.59,44.86 197.59,45.25 197.39,45.46 197.39,45.69 197.63,45.93 198.73,45.93 199.31,45.36 199.9,45.36
  TOP w0.254: PR1128.2 261.01,36.41 261.01,35.35 261.65,34.72 v1(261.88,34.72) 261.88,34.72 262.84,34.72 264.41,33.15 264.41,31.17 v2(264.5,31.07) ; PR1129.1 199.9,45.36
  IN1 w0.089: v2(197.99,44.39) 198.78,43.6 199.78,43.6 199.86,43.52 199.9,43.52
  IN1 w0.254: v2(264.5,31.07) 264.37,31.2 261.61,31.2 261.33,31.48 259.13,31.48 258.77,31.84 255.59,31.84 254.7,32.73 251.02,32.73 248.33,35.42 235.83,35.42 234.37,36.89 231.09,36.89 229.8,38.18 225.94,38.18 225.3,38.82 217.16,38.82 215.44,40.54 214.56,41.42 208.58,41.42 208.1,40.95 207.27,40.95 205.5,42.72 204.3,42.72 203.5,43.52 199.9,43.52
VSSGTX_SENSE: length 123.4
  TOP w0.089: v2(196.67,44.4) 196.36,44.71 CPU1.AH35
  TOP w0.254: v2(263.85,24.2) 263.84,24.19 PR1617.1 PC1614.1 264.12,22.64 264.19,22.7 PC1627.1 266.62,22.7 v1(266.9,22.98) ; PR1620.2 204.5,43.77 v2(204.63,43.9)
  IN4 w0.089: 199.9,43.9 199.88,43.9 199.8,43.98 199.74,43.98 199.72,43.97 197.11,43.97 v2(196.67,44.4)
  IN4 w0.254: 199.9,43.9 200.88,43.9 201.2,43.58 203.57,43.58 203.89,43.9 v2(204.63,43.9) 205,43.9 205.97,42.93 205.97,42.37 207.31,41.04 208.41,41.04 208.66,41.3 210.38,41.3 211.64,40.03 220.54,40.03 221.57,39.01 221.57,39.01 221.67,38.91 225.59,38.91 226.34,38.17 229.73,38.17 230.73,37.17 230.73,17.01 231.66,16.08 234.48,16.08 235.16,16.76 236.13,16.76 236.77,16.12 239.79,16.12 241.71,18.04 241.71,24.82 245.98,29.08 245.98,31.39 252.24,37.65 259.03,37.65 261.65,35.03 261.65,33.01 261.15,32.51 261.15,29.76 263.93,26.98 263.93,24.28 v2(263.85,24.2)
3301_ACAV_IN_NB: length 1.9
  TOP w0.254: PU1001.24 333.2,57.77 v2(333.16,57.81) 333.16,58.25 PR1019.1
3301_DC_IN_SS: length 4.7
  TOP w0.254: PU1001.34 329.62,52.69 PR1010.2 329.08,51.2 v1(328.81,50.92) PR1026.2
3301_PWRSRC: length 1.9
  TOP w0.254: PU1001.15 337.2,54.19 337.26,54.12 v2(337.72,54.12) 338.29,54.12 PR1029.1
81205_ALERT: length 2.7
  TOP w0.203: PU1100.41 260.41,43.17 261.19,42.38 v1(261.19,42.37) 261.51,42.37 PR1115.2
81205_SCLK: length 5.1
  TOP w0.102: v1(264.27,43.58) 264.27,43.45 263.99,43.17 262.85,43.17 262.85,43.17 262.62,43.17 PR1117.1
  TOP w0.203: PR1117.1 261.94,42.9 261.15,42.9 260.47,43.57 PU1100.42
81205_SDIO: length 9.1
  TOP w0.203: PR1113.1 262.14,40.66 261.84,40.36 261.61,40.36 261.3,40.66 260.27,40.66 260.07,40.85 260.07,41.1 260.2,41.23 260.77,41.23 260.9,41.1 v1(261.19,41.1) 261.45,41.1 261.64,41.3 261.64,41.68 261.51,41.8 260.9,41.8 260.77,41.68 259.82,41.68 259.68,41.82 259.68,42.11 259.82,42.25 260.39,42.25 260.53,42.39 260.53,42.58 260.34,42.77 PU1100.40
81205_VR_HOT: length 4.3
  TOP w0.203: PU1100.39 259.35,41.64 259.75,41.24 259.74,41.24 259.74,40.66 v1(260.13,40.28) 260.18,40.23 261.27,40.23 261.66,39.83 PR1110.1
81210_ADDR/VBOOT: length 2.3
  TOP w0.254: v2(260.44,25.22) 260.65,25.43 260.65,25.62 PR1610.1
  IN4 w0.254: v2(260.44,25.22) 259.32,25.22 v2(259.31,25.23)
81210_COMP: length 6.1
  TOP w0.203: 261.28,26.83 261.04,26.83 260.49,27.38 PU1600.34
  TOP w0.254: PC1609.1 PC1608.1 263.52,26.93 v1(263.5,26.94) 263.11,26.94 263,26.83 261.28,26.83
81210_ILIM: length 6.7
  TOP w0.203: v1(261.78,27.25) 261.17,27.25 260.64,27.78 PU1600.35
  TOP w0.254: v1(261.78,27.25) 262.64,27.25 262.78,27.39 264.27,27.39 264.6,27.72 PR1604.1 PC1607.1
81210_IMAX: length 4.3
  TOP w0.203: PU1600.28 258.02,24.76 257.85,24.59 257.85,23.77 v1(258.11,23.52)
  TOP w0.254: v1(258.11,23.52) 258.49,23.52 258.55,23.45 259.63,23.45 260.03,23.05 PR1612.1
81210_SENSE_RETURN: length 25.2
  TOP w0.203: PU1600.36 260.68,28.18 261.15,27.71 v2(261.33,27.71)
  TOP w0.254: v2(260.56,18.04) PH1600.2 v1(260.56,19.9) 260.44,20.01 259.8,20.01 259.54,19.76 256.3,19.76 255.76,19.21 PL1600.3 ; v2(263.25,29.94) 263.17,29.87 PC1603.2 263.16,29.22 PC1690.2
  IN3 w0.254: v2(263.25,29.94) 261.33,28.02 v2(261.33,27.71) 261.33,23.32 260.56,22.55 v2(260.56,18.04)
81210_SW1:
  vias: v1(253.42,23.97)
81210_SWN: length 17.9
  TOP w0.254: PL1600.2 255.76,20.34 255.91,20.19 259.01,20.19 v1(259.36,20.54) 259.44,20.62 261.46,20.62 v2(261.47,20.62) ; PR1601.2 264.07,29.55 v2(263.81,29.8)
  IN3 w0.254: v2(263.81,29.8) 263.81,28.86 261.94,26.98 261.94,21.09 v2(261.47,20.62)
81210_TSENSE: length 4.4
  TOP w0.203: PU1600.29 258.42,24.85 v2(258.61,24.66)
  TOP w0.254: v2(260.51,24.35) 260.52,24.34 PR1613.2 261.12,25.17 PC1612.2
  IN1 w0.254: v2(260.51,24.35) 258.93,24.35 v2(258.61,24.66)
81210_VSN: length 7.7
  TOP w0.089: PU1600.33 260.2,26.98 260.41,26.77
  TOP w0.102: v1(261.88,21.51) 261.88,21.59 PC1614.2 ; 260.41,26.77 v2(260.49,26.69)
  TOP w0.254: PC1614.2 PR1617.2 v2(262.92,24.3)
  IN1 w0.109: v2(262.92,24.3) 262.88,24.3 262.45,24.72 260.49,26.69 v2(260.49,26.69)
81210_VSP: length 11
  TOP w0.102: v2(260.39,26.06) 260.39,26.18 260,26.58 PU1600.32
  TOP w0.254: PR1618.2 PR1619.2 262.86,20.28 v2(262.23,19.65)
  IN1 w0.109: v2(262.23,19.65) 262.2,19.68 262.2,24.63 260.69,26.15 260.49,26.15 v2(260.39,26.06)
+BL_PWR_SRC:
  vias: v2(108.97,138.58) v2(109.5,139.01) v2(110.09,139.26) v3(107.02,138.83)
+CAMERA_VDD: length 45.6
  TOP w0.254: JEDP1.9 123.58,142.95 123.89,143.29 123.94,143.34 127.33,143.34 v2(128.05,144.06)
  IN2 w0.508: v2(101.41,137.88) 103.42,139.9 112.99,139.9 113.91,138.98 117.82,138.98 119.61,140.77 119.61,142.39 121.05,143.82 121.05,145.98 121.58,146.51 125.26,146.51 126.34,145.44 127.27,145.44 127.72,144.99 127.8,144.99 128.19,144.61 128.19,144.19 v2(128.05,144.06)
  BOTTOM w0.508: Q24.1 100.59,133.29 C299.1 C300.1 100.59,137.47 v3(100.76,137.65) 101,137.88 v2(101.41,137.88)
+CAP_LDO: length 4.3
  TOP w0.381: C714.1 177.62,107.06 177.5,107.18 177.5,107.73 177.31,107.92 v1(177.17,107.92)
  TOP w0.508: v2(176.7,107.52) 177.1,107.92 177.17,107.92 v1(177.17,107.92)
  BOTTOM w0.305: U46.B46 177.8,106.58 176.86,107.52 v2(176.7,107.52)
+CHAGER_SRC:
  vias: v1(293.97,17.22)
+COINCELL: length 4
  BOTTOM w0.508: JRTC1.1 50.63,28.13 48.65,28.13 PR1.1 48.49,27.09 v1(48.11,26.71)
+CPU_B+: length 13.2
  TOP w0.254: PR1150.1 249.26,47.26 v2(249.01,47.52)
  TOP w0.508: v2(256.6,34.35) 255.84,34.35 PC1642.1
  IN1 w0.508: v2(249.01,47.52) 247.42,49.11 245.77,49.11 v2(245.14,48.47)
  BOTTOM w0.508: v2(253.01,30.25) 254.74,31.98 254.74,33.31 255.78,34.35 v2(256.6,34.35)
  vias: v1(244.12,72.21) v2(237.52,31.52) v2(237.52,30.88) v2(237.52,29.99) v2(237.52,29.36) v2(237.52,21.36) v2(237.52,20.72) v2(237.58,17.86) v2(238.15,31.52) v2(238.15,30.88) v2(238.15,29.99) v2(238.15,29.36) v2(238.15,21.36) v2(238.15,20.72) v2(238.21,17.86) v2(238.87,21.36) v2(238.87,20.72) v2(241.96,15.26) v2(241.96,14.63) v2(241.96,13.55) v2(241.96,12.91) v2(241.96,11.77) v2(241.96,11.13) v2(243.71,55.09) v2(243.71,54.45) v2(243.7,47.18) v2(243.7,46.54) v2(243.73,44.97) v2(243.73,44.33) v2(244.18,58) v2(244.2,57.36) v2(244.35,55.09) v2(244.35,54.45) v2(244.34,47.18) v2(244.34,46.54) v2(244.36,44.97) v2(244.36,44.33) v2(244.71,57.68) v2(244.71,57.03) v2(245.14,47.84) v2(245.14,46.76) v2(245.14,46.12) v2(245.14,44.98) v2(245.14,44.34) v2(246.28,56.03) v2(246.28,55.39) v2(246.28,54.31) v2(246.28,53.68) v2(250.04,29.61) v2(250.66,30.25) v2(250.66,29.61) v2(251.29,30.25) v2(251.29,29.61) v2(252.37,30.25) v2(252.37,29.61) v2(253.01,29.61)
+DC1_PWR_SRC: length 20.5
  TOP w0.203: v2(353.28,30.56) 353.1,30.74 PU101.12
  IN4 w0.508: v2(353.28,30.56) 351.5,32.34 349.82,32.34 348.19,33.97 346.99,33.97 345.98,32.95 345.98,31.82 345.04,30.88 343.89,30.88 342.27,32.51 342.27,33.32 v2(341.21,34.37)
  BOTTOM w0.102: v3(337.83,31.21) v2(338.68,31.21)
  BOTTOM w0.508: PC117.1 353.11,30.73 v2(353.28,30.56)
+DC_IN: length 511.2
  TOP w0.508: PQ8.3 16.85,26.39 v2(16.9,26.44) ; PR1011.1 326.51,49.42 v2(326.01,49.92) ; v2(299.89,48.79) 299.76,48.66 299.76,34.9 v2(300.85,33.82) ; v2(19.98,64.16) 21,65.17 25,65.17 25.76,64.41 25.76,61.42 24.74,60.41 24.74,53.87 23.28,52.41 23.28,47.96 26.71,44.53 v2(26.97,44.53) ; PR737.1 v2(266.97,30.75)
  IN1 w0.508: 264.27,18.5 v2(263.63,17.86) ; 264.27,18.5 265.09,18.5 265.83,17.76 282.71,17.76 283.89,18.94 297.43,18.94 v2(300.49,22) ; 264.27,18.5 264.27,22.31 265.09,23.13 265.09,28.88 v2(266.97,30.75)
  IN2 w0.508: v2(177.72,18.12) 177.78,18.05 177.78,16.85 178.41,16.21 187.04,16.21 188.34,17.51 197.87,17.51 201.96,21.61 206.05,21.61 210.17,17.48 223.28,17.48 224.57,18.77 229.11,18.77 229.59,19.25 234.45,19.25 234.95,19.76 240.38,19.76 243.16,16.97 246.41,16.97 248.07,18.63 248.07,32.39 249.03,33.34 254.79,33.34 255.17,32.96 259.24,32.96 260.94,31.26 260.94,29.69 262.11,28.52 262.11,26.87 261.93,26.69 261.93,24.38 263.63,22.68 v2(263.63,17.86) ; v2(26.97,44.53) 27.98,43.52 30.13,43.52 35.36,48.75 v2(40.17,48.75)
  IN3 w0.508: v2(299.89,48.79) 300.52,48.15 310.43,48.15 312.21,49.93 315.93,49.93 319.4,46.46 322.53,46.46 325.99,49.92 v2(326.01,49.92) ; v2(70.15,50.69) 70.97,49.87 70.97,45.18 72.85,43.3 75.37,43.3 89.36,29.31 89.36,20.63 91.07,18.92 92.72,18.92 97.12,14.52 107.41,14.52 109.34,12.59 110.36,11.58 135.54,11.58 139.92,15.96 143.22,15.96 146.21,18.94 146.27,18.94 146.28,18.95 159.68,18.95 160.05,19.32 160.58,19.32 161.52,19.32 161.65,19.45 168.05,19.45 168.24,19.26 171.74,19.26 172.5,18.5 176.19,18.5 176.57,18.12 v2(177.72,18.12)
  IN4 w0.508: v2(70.15,50.69) 66.4,46.95 61,46.95 60.18,46.12 56.56,46.12 55.6,47.07 55.6,63.39 53.7,65.3 21.12,65.3 v2(19.98,64.16)
  BOTTOM w0.508: v2(16.9,26.44) 17.96,26.44 20.1,28.57 20.1,34.11 24.24,38.25 24.24,39.77 25.25,40.79 25.76,40.79 27.16,42.19 v3(27.16,43.57) 27.16,44.34 v2(26.97,44.53) 26.46,45.04 v3(26.2,45.04) ; v2(300.49,22) 300.66,22 303.72,25.06 303.72,27.13 302.07,28.79 302.07,32.6 v2(300.85,33.82)
  vias: v3(50.45,44.39)
+DC_IN_SS: length 489.5
  TOP w0.254: PD701.3 285.86,39.96 287.32,39.96 287.74,39.54 287.74,39.03 v2(287.61,38.9) ; v2(111.22,93.17) 111.23,93.17 110.96,93.17 110.16,93.97 109.48,93.97 108.75,94.7 108.56,94.7 107.1,96.16 106.85,96.16 106.85,96.16 104.59,96.16 99.79,91.36 99.24,91.36 97.5,89.62 92.95,89.62 92.7,89.62 92.67,89.62 68.81,65.76 68.81,65.73 68.69,65.6 68.69,53.87 63.3,48.49 63.3,44.09 62.77,43.56 62.77,39.15 64.14,37.78 64.14,36.14 60.23,32.23 60.23,31.44 v2(59.61,30.82) 59.61,30.56 60.23,29.94 60.23,27.74 59.8,27.32 57.32,27.32 56.85,26.85 JIO2.19 ; PD1102.2 v2(324.63,44.55)
  IN2 w0.254: v2(248.07,68.73) 248.07,68.73 245.66,71.14 245.07,71.14 244.27,71.94 241.07,71.94 237.74,75.27 236.89,75.27 234.14,78.01 220.7,78.01 219.48,79.23 212.53,79.23 211.39,80.37 208.78,80.37 203.6,85.55 203.36,85.55 202.77,86.14 202.77,91.08 200.54,93.31 199.98,93.31 199.52,93.77 197.06,93.77 196.13,94.7 191.5,94.7 189.98,96.22 185.55,96.22 184.47,97.3 184.15,97.3 181.72,97.3 180.7,98.32 176.9,98.32 176.78,98.2 175.71,98.2 175.59,98.32 173.2,98.32 172.21,99.3 171.33,99.3 171.01,99.63 168.06,99.63 167.79,99.36 162.2,99.36 160.98,100.58 157.88,100.58 154.34,97.05 149.39,97.05 147.15,94.81 136.37,94.81 135.96,94.39 134.47,94.39 133,92.92 113.6,92.92 113.2,92.52 111.84,92.52 111.23,93.13 111.23,93.17 v2(111.22,93.17) ; v2(257,82.27) 257,82.35 255.44,83.9 255.44,85.33 254.27,86.5 254.27,89.29 251.57,92 251.57,92.62 250.85,93.33 250.85,96.06 249.03,97.89 249.03,102.38 248.2,103.21 246.1,103.21 245.57,102.67 244.93,102.67 242.68,104.93 242.68,105.28 241.57,106.38 v2(240.71,106.38)
  IN3 w0.254: v2(257,82.27) 256.46,81.73 256.46,73.28 260.85,68.89 260.85,66.31 279.63,47.52 283.6,47.52 286.4,44.72 286.4,39.3 286.9,38.8 287.51,38.8 v2(287.61,38.9) 289.48,40.77 289.48,43.81 291.22,45.55 301.67,45.55 301.98,45.23 307.7,45.23 308.32,44.61 308.32,42.32 309.58,41.07 310.44,41.07 311.92,42.54 317.46,42.54 320.49,45.57 323.61,45.57 v2(324.63,44.55)
  IN4 w0.254: v2(59.61,30.82) 60.23,31.44 60.23,35.08 57.83,37.49 55.22,37.49 54.4,36.66 53.45,36.66 52.56,37.55 51.41,37.55 50.52,38.44 50.52,43.68 48.91,45.3 43.16,45.3 41.13,47.33 36.05,47.33 v2(35.17,46.44)
  BOTTOM w0.254: v2(240.71,106.38) 241.34,106.38 242.56,105.16 242.56,103.17 242.99,102.74 242.99,102.09 245.83,99.25 246.28,99.25 247.71,97.83 247.71,96.91 247.54,96.74 247.54,95.31 245.05,92.82 245.05,90.91 244.33,90.18 244.33,85.11 243.95,84.73 v3(243.95,82.97) 243.95,82.55 248.27,78.23 248.27,68.93 v2(248.07,68.73)
+DCIN: length 12.8
  TOP w0.102: v1(276.19,34.92) 275.73,34.46 275.3,34.46
  TOP w0.508: PR717.2 279.72,41.43 PC709.1 280.89,39.7 280.56,39.36 v2(278.89,39.36)
  BOTTOM w0.508: v2(274.81,34.82) 275.12,34.82 277.44,37.14 277.44,37.2 277.58,37.33 278.29,37.33 278.84,37.88 278.84,39.31 v2(278.89,39.36)
+DCIN_JACK:
  vias: v2(40.54,59.94) v2(40.97,60.68) v2(41.36,59.94) v2(41.79,60.68) v2(42.17,59.94) v2(42.6,60.68) v2(42.98,59.94) v2(43.41,60.68) v2(45.14,48.05) v2(45.47,48.74) v2(45.95,48.05) v2(46.28,48.74) v2(46.77,48.05) v2(47.1,48.74) v2(47.58,48.05) v2(47.91,48.74) v3(48.24,48.22) v3(48.39,50.99) v3(50.31,46.58)
+DCPRTC: length 1.9
  TOP w0.203: UH1.BA26 v2(121.77,121.68)
  BOTTOM w0.089: v2(121.77,121.68) 121.77,121.6 v1(121.38,121.21)
  BOTTOM w0.254: v2(121.77,121.68) 121.83,121.74 CH68.1
+DDR_VREF_B_DQ: length 70
  TOP w0.254: CPU1.BR13 179.71,24.63 180.12,24.22 180.12,23.93 180.21,23.84 v2(180.21,23.38)
  TOP w0.508: v2(135.59,9.93) 136.91,9.93 138.92,7.92 138.92,7.31 139.23,6.99 139.23,5.99 138.35,5.1 v1(137.8,5.1) 137.27,5.1 136.55,5.82 CD136.1 RD41.1
  IN3 w0.508: v2(180.21,23.38) 178.41,21.59 178.41,17.84 177.46,16.89 176.51,16.89 175.62,16 175.13,16 170.66,11.53 166.72,11.53 165.65,12.6 165.65,13.42 164.57,14.5 160.38,14.5 157.58,17.3 146.9,17.3 143.91,14.31 140.6,14.31 136.22,9.93 v2(135.59,9.93)
+DDR_VREF_CA: length 76.2
  TOP w0.254: CPU1.BN13 179.65,26.04 v2(179.32,26.36)
  TOP w0.508: v2(142.87,52.75) 142.87,55.16 v1(142.23,55.8) 141.8,56.23 RD45.1 CD127.1 RD23.1
  IN2 w0.508: v2(150.09,20.28) 149.65,20.72 149.65,45.97 v2(142.87,52.75)
  IN3 w0.508: v2(179.32,26.36) 179.32,25.37 178.26,24.31 177.11,24.31 177.02,24.4 171.87,24.4 169.33,21.86 151.68,21.86 v2(150.09,20.28)
+DIMM_DQ_R_VREF_B: length 85.8
  TOP w0.102: RD44.1 132.12,5.16 v1(132.06,5.1)
  TOP w0.508: RD11.1 107.94,53.24 v2(108.18,53.49) ; RD43.2 RD44.1 ; RD43.2 132.13,7.08 CD140.1 CD138.1 CD137.1 RD41.2 ; RD43.2 v2(132.12,8.91)
  IN1 w0.508: v2(132.12,8.91) 130.92,8.91 130.08,8.08 126.23,8.08 117.83,16.47 117.83,60.35 116.76,61.42 112.5,61.42 110.85,59.77 110.85,56.15 v2(108.18,53.49)
+DOCK_PWR_BAR: length 226.4
  TOP w0.254: PD701.2 286.52,39.32 v2(287.2,39.32) ; PR1007.1 326.94,53.36 PR1001.1 326.73,53.67 v2(326.25,54.15)
  TOP w0.508: v2(157.44,154.6) C702.1
  VCC w0.254: 196.72,152.59 JDOCK1.150 ; JDOCK1.150 195.9,153.96 ; JDOCK1.150 195.9,153.28 ; JDOCK1.150 196.72,153.96 ; JDOCK1.150 195.9,152.59 ; JDOCK1.147 156.27,153.96 ; JDOCK1.147 157.1,152.59 ; JDOCK1.147 157.1,153.96 ; JDOCK1.147 157.1,153.28 ; JDOCK1.147 156.27,152.59 ; 195.9,150.73 JDOCK1.149 ; JDOCK1.149 196.72,150.04 ; JDOCK1.149 195.9,151.41 ; JDOCK1.149 195.9,150.04 ; JDOCK1.149 196.72,151.41 ; JDOCK1.146 157.1,151.41 ; JDOCK1.146 157.1,150.73 ; JDOCK1.146 156.27,151.41
  IN2 w0.254: v2(210.13,142.83) 211.48,141.47 225.34,141.47 239.44,127.38 239.44,122.96 237.91,121.43 237.91,117.88 236.83,116.8 236.83,113.72 243.78,106.78 246.16,106.78 249.79,103.14 249.79,97.68 251.31,96.16 251.31,96.05 251.95,95.41 251.95,92.15 254.68,89.42 254.68,86.63 256.14,85.17 256.14,83.9 257,83.05 257.31,83.05 257.6,82.76 257.6,82.18 v2(256.98,81.55)
  IN3 w0.254: v2(326.25,54.15) 326.25,51.05 326.52,50.78 326.52,49.71 322.76,45.95 319.21,45.95 317.86,44.6 316.08,44.6 315.51,45.17 312.08,45.17 311.32,44.41 311.32,43.01 310.62,42.31 309.43,42.31 308.8,42.94 308.8,44.82 308.01,45.61 302.14,45.61 301.83,45.93 291.06,45.93 289.1,43.97 289.1,41.15 287.27,39.32 v2(287.2,39.32) 286.91,39.6 286.91,44.75 283.76,47.9 279.79,47.9 261.28,66.41 261.28,67.76 261.28,67.76 261.28,69 257.17,73.11 257.17,73.14 256.98,73.33 v2(256.98,81.55)
  vias: v1(206.63,146.76) v2(129.01,136.8) v2(129.65,136.8) v2(129.96,137.31) v2(130.28,137.82) v2(130.28,136.8) v2(130.6,137.31) v2(130.73,140.74) v2(130.73,140.1) v2(130.92,137.82) v2(130.92,136.8) v2(131.23,137.31) v2(131.36,140.74) v2(131.36,140.1) v2(131.55,137.82) v2(131.55,136.8) v2(131.87,137.31) v2(132,140.74) v2(132,140.1) v2(147.55,154.83) v2(147.55,154.2) v2(147.55,153.56) v2(148.19,155.47) v2(148.19,154.83) v2(148.19,154.2) v2(148.19,153.56) v2(148.82,156.1) v2(148.82,155.47) v2(148.82,154.83) v2(148.82,154.2) v2(148.82,153.56) v2(154.54,157.63) v2(154.79,156.99) v2(155.17,157.63) v2(155.43,156.99) v2(155.81,157.63) v2(155.81,156.48) v2(193.65,153.94) v2(193.65,153.31) v2(194.29,153.94) v2(194.29,153.31) v2(194.92,153.94) v2(194.92,153.31) v2(195.81,152.29) v2(195.81,151.66) v2(196.45,152.29) v2(196.45,151.66) v2(197.08,152.29) v2(197.08,151.66) v2(207.5,143.59) v2(207.5,142.96) v2(208.13,143.59) v2(208.13,142.96) v2(210.42,143.59)
+LCDVDD: length 6.4
  IN2 w0.508: v2(117.48,147.11) 118.23,146.36 118.23,141.26 v2(118.09,141.12)
  vias: v2(118.22,140.42) v3(117.54,146.42)
+LCDVDD_R: length 1.5
  BOTTOM w0.102: v1(117.2,141.69) 117.39,141.88 118.66,141.88
+LOM_VCT: length 5.2
  TOP w0.508: C701.1 188.65,157.08 188.62,157.08 v2(188.48,157.22)
  BOTTOM w0.102: v3(188.62,158.4) 188.62,157.93 188.48,157.79 v2(188.48,157.22)
  BOTTOM w0.254: JDOCK1.118 188.75,156.95 v2(188.48,157.22) 188.48,157.09 188.25,156.86 JDOCK1.116
+MXM_PWR:
  vias: v1(224.86,101.8)
+MXM_PWR_SRC: length 1
  BOTTOM w0.102: v2(223.17,83.19) 223.17,82.88 v3(222.72,82.43)
+MXM_SRC_EN#:
  vias: v1(225.15,107.45)
+NBDOCK_DC_IN_SS: length 531.5
  TOP w0.254: v2(59.72,28.15) 59.38,27.82 57.13,27.82 56.66,27.35 JIO2.21 ; PR1024.2 337.34,59.65 v2(337.65,59.96)
  TOP w0.508: v2(59.72,28.15) 59.72,28.65 C1425.1 ; v2(169.24,145.53) 169.24,146.36 169.97,147.09 173.4,147.09 174.67,148.36 174.67,149.82 175.24,150.39 178.1,150.39 178.67,150.96 178.67,154.07 v2(178.03,154.71)
  IN1 w0.508: v2(178.03,154.71) 178.03,155.21 177.67,155.57 173.61,155.57 172.81,154.78 169.4,154.78 168.59,155.59 166.36,155.59 165.48,154.71 162.8,154.71 159.87,151.78 159.87,151.66 158.79,150.58 158.79,147.72 154.58,143.5 154.02,143.5 153.62,143.11 153.62,141.98 152.95,141.31 152.16,141.31 151.33,140.48 151.33,139.42 150.75,138.83 143.49,138.83 140.23,142.09 136.64,142.09 133.51,138.96 128.19,138.96 125.39,136.16 121.39,136.16 119.49,138.07 113.82,138.07 110.95,135.2 103.37,135.2 102.72,135.85 98.85,135.85 97.82,134.82 97.82,131.13 90.09,123.4 90.09,117.69 92.51,115.26 95.03,115.26 96.54,113.75 96.54,109.07 95.86,108.4 95.86,99.67 v2(95.39,99.2)
  IN2 w0.508: v2(212.57,148.85) 212.57,147.53 211.41,146.36 203.64,146.36 203.25,146.76 198.85,146.76 195,150.6 193.3,150.6 191.05,152.85 187.76,152.85 185.14,155.47 183.47,155.47 182.39,154.39 178.35,154.39 v2(178.03,154.71) ; v2(72.96,58.4) 72.75,58.61 72.75,59.18 73.25,59.67 78.74,59.67 85.48,66.41 85.48,77.91 93.43,85.86 93.43,97.23 v2(95.39,99.2) ; v2(323.12,38.98) 323.1,38.97 321.54,38.97 320.72,38.15 320.72,37.35 319.87,36.51 318.76,36.51 317.93,37.33 316.46,37.33 316.08,36.95 310.14,36.95 308.87,38.22 301.25,38.22 299.97,36.95 297.48,36.95 293.98,40.44 293.98,41.08 290.97,44.09 285.38,44.09 281.43,48.03 276.92,48.03 260.41,64.54 260.41,66.28 258.42,68.27 258.42,70.49 251.88,77.03 v2(251.88,77.86)
  IN3 w0.508: v2(247.31,106.32) 245.34,106.32 243.34,108.33 243.34,113.72 242.5,114.56 242.5,117.61 242.05,118.05 242.05,123.67 234.04,131.68 234.04,132.48 223.05,143.47 216.39,143.47 212.57,147.28 v2(212.57,148.85) ; v2(323.12,38.98) 323.12,39.78 325.61,42.27 330.71,42.27 331.24,42.8 331.24,57.54 332.77,59.06 337.09,59.06 337.65,59.63 v2(337.65,59.96)
  BOTTOM w0.254: JDOCK1.41 167.75,146.36 168.58,145.53 v2(169.24,145.53)
  BOTTOM w0.508: v2(247.31,106.32) 247.31,105.88 249.33,103.86 249.33,102.76 250.74,101.35 250.74,94.64 249.03,92.93 249.03,92.03 248.97,91.98 248.97,91.97 248.74,91.74 248.74,91.74 248.35,91.36 247.74,90.75 247.74,81.44 251.32,77.86 v2(251.88,77.86) ; v2(59.72,28.15) 62.01,30.45 62.01,32.28 65.68,35.95 66.31,35.95 66.88,36.52 66.88,37.15 68.38,38.65 68.38,40.16 69.37,41.16 70.81,41.16 72.7,39.26 77.22,39.26 78.22,40.27 v1(78.22,41.63) 78.22,47.02 72.96,52.29 v2(72.96,58.4)
+PECI_VREF: length 5
  BOTTOM w0.305: U51.B51 195.9,115.65 195.52,116.03 195.52,116.87 195.62,116.97 195.62,117.52 v1(195.84,117.74) 195.88,117.78 195.88,118.03 R866.1
  BOTTOM w0.508: R866.1 C740.1
+PWR_SRC: length 73.9
  TOP w0.305: v2(339.13,54.15) 339.66,54.15 PR1029.2 339.38,53.57 v2(339.1,53.57)
  TOP w0.508: RZ73.1 74.07,34.44 v2(74.5,34.87)
  IN1 w0.508: v2(58.83,26.69) 59.49,26.69 61.85,29.05 61.85,31.01 63.36,32.52 66.13,32.52 66.52,32.91 72.54,32.91 v2(74.5,34.87)
  IN1 w1.016: 333.33,50.67 332.77,50.1 332.77,47.52 331.91,46.66 331.91,45.1 331.27,44.46 331.27,42.31 330.8,41.84 329.15,41.84 328.59,41.28 328.59,29.67 330.2,28.06 336.17,28.06 337.01,27.22 337.01,25.01 336.17,24.17 336.17,17.08 333.79,14.71 333.79,13.61 335.11,12.3
  vias: v2(46.38,38.5) v2(46.38,37.87) v2(47.02,38.5) v2(47.02,37.87) v2(47.65,38.5) v2(47.65,37.87) v2(48.29,38.5) v2(48.3,37.87) v2(48.92,38.5) v2(48.94,37.87) v2(49.17,40.99) v2(49.17,40.36) v2(49.22,39.77) v2(49.22,39.14) v2(49.36,16.47) v2(49.36,15.83) v2(49.36,15.2) v2(49.36,14.56) v2(49.36,13.93) v2(49.36,13.29) v2(49.51,11.67) v2(49.51,11.07) v2(49.81,40.99) v2(49.81,40.36) v2(49.81,39.75) v2(49.81,39.11) v2(50,68.98) v2(50,68.35) v2(50,67.71) v2(50,16.47) v2(50,15.83) v2(50,15.2) v2(50,14.56) v2(50,13.93) v2(50,13.29) v2(50.63,16.47) v2(50.63,15.83) v2(50.63,15.2) v2(50.63,14.56) v2(50.63,13.93) v2(50.63,13.29) v2(50.7,68.98) v2(50.7,68.35) v2(50.7,67.71) v2(51.4,68.98) v2(51.4,68.35) v2(51.4,67.71) v2(52.1,68.98) v2(52.1,68.35) v2(52.1,67.71) v2(52.79,68.98) v2(52.79,68.35) v2(52.79,67.71) v2(53.49,68.98) v2(53.49,68.35) v2(53.49,67.71) v2(57.56,26.69) v2(57.56,26.06) v2(57.56,25.42) v2(57.61,24.79) v2(57.56,24.15) v2(57.56,23.52) v2(58.19,26.69) v2(58.19,26.06) v2(58.19,25.42) v2(58.24,24.79) v2(58.19,24.15) v2(58.19,23.52) v2(58.83,26.06) v2(58.83,25.42) v2(58.83,24.15) v2(58.83,23.52) v2(58.88,24.79) v2(66.08,10.9) v2(66.4,10.39) v2(66.72,10.9) v2(67.04,10.39) v2(84.04,4.53) v2(84.04,3.89) v2(84.67,4.53) v2(84.67,3.89) v2(85.31,4.53) v2(85.31,3.89) v2(85.94,4.53) v2(85.94,3.89) v2(86.58,4.53) v2(86.58,3.89) v2(87.27,4.53) v2(87.27,3.89) v2(87.91,4.53) v2(87.91,3.89) v2(88.54,4.53) v2(88.54,3.89) v2(89.18,4.53) v2(89.18,3.89) v2(89.81,4.53) v2(89.81,3.89) v2(90.09,106.26) v2(90.09,105.62) v2(90.09,104.99) v2(90.72,106.26) v2(90.72,105.62) v2(90.72,104.99) v2(91.29,106.51) v2(91.29,105.87) v2(91.29,105.24) v2(91.86,106.32) v2(91.86,105.68) v2(91.86,105.05) v2(92.5,106.32) v2(92.5,105.68) v2(92.5,105.05) v2(93.13,106.32) v2(93.13,105.68) v2(93.13,105.05) v2(101.6,113.05) v2(102.32,113.08) v2(107.4,136.19) v2(108.49,135.96) v2(122.72,139.02) v2(122.72,138.39) v2(123.11,137.88) v2(123.32,138.45) v2(123.36,139.09) v2(123.8,139.47) v2(123.8,138.01) v2(123.87,138.7) v2(124.12,139.97) v2(124.44,139.47) v2(124.44,138.83) v2(124.38,138.13) v2(124.69,140.1) v2(125.04,139.62) v2(125.26,139.07) v2(125.39,140.1) v2(125.71,139.59) v2(126.03,140.1) v2(230.12,4.41) v2(230.12,3.78) v2(230.76,4.41) v2(230.76,3.78) v2(231.39,4.41) v2(231.39,3.78) v2(232.03,4.41) v2(232.03,3.78) v2(232.66,4.41) v2(232.66,3.78) v2(233.3,4.41) v2(233.3,3.78) v2(233.93,4.41) v2(233.93,3.78) v2(234.57,4.41) v2(234.57,3.78) v2(235.2,4.41) v2(235.2,3.78) v2(235.84,4.41) v2(235.84,3.78) v2(236.33,77.43) v2(236.64,76.92) v2(236.96,77.43) v2(237.28,76.92) v2(237.34,76.28) v2(237.6,77.43) v2(237.91,76.92) v2(237.98,76.28) v2(238.61,76.28) v2(251.82,83.08) v2(251.99,82.49) v2(252.33,83.59) v2(252.52,82.25) v2(252.46,80.97) v2(252.91,80.47) v2(253,81.68) v2(253.03,81.1) v2(293.2,14.05) v2(293.2,13.42) v2(293.2,12.78) v2(293.84,14.05) v2(293.84,13.42) v2(293.84,12.78) v2(294.47,14.05) v2(294.47,13.42) v2(295.17,14.05) v2(295.17,13.42) v2(295.83,14.05) v2(295.83,13.42) v2(296.46,14.05) v2(296.46,13.42) v2(297.16,14.05) v2(335.81,10.37) v2(336.21,12.62) v2(336.21,11.98) v2(336.21,11.35) v2(336.84,12.62) v2(336.84,11.98) v2(336.84,11.35) v2(337.48,12.62) v2(337.48,11.98) v2(337.48,11.35) v2(338.11,12.62) v2(338.11,11.98) v2(338.11,11.35) v2(338.75,12.62) v2(338.75,11.98) v2(338.75,11.35) v3(52.49,16.47)
+PWR_SRC_MXM:
  vias: v2(225.88,90.63) v2(225.91,89.96) v2(225.89,89.35) v2(225.88,88.73) v2(226.25,88.12) v2(226.48,90.57) v2(226.53,89.95) v2(226.52,89.34) v2(226.48,88.73) v2(226.81,103.79) v2(227.13,89.96) v2(227.12,89.34) v2(227.09,88.73) v2(227.19,104.38) v2(227.42,103.79) v2(227.56,105.01) v2(227.78,104.36) v2(228.02,103.79) v2(228.17,104.99) v2(228.38,104.39) v2(228.64,103.79) v2(228.83,104.99) v2(229.06,104.27) v2(229.4,104.8) v3(229.05,90.28)
+PWR_SRC_R: length 4.1
  TOP w0.102: v3(74.27,32.02) 73.77,32.02 73.16,32.63 RZ73.2
  TOP w0.508: JUSH1.26 73.05,33.3 RZ73.2
+REGCTL_PNP10: length 10.5
  TOP w0.203: v2(250.93,113.81) U31.7
  TOP w0.508: L29.1 v2(242.42,112.99)
  IN2 w0.508: v2(242.42,112.99) 243.25,113.81 v2(250.93,113.81)
+RSVD_VCC3P3_2:
  vias: v1(255.2,113.35)
+RTC_CELL: length 483
  TOP w0.305: v2(310.48,33.81) 310.49,33.81 310.5,33.8 JIO1.60
  TOP w0.508: RH198.1 130.67,130.18 131.04,129.82 v2(131.31,129.82)
  IN1 w0.508: v2(73.51,59.04) 74.19,58.36 74.19,37.16 71.46,34.44 61.93,34.44 60.14,32.65 55.92,32.65 55.43,33.13 52.73,33.13 51.82,32.23 51.82,29.94 51.03,29.15 47.74,29.15 46.32,30.58 v2(46.32,31.16)
  IN2 w0.508: v2(131.31,129.82) 131.31,129.17 131.87,128.61 132.82,128.61 133.47,129.26 133.47,131.26 v2(134.01,131.8) 134.42,132.21 140.61,132.21 141.39,133 141.39,134.17 143.41,136.19 145.98,136.19 146.57,136.79 151.02,136.79 151.05,136.76 152.59,136.76 153.74,137.92 155.18,137.92 155.93,137.17 155.93,136.6 157.09,135.44 160.13,135.44 160.58,134.99 164.64,134.99 165.6,134.03 166.86,134.03 167.23,133.66 167.39,133.66 168.57,132.48 173.62,132.48 174.69,133.55 179.44,133.55 179.81,133.18 179.81,133.06 180.83,132.04 183.52,132.04 184.31,132.84 186.45,132.84 187.79,131.49 189.81,131.49 189.84,131.53 194.73,131.53 196.73,133.52 197.76,133.52 198.61,132.67 206.99,132.67 v2(207.94,131.72) 209.41,133.18 212.83,133.18 213.21,132.8 213.94,132.8 215.52,134.39 226.64,134.39 227.12,133.91 v2(227.12,133.88) ; v2(230.93,100.86) 230.93,97.34 236.01,92.26 236.01,92.16 238.81,89.36 239.59,89.36 241.33,87.62 243.08,85.87 243.08,83.85 247.1,79.83 248.18,79.83 257.79,70.22 257.79,68.01 259.78,66.02 259.78,64.28 276.66,47.4 281.17,47.4 285.11,43.45 290.71,43.45 293.23,40.93 293.23,40.25 297.18,36.31 300.35,36.31 300.99,35.67 303.98,35.67 305.48,37.17 308.59,37.17 309.1,36.66 309.1,35.19 v2(310.48,33.81) ; v2(73.51,59.04) 79,59.04 86.11,66.14 86.11,77.64 95.57,87.1 103.42,94.96 103.42,96.42 101.55,98.3 101.55,100.33 100.25,101.63 100.25,104.35 101.13,105.24 v2(101.13,107.67)
  IN3 w0.508: v2(209.71,120.38) 209.59,120.5 209.59,125.94 208.7,126.83 208.7,130.96 v2(207.94,131.72) ; v2(227.12,133.88) 228.9,132.1 228.9,128.68 233.07,124.51 233.07,121.85 232.71,121.5 232.71,110.52 234.29,108.93 234.29,103.11 232.04,100.86 v2(230.93,100.86) ; v2(131.31,129.82) 130.29,130.83 126.05,130.83 125.66,131.22 v2(124.25,131.22) 124.25,131.68 123.64,132.29 120.84,132.29 120.31,132.82 119.24,132.82 116.66,135.4 115.4,135.4 112,132 108.32,132 107.77,132.54 102.99,132.54 102.09,131.64 101.4,131.64 100.74,132.3 100.05,132.3 99.34,131.59 99.34,131.31 98.78,130.75 97.6,130.75 91.65,124.8 91.65,117.53 93.36,115.82 95.44,115.82 97.72,113.54 97.72,109.39 99.45,107.67 v2(101.13,107.67)
  BOTTOM w0.102: v3(101.96,107.46) 101.76,107.67 v2(101.13,107.67)
  BOTTOM w0.508: v2(134.01,131.8) 133.73,131.52 RH201.1 133.39,130.76 RH200.1 ; PC2.1 47.5,28.91 PD1.1 46.8,30.15 46.32,30.63 v2(46.32,31.16) ; R870.1 R880.1 207.23,119.51 R1985.1 R810.1 208.9,119.52 R819.1 v2(209.71,120.38) ; v2(124.25,131.22) 124.27,131.2 RH297.1
+RTC_CELL_VBAT: length 10.9
  TOP w0.508: v2(207.03,118.07) 207.03,118.18 206.91,118.3 206.91,118.31 206.02,119.2 204.67,119.2 v1(204.16,118.69) 203.5,118.03 203.5,115.85 202.71,115.06 v2(202.71,114.92)
  BOTTOM w0.305: U51.B64 202.5,115.45 202.67,115.28 202.67,114.95 v2(202.71,114.92)
  BOTTOM w0.508: R1985.2 C1353.1 207.25,117.73 207.03,117.95 v2(207.03,118.07)
+SDC_IN: length 430.3
  TOP w0.254: PR1015.1 334.57,47.65 335.19,47.03 336.65,47.03 v2(336.73,47.12)
  TOP w0.457: PR719.2 271.68,36.16 v2(271.99,35.85)
  TOP w0.508: v2(298.97,10.5) 298.97,12.06 299.76,12.86 299.76,15.21 298.38,16.59 298.38,17.24 298.05,17.58 298.05,18.91 v2(295.03,21.93) ; 38.78,37.93 38.78,38.82 36.11,41.49 32.11,41.49 31.67,41.04 PR769.1
  IN1 w0.508: v2(250.3,9.35) 251.05,8.6 251.05,6.84 v2(251.03,6.81) ; v2(47.98,19.64) 49.89,19.64 51.73,17.8 51.73,13.99 54.14,11.58 54.14,8.02 55.22,6.94 61.83,6.94 v2(64.69,9.8)
  IN2 w0.508: v2(275.77,38.65) 275.77,34.55 277.2,33.12 277.2,32.51 277.19,32.51 277.19,29.98 279.92,27.26 287.58,27.26 292.91,21.93 v2(295.03,21.93) 295.54,21.42 298.46,21.42 299.65,22.61 303.17,22.61 303.99,23.43 306.93,23.43 309.2,21.16 325.5,21.16 326.27,21.93 330.6,21.93 331.56,22.88 335.69,22.88 337.99,25.18 337.99,33.92 337.65,34.26 337.65,43.25 338.27,43.86 338.27,45.58 v2(336.73,47.12)
  IN3 w0.508: v2(251.03,6.81) 253.35,6.81 262.01,15.48 264.76,15.48 265.3,16.02 v2(270.51,16.02) ; v2(250.3,9.35) 242.36,9.35 240.79,7.78 217.44,7.78 216.15,6.48 192.88,6.48 191.32,8.05 181.98,8.05 180.26,6.32 162.05,6.32 158.3,10.07 144.35,10.07 142.35,8.07 139.77,8.07 139.68,7.98 139.17,7.98 139.08,8.07 138.93,8.07 137.52,6.66 126.92,6.66 126.53,7.04 110.03,7.04 107.39,9.68 91.32,9.68 88.51,12.49 74.68,12.49 72.81,10.62 71.1,10.62 70.21,9.74 64.75,9.74 v2(64.69,9.8)
  IN4 w0.508: v2(298.97,10.5) 298.97,9.75 298.15,8.94 294.52,8.94 294.02,8.44 280.71,8.44 273.13,16.02 v2(270.51,16.02) ; v2(44.91,31.52) 45.23,31.2 45.23,30.48 44.78,30.04 44.78,28.65 48.37,25.06 48.37,21.29 47.98,20.91 v2(47.98,19.64)
  BOTTOM w0.508: v2(271.99,35.85) 271.64,36.2 PR1036.1 271.95,37.23 v1(272.56,37.84) 272.97,38.25 275.37,38.25 v2(275.77,38.65) ; PC700.1 37.63,35.77
  vias: v2(36.35,37.84) v2(36.38,36.88) v2(36.73,37.36) v2(37.12,36.88) v2(37.27,37.66) v2(37.35,36.32) v2(37.76,36.88) v2(37.99,36.32) v2(38.39,36.88) v2(38.62,36.32) v2(39.03,36.88) v2(39.26,36.32) v2(39.66,36.88) v2(39.89,36.32) v2(40.31,36.9) v2(40.52,36.34) v2(40.92,36.9) v2(41.51,36.93)
+SDC_IN_J:
  vias: v1(47.58,28.26) v2(46.33,31.9) v2(46.97,31.9) v2(46.99,31.22) v2(47.6,31.9) v2(47.64,31.24) v2(48.24,31.9) v2(48.28,31.24) v2(50.46,25.48) v2(50.46,24.85) v2(50.46,24.21) v2(50.46,23.58) v2(51.1,24.91) v2(51.1,24.28) v2(51.1,23.64)
+SIM_PWR: length 32.1
  IN3 w0.508: v2(322.41,31.96) 323.35,31.96 327,28.32 334.28,28.32 335.55,27.04 335.55,26.44 334.62,25.52 334.62,24.59 333.29,23.26 333.29,21.78 332.87,21.36 v2(332.72,21.36)
  BOTTOM w0.305: JNGFF2.28 322.2,32.18 v2(322.41,31.96)
  BOTTOM w0.508: JSIM1.9 339.77,20.54 338,20.54 v3(337.39,19.93) 336.73,19.27 C1356.1 334.8,19.27 v2(332.72,21.36)
+TRM_CT1: length 4.8
  TOP w0.102: v1(240.39,122.51) 240.88,123 C479.1
  TOP w0.508: C479.1 240.53,124.1 240.53,125.12 241.3,125.9 T156.3
+TRM_CT2: length 5.4
  TOP w0.102: v1(243.49,122.45) 243.06,122.45 241.9,123.61 C480.1
  TOP w0.508: T156.4 242.57,124.43 C480.1
+TRM_CT3: length 8.3
  TOP w0.508: C484.1 253.47,122.51 250.3,122.51 v1(248.96,123.85) 248.92,123.88 T156.9
+TRM_CT4: length 6.7
  TOP w0.508: T156.10 250.19,123.88 v1(250.8,123.27) 253.47,123.27 C486.1
+U637_TPM: length 4.8
  TOP w0.508: v2(189.78,125.48) 189.78,125.64 189.46,125.96 CZ5.1 190.44,126.59 RZ79.2 190.5,126.13 190.73,125.91 RZ78.2
  BOTTOM w0.254: U637.8 190,125.69 v2(189.78,125.48)
+U638_PWR: length 4.7
  TOP w0.102: U638.5 106.77,121.01 106.68,120.92 106.35,120.92 106.23,120.8 RH349.2 105.67,120.11 105.41,119.86 v1(105.41,119.76) 105.41,119.02 RH350.2
+V_DDR_REF: length 5.9
  BOTTOM w0.102: PC209.1 59.34,13.77 59.34,13.05 58.88,12.59 v3(56.94,12.59)
  BOTTOM w0.203: PU200.4 59.38,15.03 58.78,14.43 PC209.1
+V_DDR_REFCA_A: length 30.6
  TOP w0.305: JDIMM1.164 123.04,57.92 122.45,58.52 122.45,58.81 122.42,58.83 v2(122.42,58.92)
  TOP w0.508: v1(142.47,58.87) CD77.1 CD78.1 CD76.1 CD128.1 ; CD128.1 RD10.1 CD75.1 RD9.2 135.82,58.57 135.82,57.96 135.64,57.78 v2(135.64,57.59) ; CD128.1 RD23.2
  IN2 w0.508: v2(122.42,58.92) 122.42,59.28 123.15,60.01 135.06,60.01 135.64,59.43 v2(135.64,57.59)
  BOTTOM w0.254: JDIMM2.164 134.08,57.92 134.28,58.12 135.11,58.12 v2(135.64,57.59)
+V_DDR_REFCA_B: length 54
  TOP w0.305: JDIMM3.164 108.37,57.92
  TOP w0.508: CD80.1 CD82.1 CD81.1 v2(104.64,57.86) ; CD80.1 107.36,57.92 108.37,57.92 ; CD80.1 107.37,57.78 CD79.1 CD143.1 RD14.1 107.37,54.18 RD11.2 ; RD45.2 140.12,55.32 v1(141.32,54.12) 141.8,53.64 141.8,52.76 v2(141.79,52.75)
  IN2 w0.508: v2(104.64,57.86) 104.71,57.92 v2(120.05,57.92) 120.23,57.74 132.12,57.74 134.03,55.84 138.71,55.84 141.79,52.76 v2(141.79,52.75)
  BOTTOM w0.254: v2(120.05,57.92) JDIMM4.164
+VCHGR:
  vias: v3(268.96,16.53)
+VR_CAP: length 2.9
  TOP w0.508: C779.1 203.07,110.13 v2(203.38,109.82)
  BOTTOM w0.305: U51.B12 205.03,109.68 204.54,109.68 204.28,109.94 203.5,109.94 v2(203.38,109.82)
  vias: v1(203.77,110.21)
+VTR_ADC: length 4
  BOTTOM w0.279: U51.A58 201.25,116.85 201.14,116.96 v1(201.14,117.63) 201.14,118.46 C736.1
  BOTTOM w0.508: R845.2 199.19,118.65 C757.1 C736.1
A_ON: length 81.5
  TOP w0.102: R878.1 154.79,125.73 v2(155.14,126.08) ; v2(211.01,112.62) 211.01,114.37 210.6,114.79 210.6,116.7 209.63,117.66 209.63,119.23 208.63,120.23 208.63,121.93 207.41,123.15 207.41,125.84 v1(206.48,126.77) 206.1,127.15 v2(206.1,128.8)
  IN2 w0.127: v2(155.14,126.08) 156.55,124.67 165.57,124.67 166.76,123.49 167.39,123.49 167.58,123.29 168.85,123.29 169.53,123.97 173.07,123.97 174.4,125.31 176.27,125.31 176.9,124.67 178.99,124.67 180.64,126.32 181.45,126.32 182.45,125.32 185.53,125.32 186.53,126.31 189.06,126.31 189.79,127.05 193.26,127.05 193.93,127.72 195.46,127.72 195.97,128.23 201.24,128.23 201.98,128.96 205.93,128.96 v2(206.1,128.8)
  BOTTOM w0.102: v2(211.01,112.62) 211.01,113.41 210.74,113.69 208.26,113.69 207.98,113.41 R432.2 207.47,113.19 207.21,113.45 206.41,113.45 206.32,113.36 U51.A4
A_ON_R: length 3.8
  TOP w0.102: R878.2 154.79,123.65 v1(154.5,123.36) 153.95,122.82 R877.2 153.83,122.32 UZ28.3
AAC_SMBCLK: length 5.5
  TOP w0.102: R39.1 245.77,103.53 R41.1 R3738.2 245.77,101.3 T210.1 246.21,100.86 U8.20
AAC_SMBDAT: length 6.9
  TOP w0.102: R40.1 241.91,102.13 R38.1 R3739.2 243.31,102.12 243.31,101.37 243.61,101.07 T209.1 244.73,101.07 245.41,100.39 U8.21
AAEN: length 96.8
  TOP w0.102: U8.18 247.81,97.3 247.59,97.08 246.03,97.08 245.15,97.95 244.23,97.95 243.7,98.48 243.7,100.09 243.22,100.57 243.04,100.57 241.92,101.7 241.37,101.7 239.8,103.26 239.8,103.52 239.02,104.29 237.98,104.29 237.67,104.6 234.12,104.6 229.93,108.79 226.42,108.79 226.18,108.55 225.81,108.55 225.57,108.79 225.57,109.13 226.48,110.04 226.98,110.04 227.98,111.04 227.98,112.91 227.6,113.3 225.54,113.3 v1(224.36,114.47) 223.44,115.4 v2(221.59,115.4)
  IN2 w0.127: v2(178.46,113.89) 179.14,113.22 181.79,113.22 182.16,112.85 183.06,112.85 183.96,112.85 185.16,114.05 186.44,114.05 189.15,111.33 189.73,111.33 190.54,112.15 190.54,113.71 191.32,114.49 192.02,114.49 192.65,115.12 192.65,116.59 193.02,116.96 195.06,116.96 195.97,116.05 204.96,116.05 205.72,116.81 209.59,116.81 209.78,116.62 210.08,116.62 210.88,115.83 211.73,115.83 213.61,113.95 215.82,113.95 216.98,115.12 218.57,115.12 218.85,115.4 v2(221.59,115.4)
  BOTTOM w0.102: U46.B6 177.8,115.02 177.91,114.92 177.91,114.45 177.93,114.42 177.93,114.42 v2(178.46,113.89)
AC_DIS: length 511.4
  TOP w0.102: v2(23.85,22.22) 23.85,22.23 23.36,22.23 22.25,23.34 20.38,23.34 18.73,21.69 v1(18.11,21.69) 16.29,21.69 15.9,22.07 PQ8.5
  TOP w0.254: PR1030.2 340.7,57.61 v2(340.32,58)
  IN1 w0.109: v2(164.34,86.66) 164.06,86.94 164.06,88.6 161.22,91.44 160.22,91.44 158.32,93.34 158.01,93.34 157.34,94.01 157.34,98.19 158.24,99.1 159.05,99.1 159.79,99.83 160.99,99.83 161.95,100.79 166.07,100.79 168.31,103.03 168.31,103.6 169.06,104.35 170.47,104.35 171.59,105.48 171.59,105.9 172.21,106.52 v2(172.21,106.67)
  IN2 w0.127: v2(249.97,92.06) 253.19,88.84 253.19,86.05 254.33,84.91 254.33,79.11 257.45,76 257.45,74.72 260.65,71.53 260.65,69.19 262.64,67.2 262.64,66.29 278.67,50.26 283.63,50.26 286.63,47.26 295.52,47.26 296.57,46.21 310.35,46.21 310.64,46.5 313.93,46.5 315.74,44.69 317.2,44.69 318.12,43.77 320.54,43.77 322.89,46.12 325.46,46.12 328.01,48.67 328.38,48.67 330.5,50.79 335.22,50.79 336.85,52.43 339.98,52.43 340.36,52.81 340.36,57.96 v2(340.32,58) ; v2(225.19,95.44) 224.93,95.18 224.93,93.45 227.62,90.77 227.62,88.55 225.12,86.05 v2(223.47,86.05) ; v2(179.65,85.83) 179.29,86.19 178.71,86.19 176.74,88.16 164.77,88.16 164.34,87.73 v2(164.34,86.66) 164.33,86.66 164.33,86.77 162.95,88.16 156.18,88.16 151.9,83.88 144.13,83.88 143.39,84.63 138.71,84.63 138.24,85.1 136.91,85.1 136.14,85.87 132.08,85.87 131.44,86.51 126.18,86.51 125.09,85.43 123.74,85.43 122.91,86.25 117.18,86.25 116.81,86.62 111.47,86.62 110.72,85.87 108.05,85.87 106.64,84.46 105.83,84.46 105.17,83.8 102.82,83.8 99.72,80.7 98.44,80.7 98.44,80.7 98.23,80.7 92.14,74.62 92.14,62.22 78.65,48.72 75.51,48.72 73.72,46.93 73.72,46.72 73.72,46.72 73.72,46.63 67.13,40.03 66.94,40.03 66,39.1 58.82,39.1 57.07,40.85 53.06,40.85 51.99,41.93 51.99,44.7 50.73,45.96 48.44,45.96 48.37,46.02 38.5,46.02 37.51,47.01 34.61,47.01 31.89,44.29 31.89,39.08 38.71,32.26 38.71,31.8 38.1,31.19 36.96,31.19 36.5,30.73 36.5,26.92 37.7,25.73 37.7,22.17 38.94,20.93 38.94,18.89 38.26,18.21 25.9,18.21 23.85,20.25 v2(23.85,22.22)
  IN3 w0.127: v2(249.97,92.06) 248.76,93.26 247.71,93.26 246.45,94.53 246.45,94.59 245.24,95.79 243.71,95.79 242.12,97.39 241.43,97.39 237.49,101.33 234.67,101.33 231.75,98.41 231.75,98.16 228.64,95.04 227.57,95.04 226.79,95.82 225.57,95.82 v2(225.19,95.44) ; v2(223.47,86.05) 223.47,86.08 222.75,85.35 222.75,82.75 216.12,76.12 195.83,76.12 195.42,76.53 194.18,76.53 192.89,77.82 192.66,77.82 192.46,78.02 192.46,79.65 191.47,80.64 191.47,81.49 186.88,86.09 179.9,86.09 v2(179.65,85.83)
  BOTTOM w0.102: U46.A50 173.54,107.51 173.44,107.61 172.95,107.61 172.42,107.08 172.42,106.89 172.2,106.67 v2(172.21,106.67)
