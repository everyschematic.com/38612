# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N42901769: length 3.1
  BOTTOM w0.102: R42.2 119.36,144.8 119.42,144.87 119.42,145.44 v1(119.55,145.56) 119.68,145.56 120.19,145.05 U33.3
N42905932: length 4.3
  TOP w0.102: RZ77.2 195.84,128.88 195.95,128.77 v1(195.95,128.57) 195.95,128.37 195.72,128.14 v2(195.1,128.14)
  BOTTOM w0.102: RZ83.2 195.55,128.14 v2(195.1,128.14) 194.69,128.55 U637.29
N43194116: length 5.4
  TOP w0.254: PD704.1 34.78,38.06 34.55,38.29 33.86,38.29 v1(33.38,37.8) 32.9,38.29 32.45,38.29 32.26,38.09 PQ708.3 32.26,36.9 PR766.1
N43194174: length 5.6
  TOP w0.254: PQ708.5 31.61,39.27 31.41,39.07 31.09,39.07 30.96,39.21 PQ708.6 30.96,40.39 PR769.2 29.95,40.6 v1(29.57,40.22) PR770.1
N43204552: length 4
  BOTTOM w0.102: PQ1005.3 269.06,40.99 PR1033.1 v1(267.82,41.22) 267.05,41.22 266.42,40.6 PD1101.1
N43204589: length 6.1
  BOTTOM w0.102: 270.36,40.34 PQ1005.2 268.77,40.34 v1(268.71,40.28) ; 270.36,40.34 270.62,40.6 270.62,41.23 269.73,42.12 PR1034.2 ; 270.36,40.34 270.62,40.09 270.62,38.49 PR1035.1
N43204609: length 6
  BOTTOM w0.102: PR1037.1 PR1036.2 271.69,38.19 PQ1005.6 272.44,39.69 272.58,39.83 v1(272.58,40.03) 272.58,40.22 272.46,40.34 PQ1005.5
N43339931: length 3.8
  TOP w0.102: QZ2.2 196,126.27 v1(197.54,127.81) RZ84.2
N43843335: length 11.9
  TOP w0.254: PR768.2 31.96,38.79 31.61,38.44 PQ708.2 31.61,36.73 PR767.1 v1(31.54,35.64) 27.64,35.64 26.98,36.3 26.98,37.29 26.52,37.75 PQ1073.5
N43843360: length 3.5
  TOP w0.102: PR772.2 v1(27.69,41.84)
  TOP w0.254: PQ1073.3 27.69,38.44 PR771.2 PR772.2
N43843390: length 2.3
  TOP w0.102: v1(25.18,39.5) 25.85,40.18 PR773.2
  TOP w0.254: PR772.1 PR773.2
N43901142: length 6
  TOP w0.254: PR1026.1 325.21,50.13 325.21,49.85 v1(323.85,48.49) 323.32,47.96 322.65,47.96 322.13,47.44 PD1103.1
N43901144: length 8.7
  TOP w0.254: PD1102.1 323.83,47.75 324.57,48.48 v1(325.62,48.48) v2(326.14,48.48) ; PR1010.1 v2(328.38,52.15)
  IN3 w0.254: v2(326.14,48.48) 326.14,48.79 328.38,51.02 v2(328.38,52.15)
N43928875: length 17.9
  TOP w0.203: PU700.21 274.28,29.63 v2(274.36,29.54)
  TOP w0.254: PR764.1 272.6,24.45 272.85,24.7 v1(272.85,24.87) 272.85,25.13 v2(272.63,25.36) 272.56,25.43 272.56,26.26 272.05,26.77 271.03,26.77 270.75,26.49 269.93,26.49 269.3,25.86 PR758.2 269.3,24.52 PQ707.1
  IN1 w0.254: v2(272.63,25.36) 272.47,25.51 272.47,27.74 271.66,28.56 271.66,30 272.35,30.69 273.21,30.69 v2(274.36,29.54)
N43928883: length 4.1
  TOP w0.254: PR760.2 271.96,25.91 271.67,26.2 v1(271.67,26.19) 271.67,26.2 v2(271.14,26.2) ; v2(270.4,24.61) 270.73,24.28 PQ707.6
  IN3 w0.254: v2(270.4,24.61) 271.14,25.36 v2(271.14,26.2)
N44147068: length 3.5
  TOP w0.254: PQ1074.2 338.88,44.11 339.22,43.77 v1(339.22,42.95) 339.22,42.57 338.62,41.96 PU105.4
N44206069: length 4.2
  TOP w0.102: T217.1 205.85,89.83 206,89.69 JMXM1.67
N45812508: length 1.2
  TOP w0.102: v1(75.96,15.58) 76.28,15.26 PC501.1
N53085144:
  vias: v1(65.49,19.48)
N53085275: length 4.9
  BOTTOM w0.102: PR205.2 55.75,18.54 54.64,18.54 54.16,18.05 v1(54.16,17.8)
  BOTTOM w0.203: PU200.9 57.6,17.82 57.35,18.07 56.75,18.07 56.61,17.93 PR205.2
N53866851: length 2.4
  BOTTOM w0.102: C747.1 197.65,102.5 197.65,101.95 v1(197.65,101.94) 197.28,101.94 197.14,102.09 R885.2
N66037766: length 8.2
  TOP w0.102: R1167.2 v1(248.9,144.48) 247.56,144.48 JLOM1.11
N66058065: length 5.8
  TOP w0.102: JLOM1.10 248.08,146.25 v1(249.08,146.25) 249.34,146.25 249.88,145.71 R1170.2
N66078140: length 4.5
  TOP w0.102: v1(227.8,147.35) R1171.2 230.43,147.35 JLOM1.13
N66971793: length 2.8
  TOP w0.203: PR105.2 347.87,29.55 348.04,29.73 ; 348.04,29.73 348.65,30.34 PU101.5 ; 348.04,29.73 v1(348.04,29.72)
N66972075: length 2.1
  TOP w0.203: PU101.1 348.84,31.94 348.56,32.21 v1(348.09,32.21) 347.23,32.21 PR106.2
N94639990: length 3.4
  BOTTOM w0.102: v1(105.87,154.79) 106.08,154.79 106.44,155.15 U3.4 107.36,155.15 107.67,154.83 107.67,154.46 D68.2
N97449521: length 4
  TOP w0.102: R956.1 301.81,11.06 Q359.1 302.67,12.72 v1(301.92,13.47)
N104731395: length 1.4
  TOP w0.102: v1(12.9,52.68) 12.74,52.84 PC400.1
N104731470: length 1.2
  TOP w0.102: PC405.1 v1(15.82,52.2)
N106386290: length 1
  BOTTOM w0.102: RE1.2 CE1.1

## Copper pours and planes (outline as drawn)
1.2V_B+ on BOTTOM (solid shape): 74.32,21.44 74.32,16.28 74.58,16.01 79.17,16.01 79.67,15.51 79.67,13.93 79.54,13.8 79.16,13.8 79.16,14.37 77.77,14.37 77.77,13.8 71.54,13.8 70.34,15.01 68.24,15.01 67.48,15.77 67.47,15.77 66.71,16.53 66.71,18.77 67.61,19.66 67.61,20.78 67.73,20.91 72.69,20.91 73.32,21.55 74.21,21.55
+0.6V_DDR_VTT on TOP: 111.36,81.19 109.59,81.19 109.44,81.03 108.94,81.03 106.09,78.18 106.09,76.73 106.21,76.6 106.53,76.6 106.66,76.47 106.66,76.16 105.83,75.33 105.83,73.74 105.64,73.55 103.48,73.55 102.53,72.6 100.56,72.6 99.55,73.62 99.55,76.09 100.18,76.73 100.18,76.86 100.5,77.17 100.5,78.89 101.2,79.59 104.94,79.59 107,81.64 111.39,81.64 111.46,81.57 111.46,81.29
+0.6V_DDR_VTT on TOP: 130.59,89.5 132.63,89.5 133.18,88.95 133.93,88.95 134.21,88.67 134.21,87.94 134.05,87.78 130.6,87.78 130.34,87.52 129.33,87.52 128.44,88.41 128.44,89.56 128.76,89.87 130.22,89.87
+0.6V_DDR_VTT on BOTTOM: 119.61,81.67 118.02,81.67 117.92,81.57 117.92,81.34 118.04,81.21 120.63,81.21 120.94,81.52 120.94,85.55 120.68,85.81 119.93,85.81 119.72,85.6 119.72,84.47 119.71,84.46 119.71,82.3 119.83,82.19 119.83,81.97 119.61,81.76
+0.6V_DDR_VTT on BOTTOM: 134.33,81.23 131.99,81.23 131.92,81.3 131.92,81.56 131.98,81.63 133.58,81.63 133.82,81.87 133.82,84.81 132.28,86.35 132.28,88.51 132.44,88.67 134.46,88.67 134.97,88.16 134.97,82.99 134.61,82.63 134.61,81.51
+0.6V_DDR_VTT on BOTTOM: 67.06,14.99 67.05,14.99 66.53,15.51 65.71,15.51 65.19,14.99 63.38,14.99 63.25,14.86 63.25,13.66 63.25,13.65 63.81,13.65 63.81,13.65 63.81,13.18 63.81,13.18 63.26,13.18 63.25,13.17 63.25,12.92 63.27,12.9 67.26,12.9 67.42,13.06 67.42,14.63
+0.6V_DDR_VTT on IN2: 66.81,15.56 65.77,15.56 65.55,15.34 63.42,15.34 63.16,15.08 63.16,14.01 64.19,12.99 67.72,12.99 68.75,11.95 76.16,11.95 78.64,14.43 93.39,14.43 99.8,20.85 99.8,33.9 100.93,35.03 100.93,41.94 100.9,41.97 100.9,68.82 102.79,70.71 102.79,74.45 102.2,75.04 101.2,75.04 98.32,72.16 98.32,72.03 97.72,71.42 97.72,41.96 95.93,40.17 95.93,27.49 90.33,21.89 78.03,21.89 73.92,17.77 69.02,17.77
+0.6V_DDR_VTT on IN3: 108.56,80.92 118.15,80.92 120.6,83.36 120.6,85.21 120.31,85.49 119.74,85.49 116.88,82.63 108.88,82.63 108.25,82 108.25,81.24
+0.6V_P on BOTTOM: 60.07,15.11 60.08,15.11 60.08,16.26 60.14,16.32 60.22,16.32 60.28,16.26 60.28,15.39 60.48,15.2 60.73,15.2 61.05,15.51 61.05,16.4 60.88,16.57 60.88,16.67 60.94,16.72 61.75,16.72 61.81,16.66 61.81,16.24 63.12,14.93 63.12,13.64 63.12,13.64 63.12,13.55 63.16,13.52 63.66,13.52 63.67,13.51 63.67,13.33 63.66,13.32 63.12,13.32 63.11,13.31 63.11,12.92 62.85,12.66 61.26,12.66 60.6,13.31 60.6,14.26 60.07,14.79
+0.9V_LAN on BOTTOM: 249.03,107.46 245.6,107.46 242.04,111.02 242.04,111.53 245.09,114.57 245.34,114.57 245.98,115.21 253.34,115.21 255.63,112.92 255.63,107.65 256.2,107.08 257.66,107.08 258.04,106.7 258.04,105.62 257.41,104.99 255.25,104.99 252.95,107.29 252.95,111.78 252.38,112.35 251.57,112.35 250.99,111.78 248.8,111.78 248.52,111.49 248.52,109.68 248.9,109.3 248.96,109.3 249.47,108.8 249.47,107.91
+1.0V_ALW_PCH on TOP: 110.2,102.83 110.2,101.94 110.01,101.75 107.99,101.75 107.36,102.38 107.36,102.89 108.44,103.97 109.2,103.97 109.33,103.84 109.33,103.21 109.52,103.02 110.01,103.02
+1.0V_ALW_PCH on BOTTOM: 110.62,108.01 110.84,108.01 111.06,107.8 111.06,106.56 111.06,106.56 111.06,105.64 110.59,105.17 105.76,105.17 104.47,106.46 104.47,108.11 104.79,108.43 110.2,108.43
+1.0V_ALW_PCH on BOTTOM: 134.68,99.86 136.1,101.28 136.1,104.35 138.66,106.92 138.66,113.49 138.19,113.97 137.23,113.97 137.01,113.75 137.01,109.54 137.01,109.53 137.01,109.26 136.72,108.97 136.45,108.97 134.85,107.38 127.4,107.38 126.95,106.93 126.95,103.67 126.36,103.08 125.58,103.08 125.52,103.02 123.3,103.02 122.79,102.51 122.03,102.51 122.03,101.94 120.63,101.94 120.63,102.51 119.93,102.51 119.42,103.02 117.2,103.02 116.56,102.38 113.94,102.38 113.39,102.93 111.87,102.93 111.71,103.08 107.48,103.08 107.36,102.95 107.36,101.36 108.16,100.55 108.25,100.55 109.4,99.4 130.22,99.4 130.68,99.86
+1.0V_ALW_PCH on IN2: 110.26,102.93 110.27,102.92 110.27,102.06 109.67,101.47 106.5,101.47 104.19,103.78 104.19,108.23 104.43,108.47 106.79,108.47 107.6,107.67 107.6,106.02 110.26,103.36
+1.0V_AMPHYPLL on TOP: 112.55,103.45 113,103.45 113.24,103.38 113.43,103.53 113.63,103.53 113.79,103.37 113.8,103.33 113.8,103.29 113.8,103.19 113.67,103.06 113.44,103.06 113.29,102.91 112.42,102.91 112.09,102.58 112.09,101.59 112.12,101.1 112.6,101 112.61,101.01 112.71,101.01 113.07,101.36 113.07,101.36 113.84,102.13 113.84,102.53 114.05,102.73 114.05,102.86 114.14,102.95 114.29,102.95 114.45,102.79 114.45,102.54 114.27,102.27 114.48,102.03 114.48,101.81 113.39,100.71 113.39,100.56 113.12,100.29 110.45,100.29 110.43,100.31 110,100.31 109.64,100.67 109.64,101.3 109.77,101.43 110.15,101.43 110.32,101.6 110.32,103.02 110.07,103.27 109.77,103.27 109.64,103.4 109.64,103.91 109.71,103.97 112.02,103.97
+1.0V_CLK2 on BOTTOM: 126.32,111.48 126.32,110.96 126.52,110.76 134.57,110.76 134.89,111.07 134.89,111.77 134.64,112.03 126.86,112.03
+1.0V_MPHY on BOTTOM: 116.85,105.24 118.82,103.27 119.42,103.27 119.99,102.7 122.72,102.7 123.3,103.27 126.34,103.27 126.66,103.59 126.66,107.67 124.9,109.43 124.9,111.37 124.65,111.62 118.11,111.62 117.45,110.97 116.2,110.97 115.55,110.32 115.55,106.07 116.37,105.24
+1.0V_MPHY on IN3: 123.7,111.49 121.68,111.49 121.52,111.34 121.52,110.47 121.92,110.08 124.53,110.08 124.66,110.21 124.66,110.53
+1.0V_PRIM on TOP (solid shape): outline of 90 points within 121.39,111.31 124.25,114.07
+1.0V_PRIM on TOP: 187.63,98.72 185.04,98.72 184.69,99.08 184.69,99.66 184.79,99.77 186.91,99.77 187.04,99.89 187.84,99.89 188.31,100.36 190.71,100.36 190.8,100.27 190.8,97.96 191.85,96.91 199.32,96.91 199.99,97.58 199.99,99.49 199.97,99.51 199.97,101.26 199.97,101.27 201.53,101.27 201.58,101.22 201.58,100.2 201.75,100.03 203.53,100.03 203.62,99.95 203.62,99.26 203.59,99.23 203.17,99.23 202.81,98.87 202.81,96.9 202.57,96.67 202.1,96.67 201.46,96.03 201.46,95.37 201.27,95.18 195.45,95.18 195.07,94.8 195.03,94.85 191.31,94.85 189.17,96.98 189.17,98.95 188.99,99.13 188.04,99.13
+1.0V_PRIM on BOTTOM: 110.58,108.37 112.03,108.37 112.24,108.59 112.24,110.07 111.99,110.32 111.54,110.32 111.22,110.64 108.88,110.64 108.5,110.26 108.5,108.99 108.82,108.67 110.28,108.67
+1.0V_PRIM on BOTTOM: 99.75,114.24 102.75,114.24 102.95,114.04 102.95,112.9 100.66,110.61 99.12,110.61 98.84,110.89 98.84,113.33
+1.0V_PRIM on VCC: 118.96,106.95 118.09,107.82 118.09,114.66 119.65,116.23 127.57,116.23 128.31,115.49 128.25,107.31 127.89,106.95
+1.0V_PRIM on IN3: 125.52,115.84 125.52,112.1 125.07,111.65 121.45,111.65 118.09,108.29 100.78,108.29 98.68,110.38 98.68,115.95 100.36,117.62 109.38,117.62 110.77,119.02 121.52,119.02 124.5,116.03 125.33,116.03
+1.0V_PRIMP on BOTTOM: 102.09,121.81 102.47,121.43 102.47,117.05 102.9,116.62 102.9,114.37 102.88,114.35 97.54,114.35 94.15,117.74 94.15,121.44 94.27,121.57 99.07,121.57 99.32,121.81
+1.0V_RUN on TOP (solid shape): 7.73,51.45 8.29,51.45 8.81,50.93 8.81,50.62 8.7,50.5 7.28,50.5 7.03,50.76 6.33,50.76 6.07,51.01 6.07,51.68 6.15,51.76 7.42,51.76
+1.0V_RUN on TOP (solid shape): 179.87,100.36 179.96,100.28 179.96,99.73 180.49,99.73 180.49,99.48 179.96,99.48 179.96,98.95 179.96,98.95 179.96,98.93 180.49,98.93 180.49,98.68 179.96,98.68 179.96,98.66 179.96,98.66 179.96,98.08 179.73,97.85 178.4,97.85 178.26,97.99 178.26,100.2 178.43,100.36 179.84,100.36
+1.0V_RUN_PWR on TOP (solid shape): 181.92,99.78 183.2,99.78 183.3,99.68 183.3,99.02 183.43,98.89 184.07,98.89 184.57,98.38 184.57,97.62 184.26,97.3 181.39,97.3 181.36,97.35 181.33,97.4 181.3,97.44 181.26,97.47 181.22,97.5 181.17,97.52 181.12,97.53 181.07,97.54 181.02,97.54 180.99,97.53 180.22,97.53 180.09,97.66 180.09,98.32 181.13,98.32 181.13,98.26 181.15,98.21 181.17,98.16 181.19,98.12 181.23,98.08 181.26,98.04 181.31,98.01 181.36,97.99 181.41,97.97 181.46,97.96 181.51,97.96 181.57,97.97 181.62,97.99 181.67,98.01 181.71,98.04 181.75,98.08 181.78,98.12 181.81,98.16 181.83,98.21 181.84,98.26 181.84,98.32 181.84,98.37 181.83,98.42 181.81,98.47 181.78,98.52 181.75,98.56 181.71,98.6 181.67,98.63 181.62,98.65 181.57,98.67 181.51,98.67 181.46,98.67 181.41,98.67 181.36,98.65 181.31,98.63 181.26,98.6 181.23,98.56 181.19,98.52 181.17,98.47 181.15,98.42 181.13,98.37 181.13,98.32 180.09,98.32 180.09,98.55 180.61,98.55 180.61,99.06 180.09,99.06 180.09,99.35 180.61,99.35 180.61,99.86 180.09,99.86 180.09,100.32 180.12,100.35 180.19,100.35 180.19,100.35 181.35,100.35
+1.0V_VCCST on TOP (solid shape): 195.13,100.03 195.13,97.17 195.01,97.06 193.81,97.06 193.68,97.19 193.68,98.22 193.18,98.71 193.18,99.14 193.26,99.22 193.73,99.22 193.76,99.25 193.76,99.66 193.72,99.7 193.26,99.7 193.2,99.77 193.2,100.03 193.34,100.17 194.99,100.17
+1.0V_VCCST_UZ18 on TOP (solid shape): 193.03,101.15 193.03,99.58 193.06,99.55 193.59,99.55 193.6,99.54 193.6,99.38 193.59,99.37 193.06,99.37 193.04,99.36 193.04,98.79 192.87,98.61 191.15,98.61 191.08,98.69 191.08,100.08 191.44,100.45 191.44,101.54 191.53,101.63 192.55,101.63
+1.0V_VCCSTG on TOP (solid shape): 196.51,101.28 196.51,101.11 196.5,101.1 196.5,100.41 196.55,100.36 197.01,100.36 197.04,100.32 197.04,99.94 197.02,99.92 196.51,99.92 196.5,99.91 196.5,99.21 196.54,99.17 196.98,99.17 197.04,99.11 197.04,98.76 197.01,98.72 196.52,98.72 196.49,98.69 196.49,97.25 196.35,97.11 195.57,97.11 195.43,97.25 195.43,101.14 195.6,101.3 196.49,101.3
+1.0V_VCCSTG_C on TOP (solid shape): 197.92,102.46 197.92,101.63 198.76,100.79 198.77,100.79 199.03,100.54 199.52,100.54 199.67,100.39 199.67,98.61 199.43,98.37 199.43,97.58 199.18,97.33 197.01,97.33 196.65,97.68 196.65,98.55 196.68,98.58 197.21,98.58 197.22,98.59 197.22,99.34 197.21,99.35 196.67,99.35 196.67,99.78 196.68,99.79 197.22,99.79 197.22,100.53 197.21,100.54 196.66,100.54 196.65,100.55 196.65,101.07 196.98,101.4 196.98,102.99 197.06,103.07 197.31,103.07
+1.2V_MEM on TOP (solid shape): 144.71,22.21 144.71,19.29 144.38,18.96 140.89,18.96 140.36,19.49 140.36,22.56 140.68,22.88 144.04,22.88
+1.2V_MEM on TOP (solid shape): 152.75,57.17 152.75,50.02 152.57,49.84 150.27,49.84 149.89,50.22 149.89,56.94 150.35,57.41 152.51,57.41
+1.2V_MEM on TOP (solid shape): 48.73,14.82 48.73,12.15 48.53,11.95 47.05,11.95 46.92,12.07 46.92,12.24 47.08,12.4 47.46,12.4 47.77,12.71 47.77,13.87 47.46,14.18 47.46,14.94 47.59,15.07 48.48,15.07
+1.2V_MEM on BOTTOM (solid shape): 78.51,38.5 78.51,29.42 78.13,29.04 74.51,29.04 73.96,29.59 73.96,30.86 73.94,30.88 73.42,30.88 73.42,31.33 73.94,31.33 73.96,31.35 73.96,32.07 73.95,32.08 73.42,32.08 73.42,32.53 73.94,32.53 73.95,32.54 73.95,33.28 74.91,34.25 74.91,35.01 74.34,35.58 74.34,36.22 73.77,36.22 73.76,36.23 73.76,36.69 74.28,36.69 74.28,37.39 73.76,37.39 73.76,37.89 74.28,37.89 74.28,38.59 74.51,38.82 78.19,38.82
+1.2V_MEM on IN2 (solid shape): 95.67,36.49 95.67,29.33 95,28.66 75.97,28.66 75.59,29.04 75.59,36.59 75.97,36.98 95.18,36.98
+1.2V_MEM on TOP: outline of 89 points within 89.19,4.31 109.64,75.08
+1.2V_MEM on BOTTOM: 174.03,60.73 175.87,60.73 176.51,60.09 178.41,60.09 178.92,59.58 178.92,54 179.56,53.36 179.56,52.6 179.43,52.47 179.05,52.47 178.92,52.34 178.92,48.53 179.39,48.06 179.39,46.97 178.86,46.44 178.86,43.26 178.16,42.57 178.16,38.69 178.79,38.06 178.79,37.68 178.22,37.1 178.22,31.01 177.78,30.56 169.9,30.56 166.6,27.26 164,27.26 163.62,26.88 163.62,26.06 161.59,24.02 150.03,24.02 150,23.99 149.49,23.99 142.66,17.17 132.25,17.17 131.8,17.61 131.8,43.14 133.46,43.14 133.84,43.52 133.84,51.01 133.46,51.39 133.28,51.39 132.81,51.86 132.81,52.18 133.88,53.26 133.88,56.74 133.87,56.75 133.87,57.14 133.94,57.21 134.36,57.21 134.96,56.61 135.58,56.61 135.6,56.63 135.6,57.73 135.43,57.9 132.2,57.9 131.8,58.3 131.8,72.79 133.2,74.19 152.19,74.19 165.59,60.79 173.97,60.79 ; 4 cut-outs
+1.2V_MEM on IN1: 119.93,45.74 123.04,45.74 123.23,45.55 123.23,33.17 123.11,33.04 120.48,33.04 119.72,33.8 119.72,45.53
+1.2V_MEM on IN3: 132.15,31.1 114.15,31.1 110.85,34.4 110.85,42.37 113.33,44.85 123.11,44.85 124.95,46.69 150.73,46.69 155.05,51.01 155.05,55.84 152.7,58.19 145.58,58.19 136.06,67.71 136.06,76.92 135.61,77.36 107.8,77.36 92.94,62.5 92.94,32.34 92.93,32.34 92.93,20.43 97.8,15.55 106.92,15.55 109.63,12.84 136.11,12.84 140.24,16.96 142.08,16.96 144.82,19.71 144.82,29.17 140.06,33.93 134.98,33.93
+1.2V_MEN_P on TOP (solid shape): 64.3,31.71 71.35,31.71 72.61,30.45 72.61,25.97 72.05,25.42 68.05,25.42 66.02,27.45 61.56,27.45 60.81,28.2 60.81,31.83 61.13,32.15 63.86,32.15
+1.2V_MEN_P on BOTTOM (solid shape): 65.68,16.53 65.68,15.68 65.19,15.19 64.03,15.19 64.01,15.2 64.01,15.46 64.02,15.47 64.56,15.47 64.58,15.48 64.58,15.91 64.55,15.93 64.02,15.93 64,15.96 64,16.2 64.29,16.49 64.79,16.49 64.97,16.67 65.54,16.67
+1.2V_MEN_P on BOTTOM (solid shape): outline of 161 points within 65.62,28.72 74.15,38.88
+1.2V_MEN_P on IN2 (solid shape): 66.8,29.12 66.8,27.13 66.6,26.93 65.24,26.93 65.03,27.14 65.03,29.11 65.14,29.22 66.7,29.22
+1.2V_MEN_P on IN2: 65.5,15.48 64.3,15.48 64.19,15.59 64.19,17.32 64.38,17.51 65.6,17.51 65.76,17.35 65.76,15.74
+1.8V_ALW on TOP (solid shape): 240.63,81.49 240.63,79.9 240.56,79.84 239.86,79.84 239.61,80.09 239.61,80.55 239.41,80.75 239.41,81.52 239.59,81.69 240.42,81.69
+1.8V_ALW on BOTTOM (solid shape): 240.47,81.66 240.47,80.85 239.46,79.84 231.88,79.84 231.55,80.17 231.55,80.73 231.8,80.98 233.28,80.98 233.72,80.54 236.59,80.54 237.85,81.8 240.33,81.8
+1.8V_RUN on TOP: 246.35,80.1 246.35,77.94 244.63,76.22 244.07,76.22 243.92,76.37 243.92,76.95 245.41,78.43 245.57,78.43 245.6,78.46 245.6,78.98 245.6,79.06 245.6,79.06 245.06,79.06 245.04,79.09 245.04,79.32 245.06,79.34 245.57,79.34 245.6,79.37 245.6,79.87 245.59,79.88 245.06,79.88 245.04,79.9 245.04,80.11 245.06,80.13 245.6,80.13 245.6,80.54 245.91,80.54
+1.8V_RUN_PWR on TOP (solid shape): 244.1,82.44 244.1,81.72 245.03,80.79 245.32,80.79 245.47,80.64 245.47,80.26 244.91,80.26 244.91,79.75 244.94,79.73 245.44,79.73 245.47,79.7 245.47,79.47 244.94,79.47 244.91,79.45 244.91,78.96 244.94,78.94 245.44,78.94 245.47,78.91 245.47,78.68 245.39,78.61 244.1,78.61 243.95,78.76 243.95,79.01 243.12,79.84 242.09,79.84 241.99,79.94 241.99,82.22 242.34,82.57 243.97,82.57
+1.8VSP on BOTTOM (solid shape): 232.11,85.59 232.11,84.92 232.55,84.48 234.1,84.48 234.48,84.09 234.48,80.86 234.36,80.73 233.85,80.73 233.46,81.12 232.62,81.12 232.62,81.67 232.13,81.67 232.13,81.12 231.5,81.12 231.45,81.17 231.44,81.17 230.17,82.44 230.17,83.59 230.5,83.92 230.5,85.74 230.71,85.96 231.74,85.96
+1.8VSP_ON on BOTTOM (solid shape): 238.08,90.41 238.08,88.28 237.7,87.9 236.26,87.9 236.01,88.16 236.01,89.49 235.63,89.87 234.67,89.87 234.55,90 234.55,90.57 234.67,90.7 237.79,90.7
+1.8VSP_VIN on BOTTOM (solid shape): 231.88,90.57 231.88,90.38 232.39,89.87 232.9,89.87 233.15,89.62 233.15,87.97 233.66,87.46 236.33,87.46 236.52,87.27 236.52,84.98 236.39,84.86 232.71,84.86 232.52,85.05 232.52,86.03 232.26,86.29 230.67,86.29 230.28,86.68 230.28,90.5 230.48,90.7 231.75,90.7
+1VSP_B+ on TOP: 98.94,115.87 98.94,117.29 99.14,117.5 100.56,117.5 100.87,117.8 100.87,121.08 100.94,121.15 103.08,121.15 103.18,121.05 103.18,114.85 103.12,114.79 102.77,114.79 102.75,114.8 102.75,115.33 102.74,115.34 102.23,115.34 102.23,115.34 102.23,114.81 102.21,114.79 101.97,114.79 101.95,114.81 101.95,115.32 101.93,115.34 101.43,115.34 101.42,115.32 101.42,114.81 101.4,114.79 100.93,114.79 100.79,114.65 100.79,114.04 100.44,113.69 99.42,113.69 99.24,113.86 99.24,115.59 98.96,115.87
+2.5V_MEM on TOP (solid shape): 24.74,63.71 24.74,62.06 24.3,61.62 23.54,61.62 23.54,62.12 22.14,62.12 22.14,61.55 21.76,61.55 21.44,61.87 21.44,64.22 21.82,64.6 23.85,64.6
+2.5V_MEM on TOP: 86.7,76.86 86.7,82.51 91.53,87.33 98.66,87.33 100.27,88.95 101.29,88.95 101.78,89.44 112.48,89.44 113.91,88.01 115.65,88.01 116.34,88.69 118.14,88.69 118.58,88.26 118.58,87.54 118.31,87.28 118.31,85.57 120.06,83.83 120.06,81.48 119.61,81.03 118.33,81.03 118.32,81.03 117.82,81.03 117.42,81.43 117.42,81.85 117.07,82.19 117.07,82.82 116.76,83.14 116.12,83.14 115.8,83.46 112.63,83.46 109.82,86.28 100.49,86.28 99.32,85.11 99.32,76.18 99.04,75.9 93.96,75.9 87.66,75.9
+2.5V_MEM on BOTTOM: 109.82,81.02 109.78,81.07 109.78,81.07 109.64,81.2 109.64,81.62 108.56,82.7 108.56,84.86 110.24,86.54 110.24,89.11 110.69,89.56 110.69,91.51 110.84,91.66 111.52,91.66 111.6,91.57 111.6,91.34 111.6,91.33 111.6,89.4 111.74,89.26 112.36,89.26 112.48,89.14 112.48,88.44 113.14,87.78 116.98,87.78 117.23,88.03 117.23,88.64 118.27,89.68 124.12,89.68 124.25,89.56 124.25,88.73 123.99,88.48 123.36,88.48 122.6,87.71 122.6,86.6 125.48,83.73 125.48,81.1 125.4,81.02 123.92,81.02 123.43,81.51 123.43,82.4 123.06,82.77 121.4,82.77 121.23,82.94 121.23,84.64 119.81,86.06 113.33,86.06 111.71,84.45 111.71,81.16 111.57,81.02
+2.5V_MEM on IN4: 21.44,64.16 21.44,62.63 22.14,61.93 23.41,61.93 23.73,62.25 23.73,63.9 23.28,64.35 21.63,64.35
+2.5V_MEM on IN4: 51.54,59.71 53.19,59.71 53.45,59.46 53.45,42.63 53.89,42.18 60.68,42.18 61.76,41.1 61.76,38.82 60.81,37.87 52.11,37.87 51.41,38.56 51.41,59.58
+2.5V_MEM on IN4: 105.22,87.51 105.22,88.35 104.71,88.86 103.01,88.86 99.04,84.89 99.04,82.85 99.27,82.61 100.32,82.61
+2.5V_MEMP on TOP (solid shape): 24.17,61.17 24.17,60.2 24.36,60.02 24.36,58.05 24.11,57.81 19.41,57.81 19.22,58 19.22,59.52 18.27,60.47 18.27,61.3 18.33,61.36 23.98,61.36
+2.8V_FHV on IN2: 129.2,117.43 135.36,117.43 137.27,115.53 137.27,114.64 137.11,114.48 136.79,114.48 134.66,116.61 129.52,116.61 129.07,116.16 125.45,116.16 124.95,116.67 124.95,117.37 125.14,117.56 129.07,117.56
+3.3V_1.8V_FUSE on TOP: 134.29,123.85 134.29,123.67 134.04,123.42 134.04,123.29 133.91,123.17 133.4,123.17 133.28,123.29 133.28,124.23 134.34,125.29 134.34,126.39 134.73,126.77 136.21,126.77 136.66,126.32 136.66,125.97 134.54,123.85
+3.3V_1.8V_GPPD on TOP: 112.07,122.53 112.74,121.86 113.25,121.86 113.33,121.94 113.33,122.64 113.39,122.7 113.77,122.7 113.83,122.77 113.83,123.08 113.75,123.17 113.34,123.17 113.29,123.22 112.91,123.22 110.38,125.74 109.09,125.74 109.03,125.68 109.03,124.2 110.7,122.53
+3.3V_1.8V_SPI on TOP: 114.35,123.67 114.25,123.77 114.11,123.77 114.08,123.77 114.04,123.76 114,123.77 113.97,123.78 113.93,123.81 113.91,123.84 113.89,123.87 113.89,123.91 113.89,123.96 112.94,124.92 112.94,125.16 113.12,125.33 114.47,125.33 115.24,124.56 115.24,123.75 115.17,123.67
+3.3V_1.8V_SPI on BOTTOM: 113.8,127.19 113.69,127.3 111.69,127.3 111.59,127.2 111.59,126.62 111.71,126.49 112.78,126.49 112.9,126.37 112.9,124.84 113.07,124.68 113.88,124.68 114.07,124.86 114.07,125.23 114.26,125.42 114.26,126.37 114.17,126.47 113.96,126.47 113.8,126.62
+3.3V_ALW on TOP (solid shape): 153.71,124.23 153.71,123.91 153.39,123.59 152.38,123.59 152.2,123.77 152.2,124.23 152.33,124.35 153.59,124.35
+3.3V_ALW on TOP (solid shape): 12.62,58.57 12.62,55.46 12.36,55.2 11.15,55.2 10.9,55.46 10.9,58.44 11.22,58.76 12.42,58.76
+3.3V_ALW on TOP (solid shape): 307.81,31.85 307.81,31.14 307.62,30.94 305.14,30.94 305.11,30.98 305.11,31.95 305.34,32.18 307.48,32.18
+3.3V_ALW on TOP (solid shape): 218.4,124.18 218.4,124.18 218.6,123.97 220.62,123.97 221.03,123.56 221.03,122.86 221,122.83 218.84,122.83 218.28,123.39 218.23,123.46 218.16,123.52 217.91,123.76 217.91,124.1 218.04,124.23 218.36,124.23
+3.3V_ALW on TOP (solid shape): 70.02,40.6 73.22,40.6 73.99,39.82 74.55,39.82 74.91,39.47 74.91,38.81 74.78,38.68 73.69,38.68 72.41,39.96 70.4,39.96 70.02,39.58 67.48,39.58 67.23,39.83 67.23,40.98 67.35,41.1 69.51,41.1
+3.3V_ALW on TOP (solid shape): 340.7,5.31 340.78,5.23 341.38,5.23 341.38,4.69 342.13,4.69 342.13,5.23 342.58,5.23 342.58,4.69 343.33,4.69 343.33,5.23 346.71,5.23 346.71,4.69 347.46,4.69 347.46,5.23 347.91,5.23 347.91,4.69 348.66,4.69 348.66,5.23 349.29,5.23 349.48,5.04 349.48,3.89 349.1,3.51 340.15,3.51 339.96,3.7 339.96,5.42 340.08,5.54 340.47,5.54
+3.3V_ALW on TOP (solid shape): outline of 137 points within 180.02,113.04 181.45,115.62
+3.3V_ALW on BOTTOM (solid shape): 231.98,91.98 231.98,91.05 231.82,90.89 231.44,90.89 231.44,91.46 230.93,91.46 230.93,90.89 230.55,90.89 230.42,91.02 230.42,91.85 230.8,92.23 231.73,92.23
+3.3V_ALW on TOP: 17.42,41.1 17.3,40.98 17.3,40.6 16.98,40.28 16.41,40.28 16.18,40.05 16.18,39.35 16.49,39.05 17.8,39.05 18.12,39.36 18.12,40.22 18.28,40.37 18.28,41.03 18.2,41.1
+3.3V_ALW on TOP: 153.26,121.94 153.26,120.87 153.27,120.86 153.27,120.48 153.21,120.42 152.64,120.42 152.49,120.57 152.49,121.05 152.32,121.22 152.32,121.88 152.44,122 153.2,122
+3.3V_ALW on TOP: 115.04,136.67 114.15,136.67 114.02,136.8 114.02,138.26 114.28,138.51 115.04,138.51 115.17,138.39 115.17,136.8
+3.3V_ALW on TOP: 120.69,137.18 119.1,137.18 118.91,137.37 118.91,138.01 119.87,138.96 120.76,138.96 120.99,138.73 120.99,137.48
+3.3V_ALW on TOP: 212.72,94.24 212.81,94.15 212.81,92.75 212.72,92.65 212.16,92.65 211.98,92.83 211.5,92.83 211.38,92.95 211.38,93.24 211.04,93.58 211.04,94.19 211.09,94.24
+3.3V_ALW on TOP: 323.4,35.48 323.91,34.97 323.91,34.13 324.08,33.95 324.72,33.95 325.28,34.51 325.28,36.68 324.41,37.55 322.03,37.55 321.34,36.85 321.34,35.79 321.64,35.48
+3.3V_ALW on TOP: 49.77,34.44 49.24,34.44 49.17,34.37 49.17,32.24 49.77,31.64 50.55,31.64 50.99,31.2 53.12,31.2 53.23,31.3 53.23,32.75 52.94,33.04 50.95,33.04 50,33.99 50,34.21
+3.3V_ALW on TOP: 221.06,121.37 221.06,120.48 220.87,120.29 219.5,120.29 219.24,120.04 218.8,120.04 218.47,120.36 218.47,121.06 218.84,121.43 221,121.43
+3.3V_ALW on TOP: 189.13,110.37 189.46,110.37 189.47,110.38 189.59,110.38 189.84,110.14 189.84,108.8 188.26,107.22 188.26,105.5 187.23,104.48 184.7,104.48 183.36,105.82 181.03,105.82 180.92,105.93 180.92,106.67 181.11,106.86 182.8,106.86 182.84,106.9 182.94,106.8 183.93,106.8 184.08,106.65 184.62,106.65 184.83,106.44 186.52,106.44 186.75,106.67 186.75,107.98
+3.3V_ALW on BOTTOM: 188.32,108.31 188.18,108.44 188.18,110.12 188.19,110.12 188.19,110.4 188.29,110.51 189.41,110.51 189.72,110.81 189.72,113.05 189.46,113.3 188.64,113.3 188,113.94 188,114.57 188.57,114.57 188.57,115.08 188,115.08 188,115.53 188.19,115.72 189.79,115.72 190.02,115.94 192.21,115.94 192.56,115.6 192.56,114.03 192.45,113.92 191.26,113.92 191.08,113.74 191.08,110.93 190.92,110.77 190.92,110 189.23,108.31
+3.3V_ALW on BOTTOM: 114.22,137.31 115.04,137.31 117.26,135.08 117.26,131.97 115.77,130.48 115.77,129.24 116.63,128.39 116.63,127.97 117.39,127.21 117.39,123.46 118.53,122.32 118.53,121.62 118.47,121.56 117.2,121.56 116.18,122.58 116.18,123.27 115.74,123.72 115.74,127.21 114.28,128.67 114.28,131.08 115.1,131.91 115.1,134.26 113.9,135.47 113.9,136.99
+3.3V_ALW on BOTTOM: 193.5,125.8 193.37,125.93 193.37,126.69 193.43,126.74 196.23,126.74 196.51,127.02 197.34,127.02 197.46,126.89 197.46,126.19 197.08,125.81 197.08,125.24 198.1,124.23 198.8,124.23 199.37,123.65 199.37,122.7 199.24,122.58 198.29,122.58 198.1,122.77 195.88,122.77 195.37,122.26 194.54,122.26 194.1,121.81 194.1,120.99 193.21,120.1 192.45,120.1 192.38,120.16 192.38,120.99 192.57,121.18 192.76,121.18 193.3,121.72 193.3,122.73 193.72,123.15 194.73,123.15 195.05,123.46 195.56,123.46 195.94,123.85 195.94,125.36 195.5,125.8
+3.3V_ALW on BOTTOM: 192.03,103.58 192.32,103.58 192.33,103.57 192.33,103.03 192.33,103.02 192.78,103.02 192.8,103.04 192.8,103.57 192.81,103.58 193.06,103.58 193.08,103.56 193.08,102.31 192.87,102.1 192.31,102.1 192.03,102.38
+3.3V_ALW on BOTTOM: 120.94,139.71 120.37,139.15 120.37,137.82 120.76,137.43 121.96,137.43 122.34,137.82 122.34,139.47 124.31,141.43 124.31,143.3 124.15,143.47 122.12,143.47 121.66,143.01 121.66,140.9 120.94,140.18
+3.3V_ALW on VCC: outline of 1877 points within 1.27,3.37 354.73,129.69
+3.3V_ALW on IN2: 213.6,92.41 213.54,92.34 212.63,92.34 212.32,92.65 212.32,93.91 212.5,94.09 213.46,94.09 213.6,93.94
+3.3V_ALW2 on TOP (solid shape): 348.07,31.25 349.57,31.25 349.62,31.2 349.62,31.07 349.57,31.02 347.64,31.02 347.59,30.97 344.61,30.97 344.51,31.07 344.51,31.58 344.64,31.71 347.61,31.71
+3.3V_ALW_PCH on TOP (solid shape): 151.54,128.56 151.54,127.73 151.5,127.69 151.06,127.69 151.01,127.65 151.01,127.15 150.98,127.12 150.76,127.12 150.74,127.14 150.74,127.68 150.72,127.69 150.24,127.69 150.2,127.66 150.2,127.15 150.18,127.12 149.95,127.12 149.95,127.13 149.95,127.67 149.92,127.69 149.34,127.69 149.27,127.77 149.27,128.59 149.34,128.67 151.43,128.67
+3.3V_ALW_PCH on BOTTOM (solid shape): 126.45,131.72 126.34,131.46 126.47,131.2 126.47,130.32 126.41,130.26 124.89,130.26 124.76,130.39 124.76,131.26 124.39,131.62 124.12,131.62 124.02,131.53 123.98,131.49 123.94,131.45 123.7,131.21 123.7,130.53 123.62,130.46 123.62,130.45 123.37,130.2 122.5,130.2 122.39,130.21 122.28,130.2 121.47,130.2 121.4,130.26 121.4,130.89 121.49,130.98 121.81,131.1 121.94,131.41 121.94,131.84 122.26,132.16 126.01,132.16
+3.3V_ALW_PCH on TOP: 106,122.09 106,128.37 105.95,128.43 105.15,128.43 104.47,127.75 104.47,123.39 104,122.91 104,122.61 104,122.6 104,122.55 103.28,121.83 103.28,116.48 103.51,116.25 103.51,113.52 104.16,112.86 105.93,112.86 105.98,112.92 106.36,112.92 106.44,112.99 106.44,115.07 106.24,115.27 105.26,115.27 104.96,115.57 104.96,116.93 104.42,117.47 104.42,119.27 105.08,119.93 105.08,121.18
+3.3V_ALW_PCH on TOP: 124.87,131.94 121.95,131.94 121.81,131.8 121.81,131.51 120.95,130.64 120.65,130.64 120.2,130.18 120.2,128.02 120.56,127.66 121.03,127.66 121.89,128.51 122.64,128.51 122.91,128.78 122.91,129.52 123.58,130.2 123.8,130.2 124.5,129.5 125.01,129.5 125.18,129.66 125.18,131.63
+3.3V_ALW_PCH on BOTTOM: 107.1,128.97 105.61,128.97 104.75,128.11 104.75,124.23 105.21,123.77 105.72,123.77 105.85,123.9 105.85,124.68 106.17,125.01 106.17,125.9 106.79,126.52 108.15,126.52 109.79,124.87 109.79,123 110.22,122.56 111.78,122.56 111.9,122.68 111.9,123.33 111.78,123.45 111.06,123.45 110.77,123.74 110.77,126.63 110.79,126.65 110.79,128.36 110.38,128.77 110.38,132 110.28,132.1 109.71,132.1 109.58,131.97 109.58,131.45
+3.3V_ALW_PCH on BOTTOM: 197.78,130.64 196.96,130.64 196.51,130.2 196.51,129.37 196.64,129.24 197.84,129.24 197.91,129.31 197.91,129.62 197.34,129.62 197.34,130.13 197.91,130.13 197.91,130.51
+3.3V_ALW_PCH on IN1: 110.72,126.14 107.11,126.14 106.14,125.17 104.4,125.17 103.81,125.76 103.81,127.64 105,128.83 110.26,128.83 110.79,128.3 113.15,128.3 116.93,132.08 124.27,132.08 124.72,131.63 124.72,130.39 122.44,128.1 117.96,128.1 116.88,127.02 116.88,127.02 116.24,126.39 115.55,126.39 115.55,126.35 110.92,126.35
+3.3V_ALW_PCH on IN2: 137.93,124.33 137.77,124.48 137.77,125.18 137.58,125.37 137.2,125.37 137.01,125.56 137.01,126.27 137.2,126.46 143.02,126.46 145.65,129.09 146.12,129.09 147.29,130.26 152.89,130.26 154.13,129.02 165.68,129.02 167.81,126.89 173.13,126.89 173.91,127.67 182.64,127.67 183.11,127.2 183.11,126.39 182.66,125.94 180.06,125.94 178.99,124.86 173.65,124.86 172.73,123.94 171.68,123.94 171.64,123.89 169.25,123.89 168.83,123.46 167.11,123.46 165.78,124.8 156,124.8 154.57,126.23 151.55,126.23 149.65,124.33
+3.3V_ALW_PCH on IN3: 124.18,131.91 124.85,131.24 125.26,131.24 126.03,130.48 127.26,130.48 127.9,129.85 127.9,128.48 128.34,128.04 137.9,128.04 138.41,127.53 138.41,125.62 137.77,124.99 124.44,124.99 123.87,125.56 123.87,127.46 123.3,128.04 123.3,130 122.03,131.27 122.03,131.78 122.15,131.91
+3.3V_ALW_PCH_PWR on TOP: 148.02,126.55 147.58,126.11 147.58,125.6 147.93,125.24 148.57,125.24 148.66,125.15 148.66,123.5 148.76,123.4 150.73,123.4 150.92,123.59 150.92,124.29 150.79,124.42 150.05,124.42 149.74,124.73 149.74,125.5 149.89,125.65 150.31,125.65 150.91,126.25 151.12,126.25 151.59,126.73 151.59,127.46 151.5,127.56 151.16,127.56 151.15,127.54 151.15,126.99 151.15,126.98 150.6,126.98 150.6,126.99 150.6,127.54 150.34,127.54 150.34,127.53 150.34,127.01 150.32,126.99 149.82,126.99 149.8,127.01 149.8,127.53 149.77,127.56 149.51,127.56 149.47,127.52 149.47,126.88 149.13,126.55
+3.3V_ALW_U46 on BOTTOM: 187.74,116.87 186.83,116.87 186.77,116.81 186.77,116.67 186.29,116.19 186.29,115.34 187.25,114.37 187.8,114.37 187.85,114.42 187.85,116.05 187.86,116.06 187.86,116.75
+3.3V_ALW_U46 on IN1: 177.78,111.02 179.05,111.02 179.56,110.51 179.56,106.01 179.3,105.75 178.48,105.75 178.29,105.56 177.84,105.56 177.59,105.81 176.89,105.81 176.89,105.81 176.89,106.24 177.16,106.51 177.16,107.01 177.27,107.12 177.27,108.29 177.4,108.42 177.4,110.64
+3.3V_ALW_U51 on TOP (solid shape): outline of 429 points within 204.26,109.05 208.13,116.41
+3.3V_ALW_U51 on BOTTOM: 194.48,105.19 192.63,105.19 192.04,104.61 192.04,103.69 195.6,103.69 195.9,104 195.9,105.04 195.32,105.62 194.91,105.62
+3.3V_DSW on BOTTOM (solid shape): 131.22,130.72 131.22,130.16 131.19,130.15 130.95,129.82 131.19,129.48 131.22,129.47 131.22,128.43 131.14,128.36 130.72,128.36 130.7,128.36 130.63,128.39 130.6,128.46 130.6,129.71 130.39,129.91 127.62,129.91 127.35,130.18 127.35,130.27 127.69,130.61 130.46,130.61 130.61,130.77 131.17,130.77
+3.3V_HDD on TOP (solid shape): 32.59,17.31 34.4,17.31 34.71,17 34.71,16.4 34.14,16.4 34.14,15.01 34.71,15.01 34.71,14.5 34.71,14.5 34.71,14.05 34.6,13.94 33.68,13.94 33.43,13.69 33.43,11.53 33.1,11.2 31.65,11.2 31.22,11.63 31.22,14.6 31.48,14.85 31.48,17.72 31.62,17.86 32.04,17.86
+3.3V_HDD on TOP: 30.81,29.1 30.81,30.53 30.92,30.63 31.27,30.63 31.87,30.03 32,30.03 32.14,29.89 32.14,29.59 31.82,29.27 31.59,29.27 31.37,29.05 30.87,29.05
+3.3V_HDD on IN1: 24.16,23.95 29.93,23.95 30.64,23.24 30.64,15.01 32.16,13.48 33.08,13.48 33.53,13.02 33.53,11.25 33.38,11.09 32.69,11.09 32.67,11.12 28.22,11.12 23.65,15.69 23.65,23.44
+3.3V_HDD on IN3: 33.05,24.4 32.59,23.95 31.58,23.95 30.48,22.85 25.18,22.85 24.69,23.34 24.13,23.34 23.17,24.3 23.17,24.73 22.89,25.01 21.72,25.01 21.21,25.52 21.21,27.88 21.98,28.65 24.49,28.65 26.78,26.36 29.21,26.36 29.9,27.05 29.9,29.97 28.81,31.06 21.87,31.06 20.81,32.13 20.81,34.74 21.7,35.63 24.67,35.63 26.34,33.95 29.6,33.95 29.65,34.01 31.73,34.01 33.05,32.68
+3.3V_HDD1 on TOP: 28.42,20.91 30.1,20.91 30.45,20.55 30.92,20.55 31.28,20.19 31.28,17.48 31.28,16.08 31.28,16.07 31.28,15.54 31.04,15.3 30.15,15.3 29.68,15.77 28.29,15.77 27.68,16.38 27.68,18.13 27.97,18.42 27.97,19.37 27.87,19.48 27.87,20.35
+3.3V_HDD1 on BOTTOM: 29.63,18.26 29.38,18.52 29.38,19.51 29,19.9 29,20.72 29.38,21.1 29.82,21.1 30.14,20.78 30.14,20.47 30.52,20.09 30.71,20.09 31.22,19.58 31.22,18.44 31.05,18.26
+3.3V_LAN on TOP (solid shape): 228.22,144.53 228.22,143.32 227.46,142.56 227.46,141.8 227.33,141.67 226.57,141.67 226.32,141.93 226.32,144.47 226.57,144.72 228.03,144.72
+3.3V_LAN on TOP: 224.39,120.54 225.34,120.54 225.47,120.67 227.12,120.67 227.31,120.86 227.31,122 227.18,122.13 226.59,122.13 226.53,122.2 226.53,122.7 226.52,122.71 226.77,122.96 228.88,122.96 228.92,122.92 229.32,122.92 229.34,122.89 229.59,122.89 229.72,122.77 229.72,122.07 229.29,121.64 229.29,120.49 229.28,120.48 229.28,120.1 229.47,119.91 229.79,119.91 229.85,119.84 229.85,119.72 229.79,119.65 228.9,119.65 228.39,119.15 228.39,118.23 227.08,116.93 224.39,116.93 224.08,117.23 224.08,117.77 224.03,117.83 223.52,117.83 223.5,117.85 223.5,118.05 223.55,118.1 224.01,118.1 224.08,118.18 224.08,118.56 224.03,118.61 223.58,118.61 223.52,118.66 223.52,118.87 223.55,118.89 224.06,118.89 224.08,118.92 224.08,120.24
+3.3V_LAN on BOTTOM: 228.71,138.93 228.71,129.56 228.74,129.53 228.74,124.89 231.06,122.58 238.68,122.58 239.56,121.69 239.56,116.48 237.72,114.64 229.4,114.64 225.59,118.45 225.59,137.62 225.23,137.99 225.23,144.55 225.66,144.98 228.07,144.98 228.3,144.75 228.3,139.34
+3.3V_LAN_OUT on TOP: 253.79,116.59 254.71,116.59 254.83,116.48 254.83,115.87 254.76,115.8 254.68,115.8 254.67,115.81 253.85,115.81 253,114.96 253,114.24 252.85,114.1 252.68,114.1 252.33,113.74 252.33,111.78 252.15,111.61 251.76,111.61 251.6,111.77 251.6,115.18 251.95,115.53 252.72,115.53
+3.3V_LAN_OUT on BOTTOM: 251.44,104.29 248.58,104.29 248.14,104.73 248.14,106.07 249.66,107.59 249.66,108.8 248.71,109.75 248.71,111.46 249.03,111.78 251.18,111.78 251.57,112.16 252.01,112.16 252.2,111.97 252.2,110.64 251.76,110.19 251.76,104.6
+3.3V_LAN_PWR on TOP: 221.64,119.18 221.86,119.38 221.85,119.68 222.12,119.95 222.12,120.59 222.33,120.8 222.33,121.37 222.4,121.43 223.16,121.43 223.54,121.05 223.54,120.86 223.94,120.46 223.94,119.02 223.94,119.02 223.37,119.02 223.37,118.49 223.93,118.49 223.96,118.46 223.96,118.26 223.93,118.23 223.42,118.23 223.37,118.18 223.37,117.62 223.94,117.62 223.94,117.62 223.94,117.18 223.69,116.93 222.27,116.93 221.64,117.56 221.61,117.56 221.13,118.05 221.13,118.68 221.16,118.7
+3.3V_M on TOP: 151.96,120.29 150.6,120.29 150.42,120.1 150.42,119.5 150.4,119.48 149.88,119.48 149.87,119.47 149.87,119.22 149.88,119.21 150.41,119.21 150.42,119.2 150.42,118.7 150.39,118.67 149.9,118.67 149.87,118.65 149.87,118.43 149.89,118.42 150.37,118.42 150.4,118.42 150.42,118.4 150.42,117.95 150.44,117.93 150.72,117.93 150.76,117.97 150.76,118.35 152.09,119.67 152.09,120.16
+3.3V_M_PWR on TOP: 151.02,121.93 151.02,120.7 150.84,120.52 150.44,120.52 150.29,120.37 150.29,119.62 150.28,119.61 149.75,119.61 149.73,119.6 149.73,119.09 149.75,119.07 150.28,119.07 150.28,118.82 150.27,118.81 149.73,118.81 149.73,118.8 149.73,118.29 149.74,118.27 150.26,118.27 150.28,118.25 150.28,117.7 150.07,117.49 147.5,117.49 146.9,118.08 146.9,118.7 146.59,119.01 146.59,120.5 146.98,120.9 147.68,120.9 148.35,121.57 148.35,122.12 148.5,122.27 149.43,122.27 149.68,122.02 150.93,122.02
+3.3V_M_TPM on BOTTOM: 193.52,124.42 193.32,124.23 188.41,124.23 186.73,125.9 186.73,129 187.68,129.95 188.4,129.95 188.68,129.67 189.56,129.67 189.64,129.6 189.64,129.5 189.56,129.42 188.8,129.42 188.62,129.24 188.62,129.12 188.36,128.86 188.01,128.86 187.93,128.77 187.93,127.45 188.9,126.47 188.9,125.88 189.34,125.45 193.17,125.45 193.22,125.5 193.34,125.5 193.52,125.31
+3.3V_M_TPM on BOTTOM: 199.56,130.58 198.23,130.58 198.1,130.45 198.1,129.37 198.16,129.31 199.5,129.31 199.62,129.43 199.62,130.51
+3.3V_MXM on TOP (solid shape): 208.26,76.92 209.85,76.92 210.1,77.17 210.1,77.36 210.23,77.49 211.05,77.49 211.24,77.3 211.24,77.05 210.48,76.28 207.94,76.28 207.1,77.12 206.83,77.12 206.78,77.07 206.57,77.07 206.48,76.98 205.97,76.98 205.85,77.11 205.85,77.49 205.97,77.62 206.16,77.62 206.42,77.87 206.42,78.06 206.61,78.25 206.93,78.25
+3.3V_MXM on TOP (solid shape): 215.18,95.21 215.18,95.08 215.58,94.68 215.58,92.83 215.28,92.53 214.16,92.53 214.13,92.55 214.13,93.03 214.13,93.03 213.59,93.03 213.58,93.05 213.58,93.27 213.59,93.29 214.13,93.29 214.15,93.31 214.15,93.82 214.13,93.85 213.59,93.85 213.58,93.86 213.58,94.09 213.59,94.1 214.15,94.1 214.15,94.7 214.22,94.78 214.23,94.78 214.79,95.33 215.05,95.33
+3.3V_MXM on TOP (solid shape): outline of 96 points within 139.93,70.19 160.51,80.54
+3.3V_MXM on BOTTOM (solid shape): 160.63,77.62 160.63,71.14 163.05,68.73 163.62,68.73 163.62,68.16 161.71,68.16 159.24,70.63 159.24,73.81 159.11,73.93 156.19,73.93 155.93,73.68 155.93,73.3 155.99,73.25 156,73.23 156,72.85 155.87,72.73 155.36,72.73 154.79,73.3 154.79,74.7 155.3,75.2 158.98,75.2 159.24,75.46 159.24,77.62 159.43,77.81 160.44,77.81
+3.3V_MXM on BOTTOM (solid shape): 207.37,78.13 210.93,78.13 213.21,75.84 213.21,75.46 213.05,75.3 207.53,75.3 206.8,76.03 206.54,76.03 206.23,76.35 206.04,76.35 205.85,76.54 205.85,76.74 206.59,76.74 206.6,76.69 206.61,76.64 206.63,76.59 206.66,76.54 206.69,76.5 206.73,76.46 206.77,76.43 206.82,76.41 206.87,76.39 206.92,76.38 206.98,76.38 207.03,76.39 207.08,76.41 207.13,76.43 207.17,76.46 207.21,76.5 207.25,76.54 207.27,76.59 207.29,76.64 207.3,76.69 207.31,76.74 207.3,76.79 207.29,76.85 207.27,76.9 207.25,76.94 207.21,76.98 207.17,77.02 207.13,77.05 207.08,77.07 207.03,77.09 206.98,77.1 206.92,77.1 206.87,77.09 206.82,77.07 206.77,77.05 206.73,77.02 206.69,76.98 206.66,76.94 206.63,76.9 206.61,76.85 206.6,76.79 206.59,76.74 205.85,76.74 205.85,77.49 205.97,77.62 206.16,77.62 206.42,77.87 206.42,78.13 206.54,78.25 207.24,78.25
+3.3V_MXM on IN2 (solid shape): outline of 664 points within 159.3,73.87 206.93,79.71
+3.3V_MXM on IN1: 214.67,89.88 214.73,89.82 214.73,88.94 213.14,87.35 213.14,83.95 210.51,81.32 210.51,79.27 210.1,78.86 210.1,75.78 210.55,75.32 213.1,75.32 215.07,77.29 215.07,86.76 216.45,88.14 216.45,92.86 215.62,93.68 215.62,94.57 215.24,94.95 215.24,95.21 215.12,95.33 214.8,95.33 214.67,95.21
+3.3V_MXM_PWR on TOP (solid shape): 213.16,96.44 213.16,95.96 213.58,95.54 213.58,95.52 213.59,95.52 214,95.11 214,94.23 213.44,94.23 213.43,94.22 213.43,93.71 213.44,93.7 213.97,93.7 214,93.66 214,93.46 213.98,93.44 213.46,93.44 213.44,93.42 213.44,92.93 213.47,92.9 213.98,92.9 214,92.88 214,92.51 212.99,92.51 212.97,92.54 212.97,94.33 212.81,94.49 212.55,94.49 212.27,94.77 212.27,95.04 211.8,95.52 211.16,95.52 211.12,95.56 211.12,96.34 211.36,96.58 213.02,96.58
+3.3V_PGPPBCH on BOTTOM: 112.34,124.2 113.49,124.2 113.61,124.08 113.61,123.72 113.6,123.71 113.6,123.46 113.81,123.24 114.39,123.24 114.57,123.07 114.57,122.81 114.38,122.62 112.23,122.62 112.11,122.74 112.11,123.96
+3.3V_PGPPEF on BOTTOM: 114.43,116.78 114.56,116.53 114.56,116.48 115.52,116.48 115.67,116.63 115.67,118.04 115.34,118.37 114.09,118.37 114.04,118.32 114.04,116.95 114.08,116.88 114.16,116.85
+3.3V_RUN on IN3 (solid shape): outline of 874 points within 276.84,24.02 307.38,35.03
+3.3V_RUN on TOP: 310.17,30.63 309.79,30.25 308.83,30.25 308.57,30.5 308.57,31.14 307.96,31.75 307.96,32.07 307.64,32.38 305.04,32.38 304.65,32.77 304.65,33.4 304.61,33.44 304.12,33.44 304.08,33.47 304.08,33.67 304.13,33.72 304.61,33.72 304.64,33.75 304.64,34.2 304.61,34.24 304.12,34.24 304.1,34.26 304.1,34.5 304.11,34.52 304.59,34.52 304.64,34.57 304.64,35.02 304.7,35.07 305.9,35.07 305.91,35.06 307.58,35.06 308.37,34.28 308.94,34.28 310.3,32.91 312.34,32.91 312.46,32.79 312.46,30.75 312.34,30.63
+3.3V_RUN on TOP: 247.12,98.38 246.87,98.38 246.8,98.45 246.8,100.29 246.42,100.67 246.42,102.38 246.55,102.51 254.17,102.51 254.68,102 254.68,100.73 254.23,100.29 247.31,100.29 247.18,100.16 247.18,98.45
+3.3V_RUN on TOP: 34.9,16.78 34.9,13.96 34.29,13.36 34.29,11.53 34.57,11.25 36.45,11.25 36.94,11.73 36.94,16.56 36.58,16.91 35.03,16.91
+3.3V_RUN on TOP: outline of 87 points within 239.82,42.96 270.6,88.54 ; 1 cut-out
+3.3V_RUN on TOP: 50.91,35.95 50.03,35.95 50.03,35.95 49.67,35.95 49.64,35.92 49.64,34.88 50.37,34.16 53.04,34.16 53.13,34.25 53.13,34.95 53.06,35.01 51.41,35.01 51.16,35.26 51.16,35.7
+3.3V_RUN on TOP: 287.9,31.9 286.74,31.9 286.24,31.39 286.24,30.94 285.79,30.5 285.79,29.48 285.98,29.29 287.7,29.29 288.11,29.71 288.3,29.71 288.38,29.79 288.38,30.63 288.37,30.63 287.81,30.63 287.8,30.64 287.8,31.12 287.82,31.14 288.33,31.14 288.34,31.13 288.38,31.13 288.39,31.14 288.39,31.4
+3.3V_RUN on BOTTOM: 251.82,80.41 249.41,80.41 248.33,81.49 248.33,88.29 251.44,91.4 251.82,91.4 253.15,92.73 253.15,102.19 253.6,102.64 255.76,102.64 255.79,102.6 258.01,102.6 258.49,102.13 258.49,91.84 258.11,91.46 258.04,91.46 254.93,88.35 254.93,86.82 251.31,83.21 251.31,82.51 251.69,82.13 251.95,82.13 252.2,81.87 252.45,81.87 252.58,81.74 252.58,81.43 252.52,81.36 252.33,81.36 252.01,81.05 252.01,80.6
+3.3V_RUN on BOTTOM: 4.49,40.6 3.75,41.34 3.75,52.11 5.02,53.39 12.22,53.39 14.01,51.6 18.94,51.6 20.21,52.87 20.21,56.29 23.2,59.29 23.2,64.85 24.73,66.38 46.9,66.38 47.35,65.93 47.35,64.84 46.59,64.08 45.82,64.08 45.33,64.57 29.37,64.57 28.63,63.83 28.63,55.85 21.86,49.08 21.86,42.24 20.21,40.6
+3.3V_RUN on IN1: 143.56,141.44 146.58,141.44 147.33,140.69 147.33,139.6 147.13,139.39 145.68,139.39 144.8,140.28 144.11,140.28 143.65,139.81 143.26,139.81 143.02,140.04 143.02,140.9
+3.3V_RUN on VCC: outline of 121 points within 1.27,10.43 258.53,158.63
+3.3V_RUN on IN2: 262.45,45.83 263.91,45.83 263.95,45.87 267.17,45.87 267.72,45.32 267.72,38.17 266.68,37.13 266.68,31.52 270.65,27.54 274.26,27.54 274.43,27.71 278.17,27.71 278.18,27.7 278.6,27.7 278.79,27.5 278.79,25.24 278.13,24.58 277.75,24.58 276.72,23.55 266.64,23.55 263.86,26.33 263.86,28.52 262.16,30.22 262.16,36.22 260.67,37.71 260.67,44.05
+3.3V_RUN_DIMM4 on BOTTOM: 101.96,86.13 101.96,88.79 102.53,89.36 106.21,89.36 106.34,89.24 107.36,89.24 107.61,89.49 107.61,89.81 107.42,90 107.42,90.95 107.48,91.02 108.06,91.02 108.12,90.95 108.12,90.32 108.31,90.13 109.01,90.13 109.07,90.06 109.07,89.56 109.01,89.49 108.5,89.49 108.37,89.36 108.37,88.41 108.56,88.22 108.94,88.22 109.07,88.09 109.07,86.32 108.06,85.3 108.06,81.74 108.94,80.86 111.42,80.86 111.55,80.73 111.55,80.6 111.48,80.54 108.31,80.54 106.25,82.6 106.25,84.32 105.58,84.98 103.1,84.98
+3.3V_RUN_PWR on TOP (solid shape): 304.51,34.97 304.51,34.65 303.98,34.65 303.96,34.63 303.96,34.14 303.98,34.12 304.5,34.12 304.51,34.11 304.51,33.87 304.5,33.86 303.99,33.86 303.96,33.83 303.96,33.33 303.99,33.31 304.48,33.31 304.51,33.28 304.51,32.3 303.81,31.61 303.81,31.03 303.75,30.97 302.98,30.97 302.79,31.16 301.59,31.16 301.49,31.26 301.49,34.11 302.57,35.19 304.29,35.19
+3.3V_SSD1 on TOP (solid shape): 14.95,43.14 14.95,41.5 15,41.44 15.52,41.44 15.54,41.42 15.54,41.2 15.52,41.19 15.07,41.19 15,41.11 15,40.23 14.7,39.93 13.01,39.93 12.52,40.43 12.52,42.75 13.19,43.42 14.66,43.42
+3.3V_SSD1 on BOTTOM (solid shape): outline of 310 points within 2.84,10.85 25.24,17.59
+3.3V_SSD1 on TOP: 16.79,12.1 16.92,12.23 17.55,12.23 19.61,14.29 22.36,14.29 22.71,13.94 22.71,10.61 22.51,10.41 21.57,10.41 19.45,8.29 17.23,8.29 16.79,8.73
+3.3V_SSD1 on IN2: 1.36,29.1 1.37,29.12 1.37,36.34 1.37,36.34 1.37,38.53 6.39,43.56 13.95,43.56 14.5,43.01 14.5,42.63 14.63,42.5 14.63,40.79 12.73,38.88 12.73,35.58 13.69,34.62 14.57,33.74 17.61,33.74 18.76,32.6 18.76,29.93 18.74,29.92 18.74,23.38 21.59,20.53 21.59,8.83 20.71,7.96 6.39,7.96 3.82,10.52 2.88,10.52 1.36,12.05
+3.3V_SSD1_PWR on TOP (solid shape): 18.27,43.25 18.27,42.57 18.2,42.5 17.61,42.5 17.11,41.99 17.11,40.72 16.85,40.47 15.33,40.47 15.14,40.66 15.14,41.02 15.15,41.03 15.66,41.03 15.69,41.07 15.69,41.55 15.67,41.57 15.14,41.57 15.12,41.59 15.12,41.81 15.14,41.83 15.66,41.83 15.68,41.86 15.68,42.37 15.68,42.37 15.14,42.37 15.14,42.88 15.65,43.39 15.65,44.22 16.15,44.72 16.79,44.72
+3.3V_TP on TOP: 291.25,31.71 292.46,31.71 292.65,31.52 292.65,31.14 292.52,31.01 290.68,31.01 290.36,30.69 289.41,30.69 288.9,30.18 288.59,30.18 288.52,30.25 288.52,30.79 288.52,30.79 287.97,30.79 287.95,30.8 287.95,30.97 287.96,30.98 288.52,30.98 288.52,30.98 288.52,31.73 288.69,31.9 291.06,31.9
+3.3V_WLAN on TOP (solid shape): 222.17,111.69 222.17,109.92 221.87,109.62 220.51,109.62 220.45,109.68 220.45,111.95 220.53,112.04 221.82,112.04
+3.3V_WLAN on BOTTOM (solid shape): outline of 1024 points within 213.85,109.15 225.56,139.09
+3.3V_WLAN on TOP: 222.72,126.64 222.72,126.11 222.69,126.08 222.23,126.08 222.2,126.05 222.2,125.57 222.18,125.55 221.97,125.55 221.95,125.57 221.95,126.05 221.92,126.08 221.47,126.08 221.42,126.03 221.42,125.57 221.39,125.55 221.16,125.55 221.14,125.57 221.14,126.03 221.09,126.08 220.47,126.08 220.29,126.26 220.29,130.59 220.32,130.63 222.51,130.63 222.89,130.25 222.89,126.81
+3.3V_WLAN_PWR on TOP: 221.06,123.78 222.14,123.78 222.33,123.59 222.33,122.89 222.4,122.83 223.1,122.83 223.16,122.89 223.16,124 223.52,124.35 224.47,124.35 224.63,124.52 224.63,125.78 224.44,125.97 222.95,125.97 222.94,125.98 222.36,125.98 222.33,125.95 222.33,125.47 222.28,125.42 221.85,125.42 221.82,125.45 221.82,125.93 221.8,125.95 221.54,125.95 221.54,125.45 221.49,125.39 221.04,125.39 221.01,125.42 221.01,125.95 220.63,125.95 220.05,125.37 218.72,125.37 218.52,125.18 218.52,124.23 218.65,124.1 220.75,124.1
+3.3V_WWAN on BOTTOM (solid shape): 322.73,24.34 322.73,23.64 322.61,23.52 322.61,23.4 321.84,22.64 320.4,22.64 320.13,22.91 320.13,23.64 320.13,23.64 320.13,24.21 320.26,24.34 322.03,24.34 322.16,24.47 322.61,24.47
+3.3V_WWAN on TOP: 325.63,32.91 325.99,32.56 325.99,29.67 325.48,29.17 322.56,29.17 322.46,29.06 322.46,28.02 322.65,27.83 323.64,27.83 323.7,27.78 323.71,27.78 325.02,26.46 328.78,26.46 329.16,26.84 329.16,35.45 328.85,35.77 328.85,38.03 327.16,39.72 327.16,40 327.51,40.36 327.51,40.76 326.37,41.9 321.26,41.9 321.06,41.7 321.06,39.14 321.31,38.88 323.37,38.88 325.63,36.62
+3.3V_WWAN on TOP: 320.38,25.17 319.68,24.47 319.68,23.77 319.69,23.77 319.69,23.06 319.99,22.76 322.22,22.76 323.04,23.58 323.37,23.58 323.49,23.71 323.49,25.04 323.37,25.17
+3.3V_WWAN on BOTTOM: 320.13,40.72 320.27,40.58 320.75,40.58 320.77,40.56 321.81,40.56 322.02,40.35 322.62,40.35 323.06,40.79 323.06,40.97 322.16,41.87 320.26,41.87 320.13,41.74
+3.3V_WWAN on IN4: 325.08,32.18 325.08,25.14 323.12,23.18 322.89,23.18 322.25,22.54 320.59,22.54 319.99,23.14 319.99,26.39 320.74,27.13 320.74,30.94 320.78,30.98 320.78,34.43 323.76,37.41 323.76,38.91 325.73,40.89 327.28,40.89 327.84,40.33 327.84,34.94
+3.3V_WWAN_PWR on TOP: 322.51,30.88 322.74,31.11 323.52,31.11 323.93,31.52 323.93,32.56 324.03,32.66 325.1,32.66 325.23,32.53 325.23,32.13 325.86,31.49 325.86,29.74 325.45,29.32 324.42,29.32 324.39,29.36 324.39,29.89 324.38,29.89 323.87,29.89 323.85,29.87 323.85,29.41 323.86,29.35 323.85,29.34 323.62,29.34 323.6,29.36 323.6,29.87 323.58,29.89 323.08,29.89 323.07,29.87 323.07,29.37 323.04,29.35 322.55,29.35 322.51,29.39
+3VALWP on TOP (solid shape): 348.07,14.69 348.07,12.15 347.81,11.89 346.93,11.89 346.29,11.26 346.29,8.08 346.93,7.45 348.96,7.45 349.34,7.07 349.34,5.54 349.21,5.42 340.83,5.42 340.7,5.54 340.7,10.75 341.46,11.51 341.46,14.18 342.23,14.94 347.81,14.94
+5V_ALW on TOP (solid shape): 236.05,16.45 236.05,15.65 235.93,15.54 235.1,15.54 234.98,15.66 234.98,16.42 235.11,16.55 235.94,16.55
+5V_ALW on TOP (solid shape): 263.6,32.4 263.6,32 263.38,31.79 261.54,31.79 261.45,31.88 261.45,32.49 261.57,32.6 263.39,32.6
