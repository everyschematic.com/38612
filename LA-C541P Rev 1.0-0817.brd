# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLTRST_LAN#: length 99.5
  TOP w0.102: v2(238.03,105.38) 238.46,105.81 240.82,105.81 241.84,106.83 245.67,106.83 249.92,102.58 253.91,102.58 254.44,103.11 254.44,105.34 v1(254.04,105.75) 253.33,106.46 U31.36
  IN2 w0.127: v2(238.03,105.38) 237.6,105.81 237.6,106.21 232.9,110.91 232.9,116.67 231.67,117.9 231.67,119.98 230.78,120.86 230.78,124.1 229.51,125.37 229.51,131.24 229.02,131.72 229.02,132.99 226.93,135.08 215.14,135.08 214.89,134.83 205.8,134.83 204.4,133.43 198.92,133.43 197.97,134.39 194.98,134.39 193.47,132.88 189.1,132.88 188.57,132.35 v2(188.54,132.35)
  BOTTOM w0.102: v2(188.54,132.35) 188.54,132.25 187.62,131.34 RH194.2
PLTRST_MMI#: length 306.6
  TOP w0.102: v2(314.05,31.64) 314.39,31.3 JIO1.69
  IN1 w0.089: 112.88,111.97 113.52,112.61 118.98,112.61 121.05,114.68 133.04,114.68 133.84,115.47 133.84,116.87 135.28,118.31 135.28,120.14 135.8,120.66 136.83,120.66 137.57,121.39 138.39,121.39 140.05,123.05 140.05,125.49 140.12,125.56
  IN1 w0.109: v2(314.05,31.64) 312.83,31.64 312.08,32.4 309.63,32.4 309.63,32.39 309.03,32.39 308.31,33.12 303.78,33.12 299.57,37.33 297.89,37.33 296.19,39.04 290.6,39.04 290.11,39.52 288.76,39.52 287.01,41.28 282.43,41.28 280.11,43.6 274.95,43.6 266.37,52.19 264.86,52.19 257.48,59.57 252.84,59.57 249.83,62.59 249.83,72.68 246.23,76.28 246.23,77.44 245.9,77.77 245.9,78.94 240.25,84.59 240.25,86.07 239.83,86.49 239.83,86.49 238.06,88.27 238.06,89.65 235.59,92.12 235.59,92.96 230.93,97.61 v2(229.9,97.61) ; v2(106.4,110.64) 107.74,111.97 112.88,111.97 ; v2(159.5,130.49) 159.5,130.49 159.5,130.49 159.5,130.21 156.18,126.89 155.32,126.89 154.67,126.23 154.67,125.59 154.41,125.33 153.25,125.33 152.91,124.99 152.91,124.65 152.46,124.21 149.02,124.21 148.63,123.82 142.48,123.82 141.3,125 141.2,125.1 141.2,125.67 140.92,125.95 140.51,125.95 140.12,125.56
  IN3 w0.127: v2(228.85,125.05) 228.85,125.05 228.85,125.01 229.09,124.77 229.09,120.92 229.72,120.29 229.72,114.07 230.03,113.76 230.03,112.42 229.72,112.11 229.72,109.68 230.1,109.3 231.08,108.33 231.08,106.5 231.69,105.89 231.69,103.83 231.25,103.39 231.25,102.95 229.34,101.05 229.34,98.16 229.89,97.61 v2(229.9,97.61)
  IN4 w0.109: v2(159.5,130.49) 161.68,130.49 163.72,128.45 167.84,128.45 169.84,126.45 174.07,126.45 174.41,126.8 182.02,126.8 182.62,126.19 183.85,126.19 184.46,125.58 185.28,125.58 186.2,126.5 193.28,126.5 194.15,125.63 196.29,125.63 197.16,126.5 201.01,126.5 201.72,125.79 204.96,125.79 205.58,126.42 207.33,126.42 208.47,125.28 211.4,125.28 211.69,125.57 211.69,125.8 212.21,126.32 213.74,126.32 214.69,125.37 227.94,125.37 228.26,125.05 v2(228.85,125.05)
  BOTTOM w0.102: v2(106.4,110.64) 105.07,110.64 103.99,111.72 103.99,115.6 104.4,116 v1(104.4,116.91) 104.4,117.95 105.39,118.94 105.39,120.02 RH211.2
PLTRST_TBT#: length 118.7
  TOP w0.102: JIO2.100 53.03,46.85 53.61,47.43 v2(54.08,47.43)
  IN2 w0.127: v2(110.78,115.38) 110.35,114.96 108.18,114.96 106.21,112.99 106.21,112.46 104.77,111.01 104.77,110.68 102.36,108.27 102.36,104.75 102.75,104.36 102.75,98.8 104.63,96.92 104.63,93.76 104.9,93.48 104.9,91.46 104.14,90.7 101.61,90.7 101.6,90.7 100.51,90.7 87.06,77.25 87.06,65.42 75.45,53.8 72.34,53.8 71.74,53.21 68.41,53.21 64.6,49.4 56.47,49.4 54.5,47.43 v2(54.08,47.43)
  BOTTOM w0.102: RH197.2 106.43,121.21 107.05,120.59 107.22,120.59 108.18,119.63 108.18,118.46 107.12,117.39 107.12,116.02 107.6,115.54 v1(107.8,115.54) 109.33,115.54 109.78,116 110.45,116 110.78,115.67 v2(110.78,115.38)
PLTRST_TPM#: length 111.1
  TOP w0.102: RH346.2 107.34,123.16 106.99,122.81 v2(106.99,122.78)
  IN2 w0.127: v2(106.99,122.78) 106.99,122.88 106.4,123.46 106.4,127.5 111.05,132.14 111.05,133.8 111.54,134.28 115.19,134.28 115.96,133.52 116.89,133.52 117.89,134.52 120.19,134.52 121.86,136.19 125.68,136.19 128.45,138.96 133.64,138.96 136.94,142.26 141.05,142.26 142.22,141.08 142.22,140.27 143.32,139.17 148.72,139.17 149.4,139.85 150.92,139.85 151.24,140.16 151.24,140.86 151.77,141.4 156.37,141.4 157.3,140.47 161.88,140.47 164.33,138.02 167.95,138.02 168.57,138.64 170.65,138.64 171.13,138.16 173.91,138.16 174.12,137.96 181.61,137.96 181.71,138.07 186.76,138.07 187.64,137.18 187.88,137.18 v2(188.19,136.86)
  BOTTOM w0.102: U637.17 190,131.75 189.84,131.91 189.83,131.91 189.5,132.24 189.25,132.24 188.17,133.32 RH187.2 187.43,133.78 187.63,133.98 188.21,133.98 188.46,134.23 188.46,135.06 189.28,135.88 189.28,136.99 189,137.27 188.6,137.27 v2(188.19,136.86)
PLTRST_USH#: length 202.6
  TOP w0.102: v2(168.03,113.75) 168.03,113.07 164.94,109.99 164.94,109.07 164.22,108.35 164.22,107.42 162.84,106.05 162.84,104.41 162.01,103.57 162.01,98.69 161.23,97.91 v2(161.23,97.68) ; v2(140.44,92.41) 140.16,92.69 132.03,92.69 131.8,92.92 126.66,92.92 125.01,91.27 125.01,90.63 124.06,89.68 124.06,87.78 123.61,87.33 122.79,87.33 120.57,89.56 116.76,89.56 115.77,90.54 111.2,90.54 109.68,92.06 109.68,92.69 109.39,92.98 109.03,92.98 108.37,93.64 108.03,93.64 107.61,94.06 106.34,94.06 105.8,94.6 v2(105.23,94.6) 104.76,94.6 100.29,90.14 99.75,90.14 98.01,88.4 93.21,88.4 76.33,71.52 76.33,44.15 75.62,43.44 CZ57.1 74.43,43.3 JUSH1.6
  IN2 w0.127: v2(140.44,92.41) 141.27,92.41 141.85,91.83 141.85,89.68 143.56,87.97 149.67,87.97 149.97,88.26 149.97,91.16 151.92,93.11 153.92,93.11 157.54,96.73 159.17,96.73 159.36,96.92 159.36,97.37 159.68,97.68 v2(161.23,97.68) ; v2(105.62,111.18) 105.62,111.16 102.62,108.16 102.62,104.85 103.01,104.46 103.01,98.91 104.88,97.04 104.88,94.95 v2(105.23,94.6)
  BOTTOM w0.102: v2(105.62,111.18) 104.85,111.18 104.22,111.81 104.22,115.5 104.75,116.03 104.75,117.93 104.98,118.16 RH210.2 ; RH359.2 171.5,118.14 172.01,118.65 172.01,119.39 171.87,119.53 168.8,119.53 168.46,119.19 168.46,117.82 168.03,117.39 v2(168.03,113.75)
PLTRST_USH#_EC: length 7.2
  BOTTOM w0.102: v1(169.8,116.2) 169.8,116.83 170.2,117.23 RH359.1 170.36,117.23 170.82,116.77 170.82,115.95 171.05,115.72 171.87,115.72 172.25,115.34 172.25,114.83 173.16,113.92 173.16,113.86 173.5,113.51 U46.A62
PM_LANPHY_ENABLE: length 156.5
  TOP w0.089: v2(128.5,118.6) 128.13,118.96 UH1.AR15
  TOP w0.102: v2(257.09,119.08) 257.1,119.07 R555.1
  IN2 w0.089: v2(128.5,118.6) 129.38,118.6 129.7,118.28 131.62,118.28 131.67,118.33 135.78,118.33 136.42,117.69 141.2,117.69 141.64,117.25 141.76,117.25
  IN2 w0.127: v2(219.14,127.32) 216.08,127.32 215.49,126.73 207.37,126.73 207.18,126.92 201.54,126.92 201.48,126.98 196.74,126.98 195.66,125.9 191.21,125.9 189.83,124.52 189.62,124.52 188.76,123.67 187.95,123.67 187.14,122.85 184.14,122.85 183.6,122.32 179.92,122.32 178.39,120.78 171.97,120.78 168.07,116.89 164.74,116.89 163.96,117.67 161.75,117.67 161.51,117.43 154.03,117.43 153.67,117.08 144.36,117.08 144.18,117.25 141.76,117.25
  IN4 w0.109: v2(234.93,124.48) 234.67,124.73 231.57,124.73 230.2,126.11 220.36,126.11 v2(219.14,127.32)
  BOTTOM w0.089: 130.66,126.2 130.66,124.19 130.14,123.67 130.14,120.82 129.69,120.38 129.28,120.38 128.59,119.68 127.5,119.68 127.29,119.47 127.29,119.17 127.86,118.6 v2(128.5,118.6)
  BOTTOM w0.102: v2(257.09,119.08) 257.79,119.78 257.79,121.56 256.52,122.83 v1(255.07,122.83) 250.98,122.83 248.51,125.31 244.76,125.31 243.21,123.76 239.36,123.76 238.94,123.34 238.6,123.34 238.59,123.36 236.05,123.36 v2(234.93,124.48) ; RH338.1 130.01,127.29 130.66,126.64 130.66,126.2
PM_RSMRST#_AND: length 3.2
  TOP w0.102: UC4.4 192.53,103.53 192.62,103.44 v1(192.62,103.33) 192.62,103.12 191.85,102.36 RC154.1
PME#: length 2.7
  TOP w0.089: UH1.BD17 126.88,124.39 127.36,124.87 127.36,125.64 T178.1
POA_WAKE#: length 243.1
  TOP w0.102: v2(111.8,93.24) 111.8,92.87 111.58,92.64 111.06,92.64 110.03,93.67 109.35,93.67 108.64,94.38 108.45,94.38 106.98,95.85 104.72,95.85 99.91,91.05 99.37,91.05 97.63,89.31 92.83,89.31 68.99,65.48 68.99,53.75 63.61,48.36 63.61,43.96 63.07,43.43 63.07,40.77 65.16,38.69 65.16,36.09 65.63,35.62 66.59,35.62 67.41,34.8 JUSH1.23
  IN2 w0.127: v2(203.4,86.85) 203.4,87.74 203.09,88.06 203.09,91.22 200.67,93.63 200.11,93.63 199.65,94.09 197.19,94.09 196.26,95.02 191.63,95.02 190.11,96.54 185.68,96.54 184.6,97.62 184.02,97.62 182.8,97.62 181.53,98.89 176.66,98.89 176.54,98.77 175.94,98.77 175.82,98.89 173.44,98.89 172.45,99.88 171.56,99.88 171.24,100.2 167.82,100.2 167.55,99.93 162.49,99.93 160.58,101.84 158.33,101.84 154.11,97.62 149.14,97.62 146.9,95.38 136.14,95.38 135.72,94.97 134.24,94.97 132.76,93.49 112.06,93.49 v2(111.8,93.24)
  IN3 w0.127: v2(204.57,117.75) 204.12,117.75 201.85,115.47 201.85,108.12 201.82,108.09 201.82,107.75 201.83,107.73 201.83,106.23 202.03,106.04 202.03,103.88 203.19,102.72 203.19,101.72 202.16,100.69 202.16,97.37 203.16,96.36 203.16,95.56 202.95,95.35 202.9,95.35 202.64,95.09 202.64,94.76 203.73,93.67 203.73,92.13 203.4,91.81 v2(203.4,86.85)
  BOTTOM w0.102: R880.2 207.08,121 206.61,121.46 206,121.46 205.63,121.09 205.63,119.13 205.85,118.91 205.85,116.67 204.89,115.71 U51.B68 204.5,116.02 204.96,116.48 204.96,117.37 v2(204.57,117.75)
POWER_SW#_MB: length 202.2
  TOP w0.102: SW1.2 v2(208.78,150.92) SW1.4 ; v2(292.65,47.92) 292.42,48.15 290.62,48.15 290,47.53 JPB1.1
  IN3 w0.127: v2(216.89,131.6) 216.89,129.33 218.08,128.15 218.08,125.71 220.07,123.72 220.07,113.95 220.76,113.27 220.76,110.61 220.88,110.48 220.88,108.45 221,108.32 221,106.02 221.39,105.64 221.39,104.32 221.17,104.1 221.17,103.72 221.48,103.41 v2(221.48,103.37) ; v2(292.65,47.92) 292.29,48.28 279.86,48.28 261.6,66.54 261.6,69.15 257.47,73.28 257.47,82.78 256.71,83.54 256.71,83.54 256.28,83.97 256.28,86.99 256.71,87.42 256.71,88.54 256.11,89.14 255.52,89.14 253.17,91.49 249.8,91.49 249.44,91.85 249.19,91.85 248.12,92.92 247.46,92.92 246,94.38 239.67,94.38 239.29,94.76 230.47,94.76 229.36,93.66 227.15,93.66 227.1,93.71 226.29,93.71 225.95,94.05 222.53,94.05 219.91,96.67 v2(219.91,98.06) ; v2(211.48,132.54) 211.48,132.56 211.21,132.28 210.61,132.28 209.97,132.93 209.97,140.99 210.54,141.56 210.54,143.09 210.93,143.47 210.93,144.17 208.78,146.31 v2(208.78,150.92)
  IN4 w0.109: v2(216.89,131.6) 215.1,131.6 214.54,132.16 211.88,132.16 211.5,132.54 v2(211.48,132.54)
  BOTTOM w0.102: v2(208.78,150.92) 208.78,151.83 PWRSW1.1 210.19,152.13 C759.1 ; v2(219.91,98.06) 219.91,98.25 ; 219.91,98.25 219.91,98.92 221.48,100.49 v2(221.48,103.37) ; 219.91,98.25 220.35,98.69 221.04,98.69 v1(221.3,98.42) 221.48,98.24 JAPS1.11 ; v2(211.48,132.54) 211.48,132.56 211.24,132.31 211.01,132.31 210.1,131.4 210.1,125.69 210.93,124.86 210.93,122.9 211.15,122.67 211.15,121.98 210.93,121.75 210.93,120.99 210.29,120.35 210.29,118.89 209.99,118.59 R811.2 C1354.1
POWER_SW_IN#: length 10
  TOP w0.102: v2(206.3,118.06) 206.3,117.99 206.23,117.93 206.23,117.74 v1(205.12,116.63) 204.26,115.77 v2(204.26,115.1)
  BOTTOM w0.102: U51.B67 204,115.35 v2(204.26,115.1) ; v2(206.3,118.06) 206.56,117.79 206.56,117.51 206.83,117.24 208.16,117.24 208.21,117.3 208.35,117.3 208.45,117.4 208.45,117.54 208.64,117.73 C1352.1 R810.2 209.26,118.97 209.26,119 R811.1
PROCHOT_GATE: length 247.2
  TOP w0.254: v2(334.23,42.46) 334.33,42.46 334.88,41.91 334.88,40.04 335.4,39.52 v1(335.58,39.52) 335.84,39.26 337.1,39.26 337.61,39.77 PU105.2
  IN2 w0.254: v2(172.14,114.36) 172.14,116.53 173.38,117.77 174.9,117.77 175.12,118 175.12,118.35 175.72,118.94 180.08,118.94 180.82,119.69 181.21,119.69 181.99,120.47 187.92,120.47 189.11,121.66 191.86,121.66 192.87,122.68 193.63,122.68 194.18,123.22 196.45,123.22 196.89,123.66 196.89,123.91 196.89,123.92 196.89,124.02 197.13,124.26 200.82,124.26 201.81,125.25 205.42,125.25 206.01,124.66 215.44,124.66 216.59,125.8 219.89,125.8 220.84,124.85 222.53,124.85 225.61,121.77 225.61,117.8 228.74,114.67 229.24,114.67 230.93,112.98 230.93,110.07 232.19,108.81 232.19,108.25 232.75,107.69 232.82,107.69 233.34,107.16 233.34,104.91 232.31,103.88 232.31,103.87 231.28,102.84 231.28,102.65 228.63,100 228.63,97.63 227.7,96.71 227.7,93.92 232.16,89.45 236.52,89.45 240.97,85 240.97,83.96 246.06,78.87 246.06,77.95 247.05,76.96 249.98,76.96 257.03,69.91 257.03,67.69 259.02,65.7 259.02,63.96 276.98,46 279.4,46 283.28,42.12 288.83,42.12 291.11,39.83 292.58,39.83 297.16,35.25 300.02,35.25 300.48,34.79 304.31,34.79 304.75,35.24 307.11,35.24 308.31,34.03 308.51,34.03 309.5,33.04 311.22,33.04 312.13,33.95 315.72,33.95 315.96,33.71 318.56,33.71 319.18,34.34 319.18,35.03 319.83,35.68 319.83,35.69 321.92,37.78 323.26,37.78 323.63,38.15 323.63,39.48 323.82,39.67 326.41,42.26 334.03,42.26 v2(334.23,42.46)
  BOTTOM w0.254: R416.1 R415.2 334.71,42.46 v2(334.23,42.46) ; v2(172.14,114.36) 172.53,113.97 172.61,113.97 173.57,113.01 U46.A61
PS_ID: length 327.4
  TOP w0.102: PU1.4 14.94,17.33 17.87,20.26 19.66,20.26 v2(21.92,22.52) ; PT1.1 201.4,107.25 v2(201.42,107.27) 201.8,107.65 201.8,108.07 201.06,108.81 201.06,112.63 201.91,113.49 201.92,113.49 202.05,113.62 202.05,114.64 202,114.69 202,115.91 202.67,116.59 202.67,118.25 201.12,119.8 201.12,123.14 201.78,123.8 201.78,133.57 199.93,135.42 199.93,138.85 199.19,139.59 197.65,139.59 v2(197.59,139.53)
  IN2 w0.127: v2(21.92,22.52) 22.31,22.91 22.31,28.49 23.63,29.81 23.63,33.45 22.99,34.08 22.99,35.86 23.63,36.49 23.63,45.79 22.39,47.03 22.39,51.81 25.2,54.61 25.2,62.2 28.26,65.26 55.1,65.26 57.07,63.29 75.01,63.29 83.25,71.53 83.25,79.89 90.7,87.33 90.7,97.7 96.28,103.29 96.28,109.01 97.39,110.11 97.39,112.38 101.56,116.56 103.64,116.56 104.2,117.11 104.2,121.05 103.94,121.31 103.94,127.19 107.57,130.82 107.57,133.07 110.35,135.85 117.24,135.85 118.85,137.46 125.15,137.46 129.44,141.75 134.64,141.75 136.42,143.53 142.71,143.53 143.27,144.09 149.45,144.09 149.69,143.85 153.65,143.85 153.9,143.59 156.89,143.59 158.48,142.01 163.26,142.01 165.16,140.11 165.86,140.11 165.91,140.16 171.29,140.16 171.76,139.69 174.55,139.69 174.75,139.49 178.52,139.49 180.97,139.49 182.52,141.03 186.82,141.03 188.32,139.53 v2(197.59,139.53)
  BOTTOM w0.102: U51.B24 201.36,106.65 201.36,107.21 v2(201.42,107.27)
PSID_DISABLE#: length 363.9
  TOP w0.102: v2(202.75,95.74) 205.8,95.74 207.89,97.82 208.81,97.82 209.23,98.25 209.23,102.46 209.37,102.6 209.37,103.57 208.12,104.82 208.12,106.1 208.47,106.45 208.47,112.82 208.46,112.84 208.46,114.3 207.83,114.94 207.83,116.52 207.55,116.8 207.55,118.36 205.28,120.63 205.28,123.9 204.07,125.12 204.07,132.93 203.24,133.75 203.24,136.1 201.97,137.37 201.97,138.01 v2(201.34,138.64) ; v2(25.71,42.9) 23.3,40.48 23.3,38.37 17.92,32.99 14.1,32.99 8.95,27.83 PR13.2
  IN2 w0.127: v2(201.34,138.64) 200.96,138.26 197.08,138.26 196.83,138.01 191.64,138.01 191.48,137.85 191.46,137.87 187.93,137.87 187.72,137.87 186.98,138.6 181.53,138.6 181.4,138.47 178.1,138.47 174.33,138.47 174.13,138.67 171.34,138.67 170.86,139.15 168.36,139.15 167.74,138.53 164.54,138.53 162.07,140.99 158.05,140.99 157.14,141.9 148.46,141.9 147.87,142.49 142.94,142.49 142.66,142.77 136.73,142.77 133.43,139.47 128.23,139.47 125.47,136.7 121.65,136.7 119.98,135.03 117.68,135.03 116.72,134.07 116.16,134.07 115.4,134.83 111.3,134.83 110.52,134.05 110.52,132.33 105.9,127.71 105.9,122.52 106.4,122.01 106.4,119.95 106.97,119.39 106.97,118.54 107.47,118.04 107.47,115.33 105,112.86 104.43,112.86 100.44,108.86 100.44,105.53 99.55,104.64 99.55,103.24 98.49,102.19 97.86,102.19 97.7,102.19 96.92,101.41 96.84,101.33 92.47,96.97 92.47,85.59 85.03,78.15 85.03,68.28 77.57,60.81 71.14,60.81 69.65,59.33 55.77,59.33 52.38,62.72 29.31,62.72 27.74,61.15 27.74,54.64 24.31,51.21 24.31,47.63 25.4,46.54 25.4,43.2 v2(25.71,42.9) ; v2(202.75,95.74) 202.68,95.74 202.32,96.1 199.3,96.1 198.94,96.45 198.93,96.45 198.62,96.76 198.62,97.16 198.19,97.59 196.99,97.59 196.47,97.07 193.69,97.07 192.06,98.7 186.4,98.7 185.45,99.65 185.02,99.65 182.64,102.03 182.64,102.81 182.4,103.06 181.84,103.06 v2(180.83,104.07)
  BOTTOM w0.102: v2(180.83,104.07) 180.66,104.24 180.66,104.74 181.05,105.14 U46.A37
PWD_UN8: length 9.1
  TOP w0.102: UN8.3 v2(26.96,32.06) ; v2(24.82,35.17) 24.82,35.71 24.49,36.04 23.07,36.04 22.99,35.96 RN78.2
  IN1 w0.109: v2(24.82,35.17) 24.97,35.17 25.38,34.77 25.38,32.33 25.65,32.06 v2(26.96,32.06)
PWD_UN9: length 7.4
  TOP w0.102: UN9.3 v2(37.94,32.07) ; RN79.2 v2(35.13,34.08)
  IN2 w0.127: v2(37.94,32.07) 35.94,34.08 v2(35.13,34.08)
  BOTTOM w0.102: v2(37.94,32.07) 38.16,32.07 39.48,30.75 v1(39.7,30.75)
PWM1_1PH/ICCMAX1: length 51.5
  TOP w0.203: PU1100.44 260.91,44.37 v2(261.04,44.24)
  IN3 w0.254: v2(232.6,66.94) 233.57,65.97 235.38,65.97 237.66,68.24 240.29,68.24 242.93,65.61 242.93,65.17 242.42,64.66 242.42,58.28 245.91,54.8 246.48,54.8 246.9,54.38 248.15,54.38 249.04,53.49 250.2,53.49 250.2,53.49 256.14,53.49 257.59,52.03 257.59,48.83 260.29,46.13 260.29,45 v2(261.04,44.24)
  BOTTOM w0.203: PU1700.4 232.93,68.3 v1(232.3,67.67) 232.3,67.24 v2(232.6,66.94)
  BOTTOM w0.254: v2(261.04,44.24) 260.75,44.53 PR1120.1
PWM1_3PH_A/ICCMAX3A: length 29.6
  TOP w0.203: v2(252.44,46.12) 252.59,45.97 PU1100.18
  IN4 w0.254: v2(238.98,58.57) 238.98,57.79 241.28,55.49 241.28,51.04 242.62,49.69 247,49.69 248.09,48.6 248.09,46.72 248.88,45.93 251.61,45.93 251.8,46.12 v2(252.44,46.12)
  BOTTOM w0.102: PR1155.1 254.27,47.83 v1(255.06,48.62)
  BOTTOM w0.203: PU1200.4 239.27,58.92 238.98,58.63 v2(238.98,58.57)
  BOTTOM w0.254: v2(252.44,46.12) 252.56,45.99 253.07,45.99 253.64,46.57 253.64,47.01 254.09,47.45 PR1155.1
PWM1_3PH_B/ICCMAX3B: length 43.1
  TOP w0.102: v2(251.87,43.52) 250.71,43.52 v1(250.57,43.66)
  TOP w0.203: v2(251.87,43.52) 251.99,43.64 252.82,43.64 253.14,43.97 PU1100.23
  TOP w0.254: PU1400.4 233.3,17.1 v2(233.07,17.33)
  IN4 w0.254: v2(251.87,43.52) 251.8,43.58 248.84,43.58 243.18,37.92 243.18,30.64 235.44,22.9 235.44,21.18 233.07,18.82 v2(233.07,17.33)
  BOTTOM w0.254: PR1152.1 253.71,43.01 253.07,43.64 251.99,43.64 v2(251.87,43.52)
PWM2_3PH_A/ADDR: length 22.1
  TOP w0.203: v2(251.99,45.57) v1(252.79,45.57) PU1100.19
  IN4 w0.254: v2(251.99,45.57) 251.91,45.49 248.54,45.49 247.51,46.52 247.51,48.57 246.9,49.18 242.73,49.18 242.37,48.81 239.26,48.81 238.94,48.5 v2(238.94,48.18)
  BOTTOM w0.203: v2(238.94,48.18) 238.94,48.27 239.27,48.6 PU1201.4
  BOTTOM w0.254: v2(251.99,45.57) 252,45.58 253.2,45.58 254.18,46.57 PR1156.1
PWM2_3PH_B/DOSC1: length 35.8
  TOP w0.102: v2(252.4,44.13) 252,44.13 v1(251.9,44.03)
  TOP w0.203: PU1100.22 252.97,44.37 252.73,44.13 v2(252.4,44.13)
  TOP w0.254: PU1401.4 233.3,27.79 v2(233.16,27.93)
  IN4 w0.254: v2(233.16,27.93) 233.7,28.48 234.79,28.48 235.56,27.71 239.46,27.71 242.77,31.01 242.77,38.14 248.68,44.05 252.32,44.05 v2(252.4,44.13)
  BOTTOM w0.254: v2(252.4,44.13) 254.04,44.13 PR1159.1
PWM3_3PH_A/VBOOT: length 22.3
  TOP w0.203: PU1100.20 252.5,45.17 252.44,45.11 252.44,45.1 v2(252.43,45.1)
  IN4 w0.254: v2(238.9,37.76) 238.9,37.19 239.22,36.88 240.21,36.88 248.37,45.04 252.38,45.04 v2(252.43,45.1)
  BOTTOM w0.203: PU1202.4 239.32,38.22 238.9,37.8 v2(238.9,37.76)
  BOTTOM w0.254: PR1157.1 253.83,45.68 253.26,45.1 v1(253,45.1) v2(252.43,45.1)
PWM3_3PH_B/DOSC3: length 44.1
  TOP w0.102: v2(233.14,38.06) v1(233.14,38.79)
  TOP w0.203: v2(251.93,44.53) 251.99,44.6 252.63,44.6 252.8,44.77 PU1100.21 ; v2(233.14,38.06) 233.28,37.92 PU1402.4
  IN4 w0.254: v2(251.93,44.53) 251.87,44.47 248.46,44.47 242.35,38.36 242.35,31.26 239.37,28.28 236.18,28.28 235.04,29.42 235.04,36.23 234.57,36.7 234.04,36.7 233.14,37.6 v2(233.14,38.06)
  BOTTOM w0.254: PR1158.1 253.64,44.79 253.47,44.61 252.01,44.61 v2(251.93,44.53)
PWR_SRC_ON: length 202.3
  TOP w0.102: v2(54.08,38.31) 54.04,38.35 JIO2.66
  IN2 w0.127: v2(54.08,38.31) 54.65,38.87 57.96,38.87 58.5,38.34 61.31,38.34 61.5,38.15 67.06,38.15 68.5,39.58 68.5,40.32 74.49,46.31 74.49,46.62 75.58,47.71 v2(78.47,47.71) 78.71,47.71 93.78,62.78 93.78,72.56 94.89,73.67 94.89,75.3 99.53,79.94 100.04,79.94 103.14,83.04 105.49,83.04 106.15,83.7 106.95,83.7 108.34,85.08 111.55,85.08 112.3,85.83 116.52,85.83 116.86,85.49 122.59,85.49 123.42,84.66 125.41,84.66 126.49,85.75 131.13,85.75 131.79,85.08 135.85,85.08 136.59,84.34 137.92,84.34 138.4,83.87 143.07,83.87 143.82,83.12 152.22,83.12 156.47,87.37 158.89,87.37 161.53,84.73 166.66,84.73 167.34,84.06 167.99,84.06 169.15,85.22 174.6,85.22 175.04,84.78 178.05,84.78 178.35,84.48 179.96,84.48 180.45,84.96 180.45,85.99 179.68,86.75 179.68,88.74 181.3,90.36 181.66,90.36 183.09,91.79 183.09,92.84 182.32,93.61 180.62,93.61 180.24,93.23 v2(180.24,93.21)
  IN3 w0.127: v2(180.24,93.21) 180.24,93.23 180.97,93.95 180.97,96.49 182.99,98.51 182.99,103.06 182.15,103.9 182.15,105.57 181.78,105.94 181.78,107.16 182.04,107.42 182.04,107.78 181.77,108.05 181.24,108.05 180.61,108.68 180.61,113.77 v2(180.75,113.91)
  BOTTOM w0.102: v2(78.47,47.71) 79.42,46.77 v3(79.42,45.87) ; v2(180.75,113.91) 181.17,114.33 181.17,114.9 181.3,115.04 U46.B13
RED_DOCK: length 80.4
  TOP w0.102: JMXM1.196 171.75,80.93 172.55,81.73 172.8,81.73 173.61,82.54 173.97,82.54 175.9,84.48 175.9,85.21 v2(175.82,85.29)
  IN3 w0.127: v2(169.9,145.69) 169.78,145.56 169.78,144.68 168,142.9 168,137.2 167.19,136.39 167.19,136.25 165.44,134.5 165.44,127.51 168.08,124.86 168.08,123.53 168.25,123.36 168.25,121.29 169.2,120.34 169.2,115.53 169.72,115.01 169.72,113 170.59,112.12 170.59,111.5 171.97,110.13 171.97,109.41 171.33,108.77 171.33,108.02 170.57,107.26 170.57,104.72 170.05,104.21 170.05,104.17 168.69,102.81 168.69,101.04 171.11,98.61 171.11,94.17 171.91,93.37 171.91,92.95 172.25,92.61 172.25,90.37 174.73,87.89 174.73,85.97 175.42,85.29 v2(175.82,85.29)
  BOTTOM w0.102: v2(169.9,145.69) 170.16,145.94 170.41,145.94 171.75,147.28 JDOCK1.53
REM_DIODE1_N: length 254.8
  IN1 w0.254: v2(222.98,95.48) 222.98,95.38 223.05,95.31 223.05,87.33 225.78,84.59 225.78,81.49 228.2,79.08 232.07,79.08 243.06,68.09 v2(243.44,68.09)
  IN3 w0.254: v2(267.7,40.34) 267.66,40.3 267.66,39.93 267.06,39.33 266.24,39.33 265.76,38.85 265.76,37.48 263.17,34.88 261.5,34.88 259.34,37.04 259.21,37.17 253.2,37.17 248.68,32.64 248.68,24.77 242.87,18.96 234.27,18.96 233.12,17.81 229.83,17.81 228.97,18.68 218.63,18.68 214.15,23.16 204.79,23.16 200.45,18.82 198.42,18.82 197.15,20.09 197.15,23.75 196.17,24.72 194.65,24.72 194.19,25.19 193.27,25.19 192.47,25.99 192.47,42.28 192.11,42.63 191.55,42.63 190.2,43.98 188.52,43.98 188.16,43.63 185.55,43.63 185,44.17 184.1,44.17 184.06,44.14 v2(183.51,44.14) ; v2(204.14,108.91) 205.75,108.91 206.41,108.26 207.66,108.26 208.32,107.59 211.08,107.59 211.23,107.74 212.68,107.74 212.69,107.75 212.77,107.75 212.92,107.91 213.71,107.91 v2(213.9,107.71) 213.9,107.71 213.9,107.47 213.99,107.38 213.99,107.31 214.52,106.78 214.52,106.02 215.26,105.28 215.26,103.39 215.61,103.03 215.61,102.62 216.27,101.96 216.27,99.36 217,98.64 217.9,98.64 218.08,98.81 222.48,98.81 223.88,97.41 223.88,96.78 223.05,95.95 223.05,95.65 223.05,95.56 v2(222.98,95.48)
  IN4 w0.254: v2(243.44,68.09) 243.44,67.48 244.14,66.78 244.14,59.86 247.5,56.5 247.5,53.63 247.78,53.36 250.36,53.36 250.97,53.97 253.97,53.97 255.08,52.86 255.08,51.58 259.57,47.09 259.57,40.91 261.22,39.26 263.88,39.26 265.47,40.85 267.38,40.85 267.7,40.53 v2(267.7,40.34)
  BOTTOM w0.254: v2(243.44,68.09) 243.25,67.91 v1(242.97,67.91) 242.47,68.4 C339.1 241.93,69.63 Q26.1 240.07,69.63 Q26.2 ; C1343.1 213.77,107.59 v2(213.9,107.71) ; v2(183.51,44.14) 183.46,44.19 182.67,44.19 C273.2 182.1,44.19 181.72,44.19 Q16.3 ; v2(204.14,108.91) 204.16,108.91 204.16,108.92 204.21,108.92 204.38,109.09 205.08,109.09 U51.B13
REM_DIODE1_P: length 254.1
  IN1 w0.254: v2(223.56,95.46) 223.56,87.54 226.29,84.81 226.29,81.7 228.41,79.59 232.28,79.59 243.08,68.79 v2(243.44,68.79)
  IN3 w0.254: v2(267.12,40.34) 267.15,40.3 267.15,40.14 266.85,39.83 266.03,39.83 265.25,39.06 265.25,37.69 262.95,35.39 261.71,35.39 259.7,37.4 259.42,37.68 252.99,37.68 248.17,32.85 248.17,24.98 242.66,19.47 234.06,19.47 232.91,18.32 230.04,18.32 229.18,19.18 218.84,19.18 214.36,23.67 204.58,23.67 200.24,19.32 198.63,19.32 197.65,20.3 197.65,23.96 196.38,25.23 194.86,25.23 194.4,25.69 193.48,25.69 192.98,26.2 192.98,42.49 192.32,43.14 191.76,43.14 190.41,44.49 188.31,44.49 187.95,44.13 185.76,44.13 185.21,44.68 184.1,44.68 184.06,44.72 v2(183.51,44.72) ; v2(207.12,108.8) 207.83,108.8 208.53,108.1 210.87,108.1 211.02,108.25 212.47,108.25 212.64,108.41 213.5,108.41 213.92,108.41 214.41,107.92 214.41,107.83 v2(214.5,107.74) 214.5,107.52 215.03,106.99 215.03,106.23 215.76,105.49 215.76,103.6 216.12,103.24 216.12,102.83 216.78,102.17 216.78,99.58 217.21,99.14 217.69,99.14 217.87,99.32 218.29,99.32 222.69,99.32 224.39,97.62 224.39,96.57 223.56,95.74 v2(223.56,95.46)
  IN4 w0.254: v2(243.44,68.79) 243.31,68.79 242.93,68.41 242.93,67.27 243.63,66.57 243.63,59.65 246.99,56.29 246.99,53.42 247.57,52.85 250.57,52.85 251.18,53.46 253.75,53.46 254.57,52.65 254.57,51.37 259.06,46.88 259.06,40.7 261.01,38.76 264.1,38.76 265.68,40.34 v2(267.12,40.34)
  BOTTOM w0.254: v2(183.51,44.72) 183.38,44.59 182.62,44.59 C273.1 182.1,44.54 181.72,44.54 Q16.2 181.04,45.02 180.72,44.69 180.17,44.69 179.84,44.37 Q16.1 ; C1343.2 214.5,107.21 v2(214.5,107.74) ; v2(243.44,68.79) 243.72,69.07 243.72,69.85 v1(243.64,69.93) 243.55,70.01 C339.2 242.19,70.29 240.63,70.29 240.62,70.28 Q26.3 ; v2(207.12,108.8) 207.12,108.79 206.76,108.79 206.69,108.86 U51.A13
REM_DIODE2_N: length 263.2
  TOP w0.254: Q27.3 209.82,104.94 C291.2 208.85,105.29 v2(208.8,105.24)
  IN3 w0.254: v2(204.45,108.41) 204.5,108.36 205.58,108.36 206.74,107.21 207.27,107.21 207.73,106.74 207.73,106 208.48,105.25 208.8,105.25 v2(208.8,105.24) ; v2(132.64,82.85) 132.48,82.68 132.36,82.68 132,82.32 132,81.53 130.3,79.84 100.31,79.84 98.47,78 96.36,78 72.74,54.39 71.93,54.39 67.98,50.44 67.98,42.82 68.94,41.87 70.61,41.87 71.88,40.6 71.88,36.24 70.65,35.01 68.56,35.01 67.97,35.6 65.74,35.6 62.83,32.68 57.03,32.68 51.29,26.94 40.85,26.94 v2(40.64,26.74)
  BOTTOM w0.254: Q17.2 28.21,24.46 28.86,25.11 Q17.1 30.07,24.53 30.61,24.53 30.81,24.33 30.81,24.05 31.35,23.52 C340.2 33.49,23.52 34.35,24.38 38.85,24.38 v1(39.97,25.5) 40.44,25.97 40.44,26.54 v2(40.64,26.74) ; v2(132.64,82.85) 132.67,82.87 132.67,83.4 131.14,84.93 131.14,88.92 132.09,89.87 135.26,89.87 136.51,88.62 138.35,88.62 142.05,84.92 143.38,84.92 145.24,83.07 170.03,83.07 170.81,83.84 173.28,83.84 173.52,84.09 177.25,84.09 177.78,84.62 177.78,85.51 177.88,85.61 177.88,87.9 178.38,88.4 181.3,88.4 182.1,89.2 201.53,89.2 206.11,93.78 206.11,93.8 208.03,95.71 208.74,95.71 211.81,98.79 211.81,100.77 209.4,103.19 209.4,104.38 209.4,104.39 209.4,104.75 209.01,105.14 208.97,105.14 208.87,105.24 208.82,105.24 ; v2(204.45,108.41) 204.63,108.41 204.83,108.61 U51.B14 ; v2(208.8,105.24) 208.82,105.24 ; 208.82,105.24 208.78,105.28 208.02,105.28 C1350.1
REM_DIODE2_P: length 266.8
  TOP w0.254: Q27.1 210.47,103.55 Q27.2 211.12,104.55 C291.1 209.2,106.2 v2(208.82,105.83)
  IN3 w0.254: v2(133.23,82.76) 133.23,83.12 132.81,83.54 132.33,83.54 131.49,82.7 131.49,81.74 130.09,80.35 100.1,80.35 98.26,78.51 96.14,78.51 72.53,54.89 71.72,54.89 67.47,50.65 67.47,42.61 68.73,41.36 70.4,41.36 71.37,40.39 71.37,36.45 70.44,35.52 68.77,35.52 68.18,36.11 65.53,36.11 62.62,33.19 56.82,33.19 51.08,27.45 v2(41.15,27.45) ; v2(207.07,107.72) 207.1,107.75 207.45,107.75 208.24,106.95 208.24,106.21 208.64,105.81 208.82,105.81 v2(208.82,105.83)
  BOTTOM w0.254: C1350.2 208.1,106.17 208.45,105.83 v2(208.82,105.83) 209.13,105.83 209.91,105.05 209.91,104.6 209.91,104.59 209.91,103.4 212.32,100.99 212.32,98.58 208.95,95.21 208.24,95.21 206.62,93.59 206.62,93.57 201.74,88.69 182.31,88.69 181.51,87.89 178.59,87.89 178.38,87.69 178.38,85.4 178.29,85.3 178.29,84.41 177.46,83.58 173.74,83.58 173.49,83.33 171.02,83.33 170.24,82.56 145.03,82.56 143.17,84.41 141.84,84.41 138.14,88.11 136.3,88.11 135.05,89.36 132.36,89.36 131.65,88.65 131.65,85.14 133.18,83.61 133.18,82.81 v2(133.23,82.76) ; Q17.3 29.89,25.76 30.61,25.04 31.02,25.04 31.37,24.68 C340.1 31.78,24.02 33.28,24.02 34.14,24.89 v1(35.49,24.89) 38.64,24.89 39.93,26.18 39.93,27.02 40.36,27.45 v2(41.15,27.45) ; v2(207.07,107.72) 207.05,107.74 207.05,107.77 206.46,108.36 U51.A14
REM_DIODE3_N: length 198.3
  TOP w0.254: v2(103.8,34.31) 103.93,34.31 104.07,34.17 C272.2 104.82,33.98 Q14.3
  IN1 w0.254: v2(103.8,34.31) 103.74,34.37 98.58,34.37 95.1,37.85 95.1,77.15 96.52,78.57 97.43,78.57 104.02,85.16 104.91,85.16 109.03,89.28 114.06,89.28 115.55,90.77 115.55,91.81 116.07,92.32 120.14,92.32 120.25,92.21 127.38,92.21 128.76,90.83 132.38,90.83 132.69,91.14 v2(132.69,91.4)
  IN3 w0.254: v2(206.89,106.64) 206.89,106.64 206.89,106.64 207.19,106.33 207.19,105.67 208.73,104.13 v2(208.73,103.31)
  BOTTOM w0.254: C1351.1 208.7,103.81 208.7,103.34 v2(208.73,103.31) 208.69,103.27 208.69,101.71 209.21,101.2 209.34,101.07 209.34,99.52 209.61,99.26 209.61,97.3 208.59,96.29 206.48,96.29 205.49,95.3 205.49,93.88 201.32,89.71 181.95,89.71 181.63,90.02 181.5,90.02 181.45,90.06 177.8,90.06 v1(177.17,89.43) 175.24,87.5 175.24,85.6 174.26,84.61 173.14,84.61 172.87,84.35 170.37,84.35 169.59,83.57 145.45,83.57 143.59,85.43 143.17,85.43 142.35,85.43 138.64,89.13 136.72,89.13 135.47,90.38 133.56,90.38 132.69,91.25 v2(132.69,91.4) ; U51.A15 206.24,107.86 206.58,107.52 206.58,107.52 206.86,107.23 206.87,107.23 206.9,107.2 206.9,106.62 206.89,106.64 206.89,106.64 v2(206.89,106.64)
REM_DIODE3_P: length 198.6
  TOP w0.254: Q14.1 107.02,35.28 Q14.2 104.82,35.28 C272.1 104.07,35.08 103.93,34.95 v2(103.8,34.95)
  IN1 w0.254: v2(103.8,34.95) 103.74,34.88 98.79,34.88 95.61,38.06 95.61,76.94 96.73,78.06 97.64,78.06 104.23,84.65 105.12,84.65 109.24,88.77 114.27,88.77 116.06,90.56 116.06,91.6 116.28,91.82 119.92,91.82 120.04,91.7 127.17,91.7 128.55,90.32 132.59,90.32 133.33,91.06 v2(133.33,91.4)
  IN3 w0.254: v2(208.15,103.31) 208.15,104 206.88,105.26 206.7,105.26 204.69,107.27 v2(204.44,107.27)
  BOTTOM w0.254: U51.B16 204.81,107.61 204.47,107.27 v2(204.44,107.27) ; v2(133.33,91.4) 133.33,91.33 133.77,90.89 135.68,90.89 v1(136.47,90.09) 136.93,89.64 138.85,89.64 142.56,85.94 142.96,85.94 142.96,85.94 143.8,85.94 145.66,84.08 169.38,84.08 170.16,84.86 172.66,84.86 172.93,85.12 174.05,85.12 174.73,85.81 174.73,87.71 177.59,90.57 181.67,90.57 181.71,90.53 181.84,90.53 182.16,90.22 201.11,90.22 204.98,94.09 204.98,95.51 206.27,96.79 208.38,96.79 209.1,97.51 209.1,99.05 208.83,99.31 208.83,100.86 208.7,100.99 208.7,100.99 208.18,101.5 208.18,103.27 v2(208.15,103.31) 208.18,103.35 208.18,103.8 C1351.2
REM_DIODE4_N: length 213.8
  IN3 w0.127: v2(333,26.9) 332.52,27.39 332.02,27.39 331.75,27.12 329.3,27.12 327.95,25.78 320.71,25.78 319.85,24.91 312.93,24.91 310.75,22.73 310.75,20.63 306.88,16.76 302.55,16.76 299.48,19.83 291.34,19.83 290.31,18.8 282.12,18.8 281.5,18.18 275.18,18.18 274.62,18.74 274.62,21.37 275.44,22.19 275.44,26.29 277.91,28.76 277.91,32.29 278.81,33.19 278.81,35.85 279.56,36.6 280.41,36.6 281.86,38.04 281.86,39.83 272.33,49.36 270.91,49.36 264.39,55.88 264.39,57.07 256.95,64.52 256.95,65.3 252.2,70.04 252.2,73.49 250.68,75.01 250.68,76.79 247.95,79.52 246.55,79.52 245.66,80.41 243.76,80.41 242.17,78.82 242.17,78.28 241.53,77.64 241.53,77.11 239.69,75.27 236.95,75.27 229.84,82.38 228.96,82.38 223.05,88.29 221.53,88.29 219.24,90.57 216.07,90.57 214.23,92.41 214.23,95.67 212.89,97.01 212.89,100.03 211.61,101.31 211.32,101.31 209.88,101.31 209.74,101.18 207.77,101.18 207.67,101.08 207.29,101.08 207.27,101.1 v2(207.27,101.1)
  BOTTOM w0.127: v2(333,26.9) 332.78,26.69 332.78,26.39 C288.2 333.18,25.98 333.18,25.22 333.18,25.21 Q15.3 ; U51.A16 205.79,107.2 205.79,106.14 206.05,105.87 206.35,105.87 206.86,105.37 206.86,104.25 C1346.1 206.8,103.68 206.8,101.57 v2(207.27,101.1)
REM_DIODE4_P: length 215.7
  IN3 w0.127: v2(332.27,26.87) 329.4,26.87 328.06,25.52 320.82,25.52 319.96,24.66 313.03,24.66 311,22.63 311,20.53 306.98,16.51 302.44,16.51 299.37,19.58 291.44,19.58 290.42,18.55 282.22,18.55 281.6,17.93 275.07,17.93 274.36,18.64 274.36,21.47 275.19,22.3 275.19,26.4 277.65,28.86 277.65,32.39 278.55,33.29 278.55,35.95 279.45,36.85 280.3,36.85 281.6,38.15 281.6,39.73 272.23,49.11 270.81,49.11 264.14,55.77 264.14,56.97 256.69,64.42 256.69,65.19 251.95,69.94 251.95,73.38 250.42,74.91 250.42,76.69 247.84,79.27 246.45,79.27 245.56,80.16 243.87,80.16 243.39,79.67 242.42,78.71 242.42,78.17 241.79,77.53 241.79,77 239.8,75.01 236.84,75.01 229.73,82.13 228.85,82.13 222.95,88.03 221.43,88.03 219.14,90.32 215.96,90.32 213.97,92.31 213.97,95.57 212.64,96.9 212.64,99.93 211.51,101.06 211.21,101.06 209.98,101.06 209.85,100.92 207.88,100.92 207.62,100.67 206.98,100.67 v2(206.68,100.96)
  BOTTOM w0.127: Q15.1 331.88,23.47 Q15.2 331.88,25.86 C288.1 332.4,26.39 332.4,26.74 v2(332.27,26.87) ; U51.B17 205.33,107.11 205.53,106.91 205.53,106.03 205.94,105.62 206.25,105.62 206.61,105.26 206.61,104.4 C1346.2 206.44,103.76 206.54,103.66 206.54,101.1 v2(206.68,100.96)
RES_BIAS: length 4.3
  TOP w0.102: R562.1 246.24,114.89 v1(246.98,114.89) 247.35,114.89 248.93,113.31 U31.12
RESET_OUT#: length 213.8
  TOP w0.089: UH1.AY1 135.26,121.56 135.42,121.72 135.42,122.5 136.38,123.46 v2(137.08,123.46) 137.2,123.46 137.58,123.85 137.96,123.85
  TOP w0.102: v2(163.93,78.01) 163.71,77.78 161.52,77.78 160.7,76.97 160.28,76.55 160.28,74.05 157.05,70.82 155.93,70.82 145.22,60.11 145.22,24.26 v1(149.08,20.4) 149.89,19.59 RC129.1 ; RH199.1 137.96,123.85
  IN3 w0.089: v2(137.08,123.46) 137.57,123.46 138.09,123.98 139.19,123.98 139.88,123.29 139.88,122.63 140.38,122.13 140.38,120.82 141.76,119.44 ; 141.76,113.8 139.58,111.62 139.58,108.25 141.5,106.33 141.5,105.85 141.76,105.6
  IN3 w0.127: 141.76,105.6 144.76,102.6 144.76,97.94 143.68,96.86 143.68,93.86 144.04,93.5 144.04,88.8 151.1,81.74 151.71,81.74 156.8,76.65 159.96,76.65 160.74,77.43 163.35,77.43 v2(163.93,78.01) ; v2(196.52,86.83) 196.52,89.31 198.16,90.95 198.16,92.83 197.65,93.33 197.65,95.22 195.03,97.85 195.03,101.58 191.69,104.92 191.69,105.99 v2(193.77,108.08) ; 141.76,113.8 141.84,113.88 141.84,119.36 141.76,119.44
  IN4 w0.109: v2(193.77,108.08) 193.85,108.16 194.52,108.16 194.52,108.16 194.8,108.16 196.45,109.82 197,109.82 v2(197.17,109.64)
  BOTTOM w0.102: v2(193.77,108.08) 193.71,108.08 193.28,108.51 193.15,108.64 193.15,109.38 R843.2 ; v2(196.52,86.83) 196.07,86.38 193.46,86.38 192.8,87.04 191.71,87.04 188.74,84.07 186.52,84.07 181.71,79.27 165.19,79.27 v2(163.93,78.01) ; U51.B39 196.19,109.11 196.32,108.99 196.83,108.99 197.1,109.25 197.1,109.56 v2(197.17,109.64)
RF_+1VSP: length 3.3
  TOP w0.102: v1(97.57,129.84) PR806.1
  TOP w0.254: PU800.5 99.84,128.88 99.63,129.09 99.21,129.09 PR806.1
RJ45_MDIN0: length 14.7
  TOP w0.229: T156.23 240.03,137.15 239.63,137.56 239.63,138.58 240.27,139.22 240.27,139.86 v2(240.39,139.98)
  IN4 w0.178: v2(240.39,139.98) 240.39,140.04 240.12,140.3 240.12,142.08 236.9,145.31 235.91,145.31 235.19,146.03 235.19,146.28 235.57,146.64 235.89,146.64 JLOM1.2
RJ45_MDIN1: length 14.9
  TOP w0.229: v2(245.04,138.82) 244.89,138.82 244.71,138.64 244.71,137.37 245.11,136.96 T156.19
  IN4 w0.178: v2(245.04,138.82) 244.93,138.72 244.76,138.72 244.64,138.83 244.64,139.4 238.68,145.37 238.68,145.5 239.15,145.97 239.15,146.23 239.3,146.37 JLOM1.6
RJ45_MDIN2: length 16.9
  TOP w0.229: JLOM1.5 239.21,146.46 239.33,146.34 239.33,144.63 240.9,143.07 v4(242.16,143.07) 244.21,143.07 246.68,140.6 246.68,138.86 247.5,138.04 247.5,137.33 247.65,137.18 T156.17
RJ45_MDIN3: length 19.1
  TOP w0.229: T156.13 252.73,137.15 252.49,137.4 252.36,137.4 252.1,137.66 252.1,140.01 251.35,140.76 v4(250.33,140.76) 248.3,140.76 244.33,144.74 242.1,144.74 241.48,145.36 241.48,146.31 241.76,146.6 242.05,146.6 JLOM1.8
RJ45_MDIP0: length 14.7
  TOP w0.229: v2(239.81,139.98) 239.93,139.86 239.93,139.36 239.29,138.72 239.29,137.54 238.76,137.02 T156.24
  IN4 w0.178: JLOM1.1 235.1,146.64 234.87,146.42 234.87,145.9 235.78,144.99 236.77,144.99 239.81,141.95 v2(239.81,139.98)
RJ45_MDIP1: length 14.9
  TOP w0.229: v2(244.19,138.83) 244.33,138.69 244.33,137.43 243.84,136.95 T156.20
  IN4 w0.178: JLOM1.3 237.17,146.17 237.84,145.51 238.09,145.51 244.33,139.27 244.33,138.97 v2(244.19,138.83)
RJ45_MDIP2: length 16.9
  TOP w0.229: T156.18 246.38,137.05 246.58,137.24 246.97,137.24 247.16,137.43 247.16,137.9 246.33,138.72 246.33,140.46 v4(245.27,141.52) 244.07,142.72 240.75,142.72 238.99,144.49 238.99,146.2 238.82,146.37 JLOM1.4
RJ45_MDIP3: length 19.1
  TOP w0.229: T156.14 251.46,137.27 251.76,137.56 251.76,139.85 251.18,140.42 248.16,140.42 v4(247.8,140.78) 244.18,144.39 241.96,144.39 241.14,145.22 241.14,146.46 241.25,146.57 JLOM1.7
RTD3_CIO_PWR_EN: length 180.1
  TOP w0.089: UH1.R39 v2(116.28,108.6)
  TOP w0.102: v2(53.5,44.35) JIO2.90
  IN1 w0.109: v2(105.75,87.8) 106.18,88.22 106.18,88.9 106.15,88.93 106.15,90.78 v2(106.7,91.32)
  IN2 w0.089: 112.37,107.53 114.98,107.53 116.05,108.6 v2(116.28,108.6) 116.78,108.1 120.63,108.1 120.79,107.94 121.99,107.94 122.79,108.73 125.65,108.73 125.84,108.54 126.53,108.54 126.98,108.1 126.98,107.84 127.55,107.27 129.27,107.27 129.52,107.02 133.2,107.02 134.28,105.94 141.76,105.94
  IN2 w0.127: 141.76,105.94 145.71,105.94 146.28,106.51 155.68,106.51 157.59,108.41 163.75,108.41 164.32,107.84 166.24,105.92 167.58,105.92 168,105.49 168,105.18 168.51,104.67 169.06,104.67 169.82,105.43 170.54,105.43 170.86,105.11 172.44,105.11 172.76,105.43 172.76,105.76 172.67,105.85 172.67,106.61 173.12,107.06 v2(173.12,107.21) ; v2(105.75,87.8) 105.22,87.26 101.09,87.26 100.68,87.26 100.68,87.26 100.47,87.26 89.1,75.88 89.1,63.49 77.38,51.77 73.46,51.77 70.94,49.26 69.19,49.26 66.89,46.96 63.94,46.96 62.56,45.59 61.89,45.59 61.13,44.83 54.27,44.83 54.2,44.76 53.91,44.76 v2(53.5,44.35) ; 112.37,107.53 110.09,107.53 109.64,107.08 108.52,107.08 106.67,108.92 105.62,108.92 104.27,107.58 104.27,105.65 104.63,105.3 104.63,104.57 104.63,104.39 105.39,103.63 105.39,102.02 105,101.64 105,99.54 107.66,96.88 107.66,94.07 107.07,93.48 107.07,91.7 v2(106.7,91.32)
  BOTTOM w0.102: U46.A49 173.21,107.01 173.12,107.11 v2(173.12,107.21)
RTD3_USB_PWR_EN: length 186.5
  TOP w0.102: JIO2.92 53.13,44.85 53.19,44.79 53.7,44.79 v2(54.14,45.22)
  IN2 w0.127: v2(181.05,97.18) 180.23,98 177.03,98 176.91,97.88 175.58,97.88 175.46,98 173.06,98 172.08,98.99 171.2,98.99 170.87,99.31 168.42,99.31 167.87,98.76 167.87,96.29 166.54,94.95 165.14,94.95 163.62,93.43 161.47,93.43 161.21,93.7 155.23,93.7 154.14,92.6 152.13,92.6 150.47,90.95 150.47,88.05 149.88,87.46 140.07,87.46 137.44,90.09 129.94,90.09 129.64,90.39 122.33,90.39 121.64,91.08 117.25,91.08 116.69,90.52 109.78,90.52 107.99,88.73 106.66,88.73 106.14,88.21 104.35,88.21 103.84,88.72 101.57,88.72 88.84,75.99 88.84,63.59 77.28,52.03 73.35,52.03 72.58,51.25 69.91,51.25 65.99,47.34 61.16,47.34 59.91,46.08 56.62,46.08 55.77,45.22 v2(54.14,45.22)
  IN3 w0.127: v2(179.91,114.03) 180.36,113.58 180.36,108.57 181.2,107.73 181.2,105.72 180.41,104.93 180.41,103.22 181.72,101.92 181.72,99.17 181.03,98.48 181.03,97.15 181.04,97.16 181.04,97.17 v2(181.05,97.18)
  BOTTOM w0.102: v2(179.91,114.03) 180.03,114.03 180.3,114.3 U46.B11
RUN_ON: length 229
  TOP w0.102: v2(186.64,101.87) 186.63,101.87 186.26,101.51 186.26,100.53 185.87,100.14 UZ23.3 ; v2(247.06,78.44) 247.06,78.3 v2(241.94,73.18) ; UZ22.3 239.76,79.46 239.62,79.33 239.62,78.44 240.08,77.99 v2(240.08,74.37)
  TOP w0.254: R881.1 308.17,30.74 v2(308.17,31.29)
  IN1 w0.109: v2(280.69,38.24) 285.04,38.24 288.58,34.7 293.4,34.7 v2(293.58,34.53) ; v2(240.08,74.37) 240.32,74.12 240.99,74.12 v2(241.94,73.18)
  IN2 w0.127: v2(215.31,107.7) 215.31,107.85 214.16,109 214.16,110.73 214.38,110.95 214.38,111.32 214.08,111.61 211.4,111.61 210.99,112.03 v2(210.99,112.03) ; v2(241.94,73.18) 241.47,73.65 241.47,74.65 240.34,75.78 240.34,76.35 237.34,79.35 221.26,79.35 217.58,83.03 210.39,83.03 205.65,87.76 205.65,92.95 203.67,94.93 203.67,94.94 v2(203.66,94.94)
  IN3 w0.127: v2(308.17,31.29) 308.17,32.7 308.46,33 308.46,33.99 306.68,35.77 297.94,35.77 297.11,34.95 293.99,34.95 v2(293.58,34.53) ; v2(204.31,111.5) 204.3,111.52 203.97,111.52 203.68,111.23 203.38,111.23 202.96,110.82 202.96,105.68 202.58,105.31 202.58,104.06 203.76,102.88 203.86,102.88 204.36,102.38 204.36,102.03 203.37,101.04 203.37,97.42 203.67,97.12 203.67,94.94 v2(203.66,94.94) ; v2(280.69,38.24) 280.69,39.51 271.97,48.23 271.08,48.23 268.05,48.23 264.71,51.56 264.71,53.66 263.19,55.18 263.19,56.53 259.88,59.84 253.24,59.84 250.66,62.41 250.66,72.71 249.36,74.02 249.36,76.81 247.72,78.44 v2(247.06,78.44)
  IN4 w0.109: v2(210.99,112.03) 208.5,112.03 207.34,110.88 206.22,110.88 205.6,111.5 v2(204.31,111.5)
  BOTTOM w0.102: v2(203.66,94.94) 203.67,94.94 203.67,94.94 201.15,92.42 201.15,92.1 200.68,91.63 197.55,91.63 196.18,93 196.18,93.02 196.04,93.16 196.04,94.15 192.69,97.51 v1(192.69,99.63) 190.29,102.02 186.79,102.02 v2(186.64,101.87) ; U51.B9 204.82,111.11 204.43,111.5 v2(204.31,111.5) ; v2(210.99,112.03) 210.6,112.03 R3730.2 ; QE2.2 213.55,104.93 214.54,105.92 214.55,105.92 215.31,106.68 v2(215.31,107.7)
RUN_ON#: length 3.4
  BOTTOM w0.102: RE68.2 215.92,104.93 QE2.5 QE2.6 214.8,103.67 v1(214.8,102.95)
RUN_ON_AND: length 38.9
  TOP w0.254: U9.4 322.32,7.43 321.1,8.66 316.27,8.66 314.43,10.5 v2(314.43,13.61) ; PU300.1 328.66,19.51 328.35,19.82 PC312.1 PR303.1 328.35,23.03 v1(327.87,23.52) 327.83,23.52 327.32,24.02 v2(327.26,24.02)
  IN1 w0.254: v2(327.26,24.02) 327.26,23.52 325.42,21.67 317.8,21.67 314.43,18.31 v2(314.43,13.61)
RUN_ON_R: length 4.1
  TOP w0.203: UZ20.3 305.94,29.87 306.2,29.61 v1(306.61,29.61) 306.84,29.61 307.01,29.79 R881.2 306.82,30.69 306.21,30.69 306.2,30.67 UZ20.5
RUNPWROK: length 62
  TOP w0.102: v2(200.59,117.88) 201.02,117.45 201.02,116.73 200.84,116.56 v1(200.84,116.12) 200.84,115.74 201.3,115.28 201.3,114.74 201.59,114.45 201.59,113.81 201.11,113.33 200.08,113.33 199.74,112.99 199.74,110.71 199.56,110.54 199.56,109.14 200.51,108.19 200.72,108.19 200.96,107.95 200.96,107.61 200.72,107.38 200.71,107.38 v2(200.53,107.2)
  IN4 w0.109: v2(200.59,117.88) 200.53,117.94 200.53,118.35 200.28,118.59 196.95,118.59 196.86,118.51 188.83,118.51 187.91,119.43 182.18,119.43 181.3,118.55 180.38,118.55 180.1,118.82 179.14,118.82 179.02,118.7 178.19,118.7 v2(177.13,117.64) ; v2(212.7,105.28) 212.26,105.72 212.26,109.37 211.86,109.78 209.51,109.78 209.06,109.33 206.02,109.33 205.78,109.58 203.71,109.58 203.55,109.41 203.21,109.41 203.12,109.5 202.11,109.5 200.98,108.37 200.98,107.63 200.72,107.37 200.7,107.37 v2(200.53,107.2)
  BOTTOM w0.102: U51.B26 200.5,107.17 v2(200.53,107.2) ; v2(177.13,117.64) 177.13,117.04 177.05,116.96 U46.A4 ; v2(212.7,105.28) 212.65,105.23 RE67.2 212.07,105.8 212.27,106.01 213.09,106.01 QE2.3
S3_1.2V: length 3.5
  BOTTOM w0.102: v1(56.14,14.96) 56.36,15.18 PR208.2
  BOTTOM w0.203: PR208.2 56.67,16.15 57.54,17.02 PU200.7
S5_1.2V: length 4.1
  TOP w0.102: PC215.1 57.67,18.88 v1(57.61,18.94)
  TOP w0.254: PC215.1 57.24,17.86 v2(56.98,17.61)
  BOTTOM w0.203: v2(56.98,17.61) 57.34,17.61 57.53,17.42 PU200.8
  BOTTOM w0.254: PR206.2 56.41,17.04 v2(56.98,17.61)
SATA_EXP_IFDET: length 243.3
  TOP w0.089: UH1.AD35 v2(118.47,114.29)
  TOP w0.102: U639.6 5.52,37.86 4.72,38.67 v2(4.72,39.97) ; UN9.20 40.43,28.45 v2(40.75,28.77) ; v2(6.41,53.79) 6.42,53.78 RH321.2 7.24,52.2 7.39,52.06 U6.4 ; v2(101.83,111.93) 101.83,111.63 99.22,109.01 v1(98.84,109.01) 98.35,109.01 96.33,106.99 95.85,106.99 v2(95.05,106.19) ; UN8.20 29.33,28.38 29.44,28.26 29.44,27.55 29.27,27.38 v2(29.27,26.79)
  IN1 w0.089: v2(118.47,114.29) 118.47,114.25 117.64,113.43 113.58,113.43 112.37,112.22
  IN1 w0.109: v2(101.83,111.93) 102.38,111.93 103.42,112.97 106.1,112.97 106.85,112.22 112.37,112.22 ; v2(6.41,53.79) 4.56,53.79 2.67,51.9 2.67,41.59 4.28,39.97 v2(4.72,39.97) ; v2(40.75,28.77) 40.75,28.41 39.2,26.86 39.2,25.68 38.35,24.82 34.36,24.82 33.5,23.97 32.29,23.97 31.88,24.38 31.88,25.62 32.36,26.11 32.36,26.61 31.83,27.14 30.64,27.14 30.28,26.79 v2(29.27,26.79)
  IN2 w0.127: v2(95.05,106.19) 94.47,105.61 94.47,105.07 89.43,100.03 89.43,90 63.98,64.56 58.61,64.56 56.21,66.96 54.76,66.96 54.33,66.53 27.73,66.53 23.93,62.73 23.93,55.14 19.33,50.54 10.29,50.54 8.65,52.18 8.02,52.18 v2(6.41,53.79)
  IN3 w0.127: v2(29.27,26.79) 27.74,26.79 25.35,29.18 22.65,29.18 12.6,39.22 12.6,44.95 14.18,46.53 14.18,50.64 11.03,53.79 v2(6.41,53.79)
SATA_LED#: length 13.5
  TOP w0.102: D100.2 298.2,3.82 301.98,3.82 302.26,4.1 302.26,5.29 302.37,5.39 D97.2 302.89,5.38 D98.2 303.14,3.96 305.29,3.96 v1(305.52,4.19) 306.28,4.95 D99.2 306.09,5.64 Q74.4
SATA_PRX_C_DTX_N1: length 6.3
  TOP w0.102: C698.2 172.79,153.98 172.79,154.92 172.1,155.61 v4(172.1,156.9) 172.1,157.48 v2(172.28,157.66)
  BOTTOM w0.102: v2(172.28,157.66) 172.1,157.48 172.1,157.09 172.25,156.93 JDOCK1.56
SATA_PRX_C_DTX_P1: length 6.3
  TOP w0.102: v2(171.7,157.66) 171.88,157.48 171.88,155.52 v4(172.15,155.25) 172.57,154.83 172.57,153.98 C697.2
  BOTTOM w0.102: v2(171.7,157.66) 171.88,157.48 171.88,157.05 171.75,156.92 JDOCK1.54
SATA_PRX_DTX_N1: length 134.3
  TOP w0.101: v2(116.05,104.53) 116.05,103.99 UH1.D39
  TOP w0.102: v2(172.36,151.52) 172.18,151.7 172.18,151.78 172.33,151.93 172.54,151.93 172.79,152.18 172.79,152.39 C698.1
  IN4 w0.109: v2(101.24,103.97) 101.24,105.18 100.35,106.08 100.35,109.58 104.13,113.37 104.13,129.45 103.22,130.36 103.22,137.19 105.22,139.2 107.33,139.2 108.14,140.01 108.65,140.01 109.79,141.15 115.74,141.15 116.92,139.97 122.48,139.97 123.32,140.81 126.39,140.81 127.61,139.59 133.3,139.59 137.39,142.13 144.9,142.13 146.1,143.34 149.9,143.34 150.52,143.96 152,143.96 153.12,145.08 153.12,145.87 153.18,145.93 154.05,146.81 154.58,146.81 157.06,146.81 158.55,148.29 160.57,148.29 161.46,149.18 161.46,149.42 162.39,150.35 162.89,150.35 166.06,153.51 171.85,153.51 172.36,153 v2(172.36,151.52)
  BOTTOM w0.089: v2(116.05,104.53) 116.19,104.67 116.19,104.83 116.11,104.91 115.9,104.91 115.79,104.8 112.92,104.8 112.89,104.83
  BOTTOM w0.102: v2(101.24,103.97) 101.43,103.79 101.43,103.55 101.64,103.33 102.52,103.33 102.94,103.75 105.35,103.75 106.11,104.52 v4(107.34,104.52) 110.85,104.52 111.17,104.83 112.89,104.83
SATA_PRX_DTX_P1: length 134.3
  TOP w0.089: UH1.E37 116.78,104.06 116.68,104.15 v2(116.68,104.62)
  TOP w0.102: v2(171.78,151.52) 171.96,151.7 171.96,151.87 172.24,152.15 172.45,152.15 172.57,152.27 172.57,152.39 C697.1
  IN4 w0.109: v2(171.78,151.52) 171.78,151.74 171.85,151.81 172.07,151.81 172.15,151.88 172.15,152.91 171.76,153.3 166.15,153.3 162.98,150.13 162.48,150.13 161.68,149.33 161.68,149.09 160.66,148.08 158.64,148.08 157.15,146.59 154.49,146.59 154.14,146.59 153.34,145.78 153.34,144.99 152.09,143.74 150.61,143.74 149.99,143.12 146.19,143.12 144.99,141.92 137.45,141.92 133.36,139.38 127.52,139.38 126.31,140.6 123.41,140.6 122.57,139.76 116.83,139.76 115.65,140.94 109.88,140.94 108.74,139.8 108.23,139.8 107.42,138.98 105.31,138.98 103.43,137.1 103.43,130.45 104.35,129.53 104.35,113.28 100.56,109.49 100.56,106.17 101.46,105.27 101.46,105 101.46,104.5 101.54,104.41 101.86,104.41 101.95,104.33 101.95,104.09 v2(101.83,103.97)
  BOTTOM w0.089: v2(116.68,104.62) 116.19,105.11 115.81,105.11 115.7,105 113.03,105 112.98,105.05 112.89,105.05
  BOTTOM w0.102: v2(101.83,103.97) 101.64,103.79 101.64,103.64 101.73,103.55 102.43,103.55 102.85,103.97 105.26,103.97 106.02,104.73 110.76,104.73 111.08,105.05 v4(111.43,105.05) 112.89,105.05
SATA_PTX_C_DRX_N1: length 3.3
  TOP w0.102: C700.1 173.66,156.78 173.66,157.6 v2(173.78,157.72)
  BOTTOM w0.102: JDOCK1.62 173.75,156.96 173.75,156.96 173.58,157.13 173.58,157.52 v2(173.78,157.72)
SATA_PTX_C_DRX_P1: length 3.3
  TOP w0.102: v2(173.2,157.72) 173.44,157.48 173.44,156.74 C699.1
  BOTTOM w0.102: v2(173.2,157.72) 173.36,157.55 173.36,157.09 173.25,156.98 JDOCK1.60
SATA_PTX_DRX_N1: length 143.2
  TOP w0.089: v2(116.16,103.28) 116.61,102.83 UH1.B38
  TOP w0.102: C700.2 174.02,154.22 174.22,154.01 174.22,152.72 174.13,152.63 174.13,152.53 173.07,151.47 173.07,150.81 172.67,150.41 170.63,150.41 v2(170.55,150.33)
  IN4 w0.109: v2(170.55,150.33) 170.37,150.52 169.93,150.52 168.09,152.36 166.15,152.36 163.2,149.41 163.2,149.28 161.17,147.25 159.02,147.25 157.73,145.96 154.4,145.96 153.97,145.52 153.97,142.72 153,141.75 148.51,141.75 148,142.26 146.37,142.26 144.53,140.42 144.53,139.83 143.9,139.2 140.27,135.57 136.36,135.57 133.54,138.39 127.03,138.39 125.76,137.12 122.8,137.12 120.96,138.96 113.29,138.96 112.17,140.08 109.96,140.08 108.97,139.09 108.44,139.09 107.45,138.09 107.45,136.98 106.46,135.99 106.46,129.18 106.18,128.9 106.18,120.29 107.17,119.3 107.17,118.08 107.45,117.8 107.45,115.89 105.92,114.37 105.92,112.29 104.96,111.32 103.46,111.32 102.49,110.36 102.49,108.53 102.58,108.45 102.58,102.62 102.19,102.23 101.92,102.23 v2(101.74,102.05)
  BOTTOM w0.089: 112.37,103.31 112.4,103.31 112.41,103.3 113.28,103.3 114.02,102.56 114.14,102.56 115.42,102.56 115.78,102.91 115.78,103.5 115.96,103.68 116.17,103.68 116.22,103.61 v2(116.16,103.28)
  BOTTOM w0.102: 112.37,103.31 111.32,103.31 111,103.63 v4(110.39,103.63) 106.3,103.63 105.29,102.61 105.02,102.61 104.59,102.61 104.27,102.29 101.98,102.29 v2(101.74,102.05)
SATA_PTX_DRX_P1: length 143.1
  TOP w0.089: v2(116.72,103.66) 116.61,103.56 UH1.C38
  TOP w0.102: C699.2 173.8,154.85 173.8,154.13 174.01,153.92 174.01,152.81 173.92,152.72 173.92,152.62 172.85,151.56 172.85,150.9 172.58,150.62 170.84,150.62 v2(170.55,150.92)
  IN4 w0.109: v2(170.55,150.92) 170.37,150.73 170.02,150.73 168.18,152.57 166.06,152.57 162.98,149.5 162.98,149.37 161.08,147.47 158.93,147.47 157.64,146.18 154.31,146.18 153.75,145.61 153.75,142.81 152.91,141.97 148.6,141.97 148.09,142.48 146.28,142.48 144.31,140.51 144.31,139.92 143.81,139.42 140.18,135.78 136.45,135.78 133.63,138.6 126.94,138.6 125.67,137.33 122.89,137.33 121.05,139.17 113.38,139.17 112.26,140.29 109.87,140.29 108.88,139.3 108.35,139.3 107.23,138.18 107.23,137.07 106.24,136.08 106.24,129.27 105.96,128.99 105.96,120.2 106.95,119.21 106.95,117.99 107.23,117.71 107.23,115.98 105.71,114.46 105.71,112.38 104.87,111.54 103.37,111.54 102.28,110.45 102.28,108.44 102.36,108.36 102.36,102.71 102.1,102.45 101.93,102.45 v2(101.74,102.64)
  BOTTOM w0.089: 112.37,103.53 112.39,103.53 112.39,103.52 112.46,103.52 112.46,103.51 112.49,103.51 112.5,103.5 113.36,103.5 114.1,102.76 115.34,102.76 115.57,103 115.57,103.58 115.87,103.88 116.28,103.88 116.39,103.72 v2(116.72,103.66)
  BOTTOM w0.102: 112.37,103.53 111.41,103.53 111.09,103.84 v4(108.74,103.84) 106.21,103.84 105.2,102.83 105.11,102.83 105.11,102.83 104.5,102.83 104.18,102.51 101.87,102.51 v2(101.74,102.64)
