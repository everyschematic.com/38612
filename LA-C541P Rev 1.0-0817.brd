# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 116.25,117 115.36,117 115.09,117.27 115.09,118.77 115.27,118.94 116.9,118.94 117.56,118.28 117.56,117.29 117.15,116.89 116.36,116.89
GND on TOP: 107.99,78.13 108.12,78 108.12,75.97 107.55,75.39 107.55,73.93 107.42,73.81 106.21,73.81 106.15,73.87 106.15,75.33 106.21,75.39 106.4,75.39 106.79,75.78 106.79,76.66 106.53,76.92 106.47,76.92 106.34,77.05 106.34,78 106.47,78.13
GND on TOP: 67.48,48.15 71.35,48.15 71.92,47.58 71.92,45.11 71.73,44.91 70.4,44.91 70.15,44.66 70.15,43.84 69.89,43.58 69.13,43.58 68.94,43.77 68.94,44.15 68.75,44.34 66.72,44.34 66.46,44.6 66.46,45.04 66.72,45.3 68.75,45.3 69,45.55 69,46.06 68.75,46.31 67.29,46.31 67.23,46.38 67.23,47.9
GND on TOP: 102.54,127.73 103.03,127.25 103.03,126.36 102.65,125.98 97.49,125.98 97.31,126.16 97.31,127.35 97.69,127.73
GND on TOP: 312.21,52.47 314.75,52.47 317.61,49.61 317.61,49.6 318.4,48.81 318.4,47.58 317.77,46.95 317.16,46.95 316.78,46.57 314.56,46.57 314.43,46.69 314.43,48.45 314.18,48.7 313.79,48.7 313.18,48.09 309.99,48.09 309.6,48.47 309.6,49.87
GND on TOP: 52.3,19.39 56.62,19.39 57.19,19.96 58.65,19.96 60.3,21.61 60.3,22.37 60.11,22.56 59.73,22.56 59.61,22.44 59.61,22.25 59.41,22.05 57.95,22.05 57.57,21.67 52.3,21.67 51.79,21.17 51.79,19.9
GND on BOTTOM: 206.01,99.07 204.32,99.07 204.2,98.95 204.2,98.19 204.77,97.62 205.73,97.62 206.19,98.08 206.19,98.89
GND on BOTTOM: 196.94,87.1 202.09,87.1 202.32,86.87 202.32,85.48 201.73,84.89 197.19,84.89 196.59,85.5 196.59,86.75
GND on BOTTOM: 33.68,54.95 33.68,54.94 33.68,52.25 33.91,52.01 38.84,52.01 39.01,52.19 39.01,61.28 39.89,62.16 45.04,62.16 45.68,61.52 45.68,52.13 45.7,52.12 46.66,52.12 47.05,52.5 47.05,62.42 45.25,64.22 34.51,64.22 33.68,63.39
GND on BOTTOM: 117.94,15.11 118.2,14.85 125.33,14.85 125.5,15.02 125.5,41.81 125.39,41.92 118.33,41.92 117.91,41.5 117.91,15.34 117.94,15.31
GND on BOTTOM: 182.16,39.26 185.46,39.26 185.53,39.2 185.53,37.8 185.4,37.68 182.1,37.68 182.03,37.74 182.03,39.14
GND on BOTTOM: 21.9,3.27 28.34,3.27 29.63,4.57 29.63,6.54 29,7.17 22.25,7.17 21.65,6.56 21.65,3.53
GND on BOTTOM: 164.95,125.13 164.95,123.97 165.21,123.72 166.68,123.72 167.38,123.02 168.47,123.02 168.79,123.34 168.79,125.6 168.56,125.83 166.16,125.83 166.02,125.69 166.02,125.45 165.79,125.22 165.05,125.22
GND on BOTTOM: 104.94,80.47 100.5,80.47 100.25,80.73 100.25,84.35 101.07,85.17 101.52,85.17 102.47,84.22 104.94,84.22 105.13,84.03 105.13,80.67
GND on BOTTOM: 192.37,117.08 192.37,119.87 192.44,119.94 193.64,119.94 193.83,119.75 193.83,117.33 193.58,117.08
GND on BOTTOM: 116.25,144.61 115.29,144.61 114.98,144.93 114.98,146.01 114.99,146.02 114.99,146.43 115.4,146.83 116.18,146.83 116.44,146.58 116.44,146.32 116.88,145.88 118.34,145.88 118.98,145.24 118.98,144.29 118.79,144.1 117.42,144.1 117.23,144.29 117.23,144.83 117.07,144.99 116.63,144.99
GND on BOTTOM: 194.55,74.36 194.8,74.36 195.05,74.11 195.05,72.87 194.83,72.65 194.83,71.01 194.58,70.76 193.55,70.76 193.1,71.22 191.68,72.63 191.68,74.33 191.88,74.53 194.38,74.53
GND on BOTTOM: 33.25,44.53 33.7,44.09 33.7,42.28 33.16,41.74 29.72,41.74 29.64,41.82 29.64,44.52 29.94,44.81 31.31,44.81 31.59,44.53
GND on BOTTOM: 349.24,32.6 349.24,30.75 349.43,30.56 349.94,30.56 350.13,30.37 351.34,30.37 351.47,30.5 351.47,31.39 351.64,31.57 352.68,31.57 352.81,31.69 352.81,32.43 352.66,32.58 351.39,32.58 351.18,32.79 349.43,32.79
GND on BOTTOM: 102.71,22.55 102.71,36.9 105.39,39.58 107.05,39.58 107.92,40.45 107.92,41.32 108.14,41.54 109.22,41.54 109.57,41.89 109.88,41.89 109.9,41.87 111.39,41.87 111.49,41.77 111.49,15.02 111.32,14.85 108.85,14.85 108.54,15.16 108.54,16.1 107.65,16.99 107.65,17.61
GND on BOTTOM: 208.23,135.5 207.94,135.79 207.6,135.79 207.36,136.02 207.36,140.86 207.41,140.91 209.41,140.91 209.83,140.49 209.83,139.16 210.1,138.89 210.42,138.89 211.72,137.59 211.72,136.32 210.9,135.5
GND on BOTTOM: 194.03,127.15 194.61,127.15 195.05,127.59 195.88,127.59 196.32,128.04 196.32,128.35 196.51,128.54 197.27,128.54 197.4,128.42 197.4,127.66 197.15,127.4 196.7,127.4 196.19,126.89 194.03,126.89 193.97,126.96 193.97,127.08
GND on BOTTOM: 49.52,43.11 49.52,42.6 49.39,42.48 49.39,41.61 49.2,41.42 46,41.42 45.85,41.57 45.85,42.17 46.98,43.3 49.33,43.3
GND on BOTTOM: 51.46,25.45 52.12,26.11 55.01,26.11 55.36,25.77 55.36,23.04 55.24,22.93 51.7,22.93 51.46,23.17
GND on BOTTOM: 106.48,58.62 107.27,59.41 108.18,59.41 109.17,58.41 111.36,58.41 111.48,58.54 111.48,78.81 111.41,78.89 109.81,78.89 106.38,75.46 104.68,75.46 104.14,74.92 104.14,67.25 103.46,66.57 103.46,59.66 104.5,58.62
GND on BOTTOM: 188.9,123.74 188.9,122.97 189.13,122.74 191.58,122.74 191.66,122.82 191.66,123.77 191.65,123.78 191.65,123.98 191.49,124.14 189.3,124.14
GND on BOTTOM: 97.96,127.91 102.49,127.91 102.72,127.68 102.72,125.12 102.54,124.94 100.23,124.94 99.22,125.95 97.95,125.95 97.4,126.5 97.4,127.35
GND on BOTTOM: 269.75,36.67 270.69,36.67 270.98,36.39 270.98,35.28 270.91,35.21 269.74,35.21 269.56,35.39 269.56,36.48
GND on BOTTOM: 214.41,80.59 217.41,80.59 217.73,80.92 217.73,82.2 216.67,83.26 215.71,83.26 214.17,81.73 214.17,80.83
GND on BOTTOM: 117.91,58.41 118.05,58.27 125.32,58.27 125.48,58.44 125.48,58.44 125.48,79.85 125.15,80.19 118.07,80.19 117.91,80.03
GND on BOTTOM: 24.27,31.31 28.01,31.31 28.68,30.64 28.68,28.02 28.11,27.45 25.19,27.45 24.13,28.51 24.13,31.17
GND on BOTTOM, IN1, IN2, IN4: 244.45,1.62 244.45,3.74 244.91,4.2 268.09,4.2 268.52,3.77 268.52,1.82 267.97,1.27 244.8,1.27
GND on GND1: outline of 156 points within 0.25,0.26 355.75,159.64
GND on GND1: 257.04,140.93 257.04,141.09 254.2,141.09 252.14,143.15 250.99,143.15 248.07,146.07 247.31,146.07 243.67,149.71 243.73,149.85 243.75,150 243.75,150.65 243.77,150.68 243.8,150.69 245.11,150.69 245.68,150.46 246.05,150.95 246.05,157.9 246.27,158.43 246.8,158.64 248,158.64 248.53,158.43 248.74,157.9 248.74,152.7 249.11,151.81 250,151.44 256.8,151.44 257.33,151.23 257.54,150.7 257.54,140.93
GND on IN1: 123.09,15.87 121.77,15.87 119.71,17.93 119.71,32.57 119.84,32.7 122.7,32.7 123.09,32.3 123.09,30.68 122.81,30.4 122.81,21.86 122.61,21.66 122.61,20.34 123.09,19.86
GND on IN1: 117.89,79.93 122.92,79.93 122.99,79.86 122.99,78.17 123.22,77.95 123.22,64.66 122.03,63.47 118.04,63.47 117.71,63.8 117.71,79.75
GND on VCC: 223.23,8.97 223.23,41.49 228.54,41.49 229.2,42.14 229.2,65.87 239.33,65.87 240.45,64.75 240.45,13.21 236.22,8.97
GND on VCC: 164.23,9.55 162.64,11.13 160.36,11.13 149.67,11.13 148.78,12.02 128.08,12.02 125.44,14.67 125.41,14.69 125.4,14.73 125.34,14.77 125.29,14.82 125.25,14.82 125.22,14.83 125.15,14.82 107.04,14.82 107.04,20.85 106.79,20.85 106.79,79.8 112.35,85.36 149.8,85.36 155.77,79.4 165.52,79.4 165.52,70.91 170.6,65.83 170.6,64.68 176.53,58.76 178.41,58.76 178.41,58.02 179.05,57.38 179.05,47.48 179.06,47.47 179.06,29.98 179.75,29.29 180.45,29.29 180.45,27.07 180.43,26.12 180.43,13.27 178.12,10.94 172.72,10.94 171.32,9.55
GND on VCC: 254.2,141.09 252.14,143.15 252.14,143.15 250.99,143.15 248.07,146.07 246.59,146.07 244.01,148.65 244.48,149.09 244.73,149.67 246.28,149.62 247.07,150.95 247.07,157.63 247.73,157.63 247.73,152.7 248.39,151.09 250,150.43 256.53,150.43 256.53,141.09
GND on VCC: 244.47,1.27 244.06,2.47 243.04,3.24 243.04,6.18 247,6.18 247.43,5.75 247.5,5.67 247.51,5.67 247.61,5.67 247.73,5.67 247.73,5.67 270.37,5.67 271.11,4.93 271.11,3.37 270.6,3.37 269.09,2.76 268.43,1.27
GND on IN2: 136.88,62.83 136.88,73.71 136.2,74.39 120.78,74.39 116.82,70.43 108.6,70.43 107.74,69.57 107.74,67.97 108.06,67.65 108.06,60.12 120.93,60.12 122.61,61.79 135.84,61.79
GND on IN2: 136.73,40.37 137.9,39.2 137.9,18.33 137.06,17.5 126.17,17.5 123.99,15.32 116.07,15.32 115.27,16.12 112.5,16.12 111.94,16.68 106.76,16.68 104.88,18.56 104.88,38.3 105.34,38.76 106.4,38.76 106.61,38.55 109.35,38.55 109.58,38.78 109.58,40.08 111.38,41.88 113.47,41.88 114.15,41.19 119.23,41.19 119.97,41.93 123.4,41.93 124.95,40.37
GND on GND2: outline of 158 points within 0.25,0.26 355.75,159.64
GND on GND2: 257.04,140.93 257.04,141.09 254.2,141.09 252.14,143.15 252.14,143.15 250.99,143.15 248.07,146.07 247.31,146.07 243.67,149.71 243.73,149.85 243.75,150 243.75,150.65 243.77,150.68 243.8,150.69 245.11,150.69 245.68,150.46 246.05,150.95 246.05,157.9 246.27,158.43 246.8,158.64 248,158.64 248.53,158.43 248.74,157.9 248.74,152.7 249.11,151.81 250,151.44 256.8,151.44 257.33,151.23 257.54,150.7 257.54,140.93
GND on GND3: 257.04,140.96 257.04,141.09 254.26,141.09 252.2,143.15 250.99,143.15 248.07,146.07 247.31,146.07 243.67,149.71 243.73,149.85 243.75,150 243.75,150.65 243.77,150.68 243.8,150.69 245.11,150.69 245.68,150.46 246.05,150.95 246.05,157.9 246.27,158.43 246.8,158.64 248,158.64 248.53,158.43 248.74,157.9 248.74,152.7 249.11,151.81 250,151.44 256.8,151.44 257.33,151.23 257.54,150.7 257.54,140.96
GND on GND3: outline of 158 points within 0.25,0.26 355.75,159.64
GNDA_CHG on TOP (solid shape): 274.43,33.93 274.43,33.57 274.16,33.3 274.16,32.77 274.43,32.5 274.43,31.39 274.36,31.33 271.82,31.33 271.76,31.39 271.76,33.93 271.82,33.99 274.36,33.99
GNDA_CHG on BOTTOM: 271.09,35.18 271.56,35.18 271.74,35 271.74,34.15 271.61,34.01 269.83,34.01 269.52,34.32 269.52,34.93 269.69,35.1 269.94,35.1 269.96,35.12 270.17,35.12 270.18,35.1 270.18,34.59 270.23,34.54 270.6,34.54 270.62,34.57 270.62,35.07 270.67,35.11 271,35.11 271,35.1 271.05,35.1 271.05,35.14
GNDA_CHG on IN2: 271.56,28.11 268.48,31.19 268.48,33.97 267.78,34.67 267.55,34.9 267.55,35 267.52,35.09 267.52,35.12 268.22,35.2 267.52,35.28 267.52,36.71 267.83,37.03 269.17,37.03 270.37,38.22 270.37,38.84 271,39.47 271.69,39.47 274.64,36.52 274.64,30.94 275.78,29.8 276.65,29.8 276.97,29.48 276.97,29.04 276.04,28.11
VIN_EDRAMP on TOP (solid shape): 71.61,10.82 71.61,9.67 71.86,9.42 73.77,9.42 73.89,9.29 73.89,9.16 73.77,9.04 72.24,9.04 71.99,8.78 67.14,8.78 66.94,8.98 66.94,9.73 67.01,9.8 68.94,9.8 69.07,9.93 69.07,10.94 69.19,11.07 71.35,11.07
VIN_EOPIOP on TOP (solid shape): 53.38,10.24 54.02,10.24 55.1,9.16 56.75,9.16 56.81,9.1 56.81,8.97 56.75,8.91 54.91,8.91 54.46,8.47 54.46,8.19 54.4,8.13 53.81,8.13 53.76,8.18 53.76,8.91 53.45,9.23 51.18,9.23 50.98,9.02 50.98,8.43 50.82,8.27 49.95,8.27 49.83,8.39 49.83,10.24 49.95,10.37 53.26,10.37
81210_SW1 on TOP (solid shape): 256.14,25.86 256.14,24.4 257.28,23.26 257.28,20.59 257.15,20.47 256.2,20.47 256.2,22.63 255.31,22.63 255.31,20.47 254.17,20.47 253.79,20.85 253.79,23.01 253.41,23.39 251.82,23.39 251.63,23.58 251.63,24.15 251.76,24.28 253.79,24.28 254.99,25.48 254.99,25.74 255.19,25.93 256.07,25.93
+BL_PWR_SRC on TOP: 127.68,142.45 126.03,142.7 125.9,142.58 125.65,141.12 126.47,140.29 126.47,137.94 125.07,136.55 117.2,136.55 116.95,136.8 115.8,136.8 115.55,136.55 111.61,136.55 110.91,137.24 110.91,138.58 110.73,138.76 110.73,139.28 110.48,139.53 108.63,139.53 108.12,139.02 108.12,137.12 111.04,134.2 114.95,134.2 115.6,133.55 118.23,133.55 118.88,134.2 122.79,134.2 123.78,133.2 126.11,133.2 128.63,135.72 128.63,141.5
+BL_PWR_SRC on BOTTOM: 110.41,140.55 108.5,140.55 108.12,140.16 108.12,139.4 107.87,139.15 107.48,139.15 107.47,139.14 106.72,139.14 106.62,139.04 106.62,138.5 107.1,138.02 107.1,137.43 107.29,137.24 110.72,137.24 110.91,137.43 110.91,138.64 110.47,139.09 110.47,140.48
+CHAGER_SRC on TOP (solid shape): 290.05,28.21 290.05,26.69 290.08,26.66 290.08,25.01 291.19,23.9 292.84,23.9 294.11,22.63 294.11,21.38 296.92,18.57 296.92,17.56 297.64,16.83 297.64,14.75 297.51,14.63 293.92,14.63 293.73,14.82 293.73,16.47 292.71,17.48 290.87,17.48 290.62,17.74 290.62,21.99 290.36,22.25 290.36,22.88 289.95,23.29 288.56,23.29 287.95,23.9 285.6,23.9 285.35,24.15 285.35,28.09 285.67,28.4 289.86,28.4
+CPU_B+ on TOP (solid shape): outline of 130 points within 234.98,7.84 256.57,61.81
+CPU_B+ on BOTTOM: outline of 90 points within 234.26,10.88 247.97,79.5
+CPU_B+ on IN1: 236.83,32.02 248.77,32.02 249.66,31.14 252.84,31.14 253.85,30.12 253.85,21.61 252.33,20.09 244.33,20.09 242.42,18.18 242.42,11.07 242.04,10.69 236.71,10.69 236.2,11.2 236.2,31.39
+DC1_PWR_SRC on TOP (solid shape): 348.09,38.56 348.09,36.15 347.78,35.85 347.78,35.19 347.72,35.14 342.35,35.14 339.7,32.48 339.7,17.6 339.54,17.44 336.82,17.44 335.89,18.37 335.89,25.29 336.29,25.69 336.29,26.28 335.89,26.68 335.89,28.9 336.54,29.1 335.89,29.31 335.89,34.52 337.21,35.83 337.54,36.17 340.2,38.82 347.83,38.82
+DC_IN on BOTTOM: 38.14,51.21 37.82,50.9 37.82,48.03 38.08,47.77 40.01,47.77 40.24,47.54 40.24,45.69 40.33,45.59 42.87,45.59 43.9,44.57 43.92,44.57 44.28,44.22 44.28,44.04 44.48,43.84 46.41,43.84 46.65,43.59 50.66,43.59 50.83,43.76 50.83,44.77 50.72,44.88 46.82,44.88 46.27,45.44 44.24,45.44 43.98,45.69 43.98,50.9 43.67,51.21
+DC_IN_SS on BOTTOM (solid shape): 37.44,51.15 37.44,45.16 37.95,44.65 41.99,44.65 42.27,44.37 42.27,40.85 42.14,40.72 42.14,39.82 41.94,39.62 38.13,39.62 37.89,39.86 37.89,41.8 36.81,42.88 34.78,42.88 34.33,43.33 34.33,43.96 33.32,44.98 30.74,44.98 30.55,45.17 30.55,45.95 32.11,47.52 32.11,50.92 32.54,51.35 37.24,51.35
+DCIN on TOP (solid shape): 275.52,34.7 275.52,34.7 275.83,34.39 275.83,34.08 275.52,33.76 274.73,33.76 274.66,33.84 274.66,34.92 274.8,35.07 275.15,35.07
+DCIN_JACK on BOTTOM (solid shape): 45.05,61.53 45.05,52.41 45.55,51.91 48.11,51.91 48.75,51.28 48.75,49.49 48.94,49.3 50.17,49.3 50.79,48.68 50.79,46.48 50.54,46.23 48.1,46.23 47.95,46.08 47.93,46.08 47.33,45.48 44.56,45.48 44.37,45.67 44.37,51.09 44.02,51.44 43.05,51.44 40.63,51.44 39.71,52.36 39.71,61.42 39.98,61.69 44.89,61.69
+DCIN_JACK on IN2: 44.81,47.65 48.34,47.65 48.57,47.87 48.57,59.46 46.18,61.84 40.7,61.84 40.06,61.21 40.06,55.52 43.57,52.01 43.57,48.89
+DOCK_PWR_BAR on TOP: 156.06,150.13 156.7,150.13 157.46,150.9 157.46,153.94 158.73,155.21 158.73,158.01 158.22,158.52 148.19,158.52 147.81,158.14 147.81,157.12 146.66,155.98 146.66,153.69 147.3,153.06 148.19,153.06 150.98,150.26 152.12,150.26 152.25,150.39 155.3,150.39 155.43,150.26 155.93,150.26
+DOCK_PWR_BAR on TOP: 197.35,154.33 197.42,154.25 197.42,149.05 198.89,147.59 206.82,147.59 209.53,144.89 209.53,142.82 208.97,142.27 207.65,142.27 205.53,144.39 196.48,144.39 193.15,147.72 193.15,150.39 192.3,151.23 192.3,154.07 192.56,154.33
+DOCK_PWR_BAR on BOTTOM: 210.1,144.29 210.67,143.72 210.67,143.4 210.48,143.21 210.48,142.77 210.16,142.45 207.62,142.45 207.24,142.83 207.24,143.91 206.93,144.23 205.53,144.23 205.27,144.48 205.27,145.5 204.96,145.82 197.08,145.82 196.07,146.83 196.07,148.99 193.27,151.79 193.27,154.2 193.53,154.45 195.18,154.45 195.56,154.83 195.56,155.72 196.83,156.99 204.96,156.99 209.05,152.9 209.05,150.74 210.1,149.69
+DOCK_PWR_BAR on BOTTOM: 128.95,142.45 133.58,142.45 133.84,142.2 133.84,138.13 133.58,137.88 132.63,137.88 132.19,137.43 132.19,136.29 131.77,135.88 129.77,135.88 129.15,135.26 128.74,135.26 128.06,134.58 128.06,134.01 127.74,133.69 126.34,133.69 126.15,133.88 126.15,137.37 126.34,137.56 127.87,137.56 128.69,138.39 128.69,142.2
+DOCK_PWR_BAR on BOTTOM, IN2: 156.06,150.13 156.7,150.13 157.46,150.9 157.46,153.94 157.71,154.2 157.71,154.83 157.46,155.09 157.46,157.88 156.82,158.52 148.19,158.52 147.81,158.14 147.81,157.12 146.66,155.98 146.66,153.69 147.3,153.06 148.19,153.06 150.98,150.26 155.93,150.26
+DOCK_PWR_BAR on VCC: 126.96,129.18 126.72,129.41 126.72,143.36 128.26,144.9 136.58,144.81 140.77,152 140.77,155.93 145.5,155.93 147.1,156.59 147.77,158.2 147.77,158.63 203.3,158.63 203.29,150.94 202.04,149.69 195.62,149.69 195.6,149.72 195.45,149.76 191.58,153.63 169.4,153.63 168.39,152.61 160.64,152.61 158.1,150.07 155.43,150.07 154.14,148.78 154.14,146.37 137.71,129.94 128.02,129.94 127.25,129.18
+DOCK_PWR_BAR on IN3: 193.65,154.33 204.07,154.33 208.39,150.01 208.39,146.2 210.67,143.91 210.67,143.53 210.35,143.21 210.35,142.7 210.16,142.51 196.83,142.51 193.27,146.07 193.27,153.94
+LCDVDD on TOP: 118.98,142.07 118.15,142.07 117.73,141.64 117.73,140.39 118.71,139.4 122.91,139.4 123.8,140.29 124.18,140.29 124.86,140.97 125.14,142.45 125.14,142.65 125.08,142.72 124.06,142.9 123.93,142.83 123.87,142.51 123.7,141.62 123.53,141.45 122.17,141.45 121.93,141.21 119.84,141.21
+LCDVDD on BOTTOM: 117.28,147.92 119.06,147.92 119.15,147.83 119.15,146.3 119.05,146.2 117.26,146.2 116.74,146.71 116.74,147.39
+LCDVDD on BOTTOM: 118.46,141.39 118.62,141.22 118.62,140.24 118.66,140.2 119.24,140.2 119.28,140.24 119.28,140.74 119.3,140.76 119.52,140.76 119.54,140.74 119.54,140.22 119.55,140.21 120.06,140.21 120.08,140.23 120.08,140.73 120.09,140.74 120.3,140.74 120.33,140.72 120.33,140.23 120.35,140.2 120.79,140.2 120.82,140.17 120.82,139.76 120.27,139.21 120.27,138.04 120.19,137.96 117.74,137.96 117.52,138.18 117.52,141.13 117.77,141.39
+LCDVDD_R on BOTTOM (solid shape): 121.43,143.21 121.43,140.87 120.9,140.34 120.46,140.34 120.46,140.87 119.95,140.87 119.95,140.34 119.66,140.34 119.66,140.87 119.15,140.87 119.15,140.35 119.13,140.34 118.79,140.34 118.75,140.37 118.75,141.39 118.37,141.78 120.46,141.78 120.46,141.73 120.47,141.67 120.49,141.62 120.51,141.57 120.54,141.53 120.58,141.49 120.62,141.46 120.66,141.43 120.71,141.41 120.77,141.4 120.82,141.4 120.87,141.4 120.92,141.41 120.97,141.43 121.02,141.46 121.06,141.49 121.1,141.53 121.13,141.57 121.15,141.62 121.17,141.67 121.18,141.73 121.18,141.78 121.17,141.83 121.15,141.88 121.13,141.93 121.1,141.97 121.06,142.01 121.02,142.05 120.97,142.07 120.92,142.09 120.87,142.1 120.82,142.11 120.77,142.1 120.71,142.09 120.66,142.07 120.62,142.05 120.58,142.01 120.54,141.97 120.51,141.93 120.49,141.88 120.47,141.83 120.46,141.78 118.37,141.78 117.69,142.46 117.69,143.33 117.81,143.45 118.81,143.45 118.96,143.3 119.93,143.3 120.1,143.47 121.18,143.47
+MXM_PWR on TOP: 225.17,102.94 229.93,102.94 230.51,102.37 230.51,99.62 229.56,98.66 229.15,98.66 229.15,98.67 228.93,98.67 228.88,98.61 228.88,98.16 228.85,98.12 228.45,98.12 228.43,98.15 228.43,98.57 228.43,98.58 228.43,98.62 228.38,98.67 227.7,98.67 227.68,98.64 227.68,98.15 227.65,98.12 227.25,98.12 227.23,98.15 227.23,98.65 227.21,98.67 227.1,98.67 227.1,98.67 223.81,98.67 223.81,98.67 223.66,98.67 223.6,98.61 223.6,98.18 223.55,98.13 223.21,98.13 223.16,98.18 223.16,98.32 223.16,98.32 223.16,98.62 223.1,98.67 222.43,98.67 222.41,98.65 222.41,98.16 222.37,98.12 222,98.12 221.96,98.17 221.96,98.63 221.92,98.67 221.17,98.67 221.1,98.74 221.1,100.34 221.8,101.04 223.36,101.04 225.17,102.85
+MXM_PWR_SRC on TOP: 223.82,98.51 227.05,98.51 227.05,97.94 227.79,97.94 227.79,98.47 227.84,98.52 228.22,98.52 228.27,98.47 228.27,97.99 228.32,97.94 229.02,97.94 229.02,98.51 229.47,98.51 229.53,98.45 229.53,96.86 228.26,95.59 228.26,92.54 227.94,92.22 225.66,92.22 224.83,91.4 224.83,77.49 224.45,77.11 221.97,77.11 220.32,78.76 219.31,78.76 218.99,79.08 218.99,91.9 219.56,92.48 219.56,96.48 220.17,97.08 220.86,97.08 221.09,97.3 221.09,98.32 221.28,98.51 221.78,98.51 221.78,97.94 222.56,97.94 222.56,98.5 222.58,98.52 222.99,98.52 223.02,98.5 223.02,97.99 223.07,97.94 223.82,97.94
+MXM_SRC_EN# on TOP: 225.09,107.48 226.48,107.48 226.71,107.24 226.71,104.84 226.37,104.49 224.86,104.49 224.78,104.57 224.78,105.36 224.83,105.41 224.83,106.92 224.83,107.23
+PWR_SRC on TOP (solid shape): 50.78,12.09 50.78,10.94 50.65,10.82 49.25,10.82 49.19,10.88 49.19,12.02 49.48,12.31 50.56,12.31
+PWR_SRC on TOP (solid shape): 68.56,11.07 68.56,10.18 68.3,9.93 66.15,9.93 65.83,10.24 65.83,11.02 65.96,11.15 68.48,11.15
+PWR_SRC on TOP (solid shape): 59.52,26.5 59.52,22.5 59.33,22.31 57.7,22.31 57.51,22.12 55.22,22.12 55.03,22.31 55.03,25.93 55.16,26.06 56.81,26.06 57,26.25 57,26.56 57.38,26.94 59.08,26.94
+PWR_SRC on TOP (solid shape): 336.83,16.78 339.31,16.78 339.56,16.53 339.56,11.42 339.12,10.98 335.68,10.98 335.18,11.48 335.18,15.26 333.97,16.47 333.97,18.69 334.92,18.69
+PWR_SRC on TOP (solid shape): 292.9,17.04 292.9,14.94 293.48,14.37 297.59,14.37 298,13.96 298,10.41 297.91,10.33 297.37,10.33 297.35,10.31 294.3,10.31 292.52,12.09 289.54,12.09 289.09,12.53 289.09,13.29 288.33,14.05 284.97,14.05 284.78,14.24 284.78,15.77 285.16,16.15 285.16,16.91 285.23,16.98 286.68,16.98 286.68,16.97 286.68,16.28 287,15.96 288.14,15.96 289.41,17.23 292.71,17.23
+PWR_SRC on BOTTOM (solid shape): 108.82,136.93 108.82,135.96 108.59,135.73 108.59,134.56 107.73,133.7 107.73,133.07 107.65,133 107.29,133 107.2,133.09 107.2,134.07 107.16,134.11 107.16,136.77 107.42,137.03 108.72,137.03
+PWR_SRC on IN3 (solid shape): outline of 2918 points within 83.65,3.39 339.58,14.82
+PWR_SRC on TOP: 238.37,79.46 238.37,78.78 239.21,77.94 239.21,76.25 238.87,75.9 234.99,75.9 234.48,76.41 234.48,79.52 234.67,79.71 238.12,79.71
+PWR_SRC on TOP: 241.13,3.39 241.83,4.08 241.83,6.69 241.45,7.07 230.55,7.07 229.72,6.24 229.72,3.7 230.04,3.39
+PWR_SRC on TOP: 101.55,115.19 101.57,115.21 101.78,115.21 101.82,115.18 101.82,114.71 101.82,114.7 101.82,114.66 101.83,114.65 102.33,114.65 102.36,114.68 102.36,115.19 102.37,115.21 102.6,115.21 102.62,115.19 102.62,114.69 102.64,114.68 103.2,114.68 103.31,114.57 103.31,113.05 102.94,112.68 101.64,112.68 101.02,113.3 101.02,114.6 101.08,114.66 101.52,114.66 101.55,114.69
+PWR_SRC on TOP: 53.88,68.85 53.88,65.82 53.87,65.81 53.87,65.3 53.68,65.11 50.89,65.11 46.05,60.27 46.05,53.06 46.06,53.04 46.06,42.96 47.67,41.36 50.14,41.36 50.4,41.1 50.4,37.93 50.02,37.55 46.02,37.55 44.75,38.82 43.08,38.82 39.22,38.82 33.44,44.6 33.44,64.35 36.05,66.95 47.54,66.95 50.52,69.93 52.79,69.93
+PWR_SRC on BOTTOM: 61.84,44 61.78,44.06 53.75,44.06 52.86,44.95 52.86,53.33 52.52,53.68 49.72,53.68 49.08,54.33 49.08,68.95 50.25,70.12 52.94,70.12 52.94,70.14 54.43,70.2 55.92,70.33 56.49,70.14 56.73,69.6 56.73,69.4 61,65.13 65.27,69.4 65.27,71.64 66.1,72.86 82.88,86.39 89.37,106.95 93.96,106.95 95.1,105.81 95.1,96.29 92.94,94.13 92.94,80.41 77.11,64.57 75.46,64.57 75.16,64.28 75.16,62.63 72.05,59.52 72.02,59.55 68.57,56.1 68.57,45.63 66.95,44
+PWR_SRC on BOTTOM: outline of 112 points within 48.86,3.39 339.58,84.03 ; 1 cut-out
+PWR_SRC on BOTTOM: 128.25,141.31 124.5,141.31 122.47,139.28 122.47,137.43 122.09,137.05 120.63,137.05 120.44,136.86 120.44,134.01 120.57,133.88 125.52,133.88 125.77,134.13 125.77,137.43 126.15,137.82 127.74,137.82 128.44,138.51 128.44,141.12
+PWR_SRC on BOTTOM: 46.14,35.75 50.19,31.71 55.46,31.71 55.65,31.52 55.65,23.58 56.1,23.13 58.83,23.13 59.21,23.52 59.21,28.15 58.51,28.85 58.51,32.53 54.85,36.19 52.53,36.19 51.5,37.22 51.5,40.57 50.78,41.3 46.69,41.3 46.46,41.07 46.46,40.63 46.64,40.46 48.06,40.46 48.19,40.33 48.19,40 48.01,39.82 46.56,39.82 46.46,39.72 46.46,38.87 46.14,38.55
+PWR_SRC on IN1: 335.09,13.24 338.98,13.24 339.26,12.96 339.26,11.38 338.8,10.92 334.79,10.92 334.35,11.36 334.35,12.5
+PWR_SRC on IN1: 339.61,54.38 338.05,54.38 335.19,51.53 333.33,51.53 332.43,50.62 332.43,49.4 332.81,49.02 334.31,49.02 335.92,50.62 337.03,50.62 339.52,53.12 339.9,53.12 339.9,54.09
+PWR_SRC on VCC: 89.26,104.6 89.36,106.75 89.34,108.9 89.36,109.65 89.37,110.4 89.37,123.55 89.43,123.83 89.58,124.07 96.7,131.19 97.2,131.92 97.37,132.79 97.37,140.74 97.43,141.02 97.58,141.26 101.45,145.13 102,145.13 103.6,145.79 104.27,147.4 104.42,147.61 105.37,147.4 105.77,147.99 105.77,157.9 105.98,158.42 106.5,158.63 117.23,158.63 117.23,158.2 117.89,156.59 119.5,155.93 124.23,155.93 124.23,152 125.18,148.14 127.82,145.18 126.22,143.57 126.22,130.05 125.86,129.69 119.08,129.69 118.58,130.2 110.21,130.2 106.79,126.77 106.79,113.6 97.79,104.6 ; 1 cut-out
+PWR_SRC on VCC: outline of 87 points within 43.65,3.36 339.77,16.91
+PWR_SRC on IN2: 48.35,13.67 48.35,19.32 53.3,24.28 53.3,29.48 50.21,32.58 49.32,32.58 44.17,37.72 44.17,39.71 45.17,40.71 47.4,40.71 48.11,41.42 49.92,41.42 50.34,41 50.34,35.32 53.59,32.07 57.05,32.07 58.51,30.6 58.51,28.85 59.21,28.15 59.21,21.8 58.83,21.43 57.96,21.43 56.53,20 54.55,20 53.71,19.16 53.71,17.99 54.25,17.44 54.25,13.61 53.62,12.97 49.05,12.97
+PWR_SRC on IN3: 54.91,27.26 58.72,27.26 59.16,26.82 59.16,18.69 55.16,14.69 53.89,14.69 52.18,12.97 49.13,12.97 48.56,13.55 48.56,20.91
+PWR_SRC on IN3: 240.29,76.88 240.29,79.14 241.3,80.16 247.69,80.16 249.15,78.7 252.65,78.7 253.34,79.4 253.34,82.51 253.15,82.7 253.15,85.33 251.47,87.01 241.2,87.01 241.16,86.97 238.81,86.97 236.22,84.38 236.22,82.03 234.87,80.68 234.87,77.17 236.14,75.9 239.31,75.9
+PWR_SRC_MXM on BOTTOM (solid shape): 229.37,90.85 229.37,90.01 227.68,88.33 226.92,88.33 226.43,87.84 225.75,87.84 225.66,87.93 225.66,90.91 225.78,91.03 229.19,91.03
+PWR_SRC_MXM on TOP: 227.45,107.39 230.38,107.39 230.74,107.04 230.74,104.11 229.94,103.32 225.01,103.32 224.76,103.56 224.76,103.99 224.85,104.08 225.15,104.08 225.16,104.07 226.53,104.07 227.34,104.88 227.34,107.29
+PWR_SRC_MXM on TOP: 228.32,87.9 225.97,87.9 225.46,88.4 225.46,90.66 225.48,90.68 225.48,90.84 225.78,91.14 228.05,91.14 228.32,90.86 230.67,90.86 231.39,90.14 231.39,89.49 232.2,88.68 232.2,87.59 232.67,87.11 235.28,87.11 235.69,86.7 235.69,83.71 235.94,83.46 236.77,83.46 236.9,83.33 236.9,80.98 236.29,80.38 235.02,80.38 233.91,79.27 233.91,77.87 233.72,77.68 230.55,77.68 229.56,78.67 229.56,86.66
+PWR_SRC_MXM on VCC: 225.83,87.78 225.21,88.39 225.21,95.86 226.29,96.94 226.29,104.56 227.22,105.49 235.84,105.49 238.68,102.66 238.68,97.56 238.61,88.79 237.05,88.79 236.03,87.78
+PWR_SRC_MXM on IN2: 222.57,87.18 219.16,90.59 219.16,99.17 220.71,100.72 220.71,100.73 221.78,101.81 222.09,101.81 222.16,101.89 222.33,102.2 222.15,102.5 222.1,102.58 222.13,102.67 222.22,102.79 222.26,102.94 222.29,103.02 222.37,103.05 222.67,103.15 222.77,103.45 222.77,103.75 223.95,104.92 226.32,104.92 226.41,104.95 226.48,104.89 226.99,104.74 227.09,105.26 227.08,105.36 227.17,105.42 229.34,105.42 229.59,105.18 229.59,103.77 224.96,99.14 224.96,97.48 224.79,97.18 224.96,96.87 224.96,96.54 224.96,96.54 224.96,93.2 227.47,90.69 227.47,88.67 225.98,87.18
+RSVD_VCC3P3_2 on TOP: 255.67,113.73 256.17,113.73 256.27,113.63 256.27,113.08 255.96,112.77 254.78,112.77 254.41,112.4 253.3,112.4 253.22,112.48 253.22,113.39 253.47,113.64 255.58,113.64
+SDC_IN on TOP (solid shape): 276.39,38.99 276.39,37.67 276.37,37.65 275.32,37.65 275.11,37.86 275.11,39.26 275.19,39.34 276.05,39.34
+SDC_IN on TOP: 36.58,38.31 36.3,38.31 36.11,38.12 36.11,36.08 36.77,35.41 41.81,35.41 43.31,33.92 46.93,33.92 47.07,34.06 47.07,35.78 46.82,36.04 45.65,36.04 45.35,36.34 45.35,37.01 44.05,38.31
+SDC_IN on BOTTOM: 45.51,41.24 45.51,40.62 45.42,40.53 44,40.53 43.82,40.36 43.82,39.95 44,39.77 45.47,39.77 45.52,39.72 45.52,39.34 44.45,38.27 44.45,37.66 43.97,37.18 42.93,37.18 41.39,35.64 39.98,35.64 39.86,35.52 35.16,35.52 34.4,36.28 34.4,41.3 34.71,41.61 36.62,41.61 37,41.23 37,38.25 37.32,37.93 37.37,37.93 37.53,37.76 37.6,37.76 37.65,37.71 37.65,37.23 37.75,37.13 38.66,37.13 39.03,37.5 39.03,38.73 39.46,39.16 41.97,39.16 42.49,39.69 42.49,40.82 43.01,41.34 45.41,41.34
+SDC_IN on IN2: 37.06,38.31 37.02,38.27 36.17,38.27 35.89,37.99 35.89,37 42.46,30.44 43.35,30.44 43.73,30.06 44.24,30.06 45.32,31.14 45.32,35.64 42.65,38.31
+SDC_IN_J on TOP: 48.35,26.18 48.86,26.18 49,26.03 49,22.25 49.64,21.61 51.45,21.61 51.94,22.1 52.98,22.1 53.13,22.25 53.13,28.47 53.06,28.53 50.6,28.53 49.41,29.72 49.41,30.6 49.32,30.69 48.67,30.69 48.55,30.82 48.55,32.23 47.41,33.36 47.41,33.36 46.98,33.79 43.86,33.79 43.69,33.62 43.69,32.25 44.43,31.52 44.43,30.73 44.71,30.45 45.29,30.45 45.81,29.93 45.81,28.35 46.46,27.71 46.82,27.71
+SDC_IN_J on IN2: 46.33,32.47 49.38,32.47 52.75,29.1 52.75,24.02 51.92,23.2 48.3,23.2 47.79,23.71 47.79,24.91 46.08,26.63 46.08,32.21
+VCHGR on TOP (solid shape): 271.74,20.34 271.74,18.75 270.15,18.75 269.96,18.56 269.96,18.18 270.15,17.99 271.74,17.99 271.74,17.42 271.61,17.29 270.66,17.29 268.38,15.01 268.38,12.28 268.06,11.96 266.22,11.96 265.58,12.59 265.58,17.74 266.53,18.69 266.53,20.15 266.95,20.56 271.52,20.56
+VR_CAP on TOP: 203.81,110.47 203.96,110.32 203.96,110.12 203.3,109.46 202.34,109.46 202.24,109.55 202.24,110.41 202.3,110.47
BL_PWR_SRC_ON on BOTTOM (solid shape): 110.78,136.84 110.78,135.84 111.05,135.57 111.87,135.57 111.99,135.44 111.99,135.13 111.92,135.06 111.55,135.06 110.94,134.45 110.94,134.19 110.85,134.1 109.86,134.1 109.49,133.73 109.49,133.08 109.41,133.01 108.17,133.01 108.1,133.08 108.1,133.65 108.85,134.39 108.85,135.66 109.05,135.86 109.05,136.24 109.07,136.26 109.07,136.86 109.27,137.06 110.56,137.06
BOOT_1.2V on BOTTOM (solid shape): 63.14,17.8 63.14,16.97 63.09,16.92 62.49,16.92 62.1,17.32 60.94,17.32 60.88,17.38 60.88,17.46 60.94,17.52 61.97,17.52 62.37,17.92 63.02,17.92
BQ24780_REGN on TOP: 277.78,31.82 278.05,32.09 278.68,32.09 278.93,31.83 278.93,30.88 278.81,30.75 276.9,30.75 276.55,31.1 276.55,31.23 275.69,32.09 275.64,32.09 275.62,32.11 274.74,32.11 274.66,32.2 274.66,32.32 274.71,32.37 275.72,32.37 276.27,31.82
BST_3V on TOP (solid shape): 351.19,30.09 351.19,29.17 352.02,28.34 352.51,28.34 352.61,28.24 352.61,27.66 352.58,27.63 351.29,27.63 351.27,27.64 350.89,27.64 350.78,27.76 350.78,27.96 350.98,28.16 350.98,30.1 351.04,30.16 351.12,30.16
BST_3V_C on TOP (solid shape): 351.62,27.01 353.59,27.01 353.76,26.83 353.76,26.23 353.66,26.12 350.86,26.12 350.74,26.25 350.74,27.01 350.86,27.13 351.5,27.13
BST_5V on TOP (solid shape): 353.04,34.59 353.04,34.02 352.87,33.85 351.98,33.85 351.76,33.64 351.6,33.64 351.19,33.22 351.19,32.2 351.12,32.14 351.04,32.14 350.98,32.2 350.98,34.51 351.13,34.67 352.96,34.67
BST_5V_C on TOP (solid shape): 351.79,35.86 352.2,35.86 352.21,35.85 352.72,35.85 352.84,35.73 352.84,35.38 352.7,35.24 352.04,35.24 352,35.2 349.86,35.2 349.74,35.33 349.74,35.73 349.88,35.87 351.78,35.87
BST_+1VSP on TOP: 101.73,125.78 103.38,125.78 103.89,126.28 104.2,126.28 104.27,126.21 104.27,124.76 104.2,124.68 103.15,124.68 102.93,124.91 101.81,124.91 101.71,125.01 101.71,125.75
BST_+V0.95SP on TOP (solid shape): 326.99,21.42 326.99,20.28 326.86,20.15 326.03,20.15 325.84,20.34 325.84,21.42 325.97,21.55 326.86,21.55
BST_+V0.95SP on TOP (solid shape): 331.69,19.64 331.69,18.82 331.56,18.69 330.87,18.69 330.77,18.79 330.77,19.3 331.3,19.83 331.5,19.83
BST_+V0.95SP on IN4 (solid shape): 327.13,20.39 327.13,18.99 327,18.87 326.24,18.87 325.86,19.25 325.86,20.52 325.99,20.64 326.88,20.64
BST_+V0.95SP on IN4 (solid shape): 331.7,19.64 331.7,18.69 331.13,18.12 330.5,18.12 330.12,18.5 330.12,18.69 331.26,19.83 331.51,19.83
BST_+V0.95SP_C on TOP (solid shape): 326.92,23.77 326.92,22.18 326.8,22.05 324.7,22.05 324.57,22.18 324.57,23.35 325.1,23.87 326.83,23.87
BST_R_EDRAMP on TOP (solid shape): 76.31,13.67 76.31,13.16 76.18,13.04 74.15,13.04 74.02,13.16 74.02,13.74 74.08,13.8 76.18,13.8
BST_R_EOPIOP on TOP (solid shape): 58.59,14.1 58.59,12.78 58.53,12.72 56.37,12.72 56.24,12.85 56.24,13.42 56.37,13.55 56.89,13.55 57.79,14.45 58.25,14.45
CHG on TOP: 272.76,18.75 274.35,18.75 274.54,18.56 274.54,18.24 274.28,17.99 272.76,17.99 272.76,17.48 272.95,17.29 274.09,17.29 274.1,17.3 280.66,17.3 281.28,17.93 281.28,20.85 281.09,21.04 274.55,21.04 273.66,20.15 273.65,20.15 272.76,19.26
DH_1.2V on BOTTOM (solid shape): 73.38,22.8 73.38,22.14 72.92,21.67 71.21,21.67 71.02,21.86 71.02,22.82 71.15,22.94 73.24,22.94
DH_1.2V on BOTTOM (solid shape): 63.33,18.37 63.33,18.18 63.21,18.05 62.32,18.05 61.98,17.72 60.94,17.72 60.88,17.78 60.88,17.86 60.94,17.92 61.74,17.92 62.38,18.56 63.14,18.56
DH_1.2V on IN4 (solid shape): 72.59,22.72 72.59,21.83 72.34,21.58 70.31,21.58 70.11,21.77 70.11,22.47 70.24,22.59 71.26,22.59 71.58,22.91 72.4,22.91
DH_1.2V on IN4 (solid shape): 64.16,19.32 64.16,19.01 63.21,18.05 62.32,18.05 62.19,18.18 62.19,18.44 63.33,19.58 63.91,19.58
DL_1.2V on BOTTOM (solid shape): 76.03,24.28 76.03,23.45 75.84,23.26 74.26,23.26 74,23.52 74,24.28 74.19,24.47 75.84,24.47
DL_1.2V on BOTTOM (solid shape): 62.45,20.91 62.45,20.09 62.26,19.9 62,19.9 60.63,18.52 60.53,18.52 60.48,18.58 60.48,19.38 61.09,19.99 61.13,20.02 61.16,20.07 61.64,20.54 61.64,20.55 62.13,21.04 62.32,21.04
DL_1.2V on IN4 (solid shape): 63.97,21.93 63.97,21.42 62.45,19.9 62.06,19.9 61.94,20.02 61.94,20.85 63.27,22.18 63.72,22.18
DL_1.2V on IN4 (solid shape): 76.18,24.15 76.18,23.32 75.99,23.13 75.29,23.13 74.65,23.77 74.65,24.4 74.78,24.53 75.8,24.53
LG_3V on TOP (solid shape): 342.78,26.07 342.78,24.93 342.52,24.67 341.71,24.67 341.49,24.89 341.49,26.17 341.67,26.35 342.51,26.35
LG_3V on TOP (solid shape): 352.98,30.12 353.28,30.12 353.3,30.1 353.47,30.1 353.52,30.04 353.52,29.74 353.39,29.61 352.39,29.61 351.84,30.16 351.83,30.16 351.77,30.22 351.72,30.22 351.67,30.27 351.67,30.4 351.71,30.44 352.67,30.44
LG_3V on IN3 (solid shape): 353.01,30.14 353.52,30.14 353.57,30.09 353.57,29.71 353.47,29.62 351.16,29.62 350.62,29.07 350.62,25.66 349.47,24.51 342.62,24.51 341.41,25.71 341.41,26.3 341.57,26.45 342.63,26.45 343.34,25.73 349.04,25.73 349.54,26.24 349.54,29.75 350.03,30.24 352.91,30.24
LG_5V on TOP (solid shape): 352.55,38.07 352.55,36.51 352.49,36.46 351.76,36.46 351.68,36.54 351.68,37.88 351.5,38.06 351.5,38.56 351.62,38.69 351.93,38.69
LG_5V on TOP (solid shape): 353.39,33.22 353.39,32.25 353.29,32.15 352.81,32.15 352.49,31.83 351.72,31.83 351.66,31.89 351.66,31.99 353,33.32 353.29,33.32
LG_5V on IN3 (solid shape): 353.36,37.02 353.36,33.22 353.66,32.92 353.66,32.34 353.4,32.09 352.89,32.09 352.64,32.34 352.64,36.34 352.01,36.98 352.01,37.68 352.2,37.87 352.51,37.87
LG_+1VSP on IN4 (solid shape): 99.55,120.11 99.55,119.4 98.99,118.84 98.99,118.77 98.99,118.77 98.99,117.88 98.87,117.75 98.55,117.75 97.57,118.73 97.57,119.32 98.48,120.24 99.42,120.24
LG_+1VSP on IN4 (solid shape): 99.45,125.52 99.95,125.52 100.31,125.17 100.31,124.1 100.23,124.02 99.09,124.02 99.04,124.07 99.04,124.56 98.87,124.72 98.34,124.72 98.3,124.76 98.3,125.43 98.4,125.53 99.43,125.53
LG_+1VSP on TOP: 99.85,125.8 100,125.65 100,124.89 99.88,124.76 97.85,124.76 97.67,124.94 97.67,125.67 97.79,125.8
LG_+1VSP on TOP: 97.92,117.62 98.86,117.62 99.01,117.77 99.01,118.99 98.91,119.1 97.97,119.1 97.87,118.99 97.87,117.67
LGATE_CHG on TOP (solid shape): 287.71,23.2 287.71,22.68 287.13,22.1 286.37,22.1 286.22,22.25 286.22,22.58 285.92,22.88 284.92,22.88 284.73,23.07 284.73,23.32 284.84,23.43 287.49,23.43
LGATE_CHG on IN4 (solid shape): 285.81,23.49 285.81,22.03 285.69,21.91 283.82,21.91 283.49,22.23 283.49,23.31 283.78,23.6 285.7,23.6
LGATE_CHG on TOP: 274.74,31.96 275.57,31.96 276.39,31.14 276.39,31.01 276.58,30.82 276.58,30.63 276.46,30.5 276.46,29.87 276.33,29.74 275.95,29.74 275.82,29.87 275.82,30.25 276.08,30.5 276.08,31.14 275.51,31.71 274.74,31.71 274.68,31.77 274.68,31.9
LGATE_CHG on IN4: 276.65,29.81 276.65,30.86 276.5,31.01 276.27,31.01 276.08,30.82 276.08,30.63 275.89,30.44 275.66,30.44 275.19,29.97 275.19,28.47 275.38,28.28 275.76,28.28 276.33,28.85 276.33,29.48
LX_2.5V on TOP (solid shape): 23.4,56.22 23.41,56.22 23.54,56.09 23.54,53.93 22.58,52.98 18.01,52.98 17.82,53.17 17.82,54.31 18.39,54.88 18.39,55.39 18.27,55.52 17.5,55.52 17.38,55.65 17.38,55.84 17.44,55.9 18.95,55.9 19.51,56.46 23.16,56.46
LX_CHG on TOP (solid shape): 278.04,34.87 278.04,34.67 277.83,34.46 277.83,33.84 277.46,33.47 276.61,33.47 276.61,33.47 275.86,33.47 275.72,33.33 274.74,33.33 274.67,33.41 274.67,33.49 274.73,33.55 275.5,33.55 276.48,34.54 277.01,34.88 277.21,35.08 277.83,35.08
LX_CHG on TOP: 285.15,17.36 285.2,17.42 285.67,17.88 285.67,22.5 285.6,22.56 284.46,22.56 284.33,22.69 284.33,22.88 283.89,23.32 281.92,23.32 281.47,23.77 281.47,24.79 281.73,25.04 284.52,25.04 284.71,25.23 284.71,28.15 284.59,28.28 279.44,28.28 278.17,27.01 277.66,27.01 277.52,26.86 277.52,22.52 278.33,21.71 281.44,21.71 281.79,21.36 281.79,17.8 282.23,17.36
LX_CHG on IN1: 278.87,23.93 277.35,23.93 277.21,23.79 277.21,22.54 277.41,22.34 278.87,22.34 279.06,22.53 279.06,23.74
LX_CHG on IN1: 277.85,35.11 275.53,35.11 275.43,35 275.43,33.97 275.61,33.79 277.92,33.79 278.11,33.98 278.11,34.85
NB_PSID on BOTTOM (solid shape): 33.06,59.14 33.06,52.22 32.17,51.33 31.79,51.33 31.73,51.39 31.73,51.77 32.17,52.22 32.17,59.2 33,59.2
Net_75 on BOTTOM (solid shape): 17.96,59.54 2.96,59.54 2.96,69.54 17.96,69.54
Net_76 on BOTTOM (solid shape): 10.71,31.16 2.71,31.16 2.71,39.16 10.71,39.16
Net_77 on BOTTOM (solid shape): 10.71,22.02 2.71,22.02 2.71,30.02 10.71,30.02
PBATT+ on TOP (solid shape): 265.39,15.7 265.39,8.96 263.44,7.01 261.7,7.01 261.45,7.26 261.45,10.92 261.85,11.32 262.79,11.32 263.17,11.7 263.17,12.47 262.79,12.85 260.57,12.85 260.25,12.53 257.07,12.53 256.82,12.78 256.82,14.3 257.09,14.57 260.52,14.57 260.85,14.9 260.85,16.38 261.05,16.58 261.05,16.59 264.5,16.59
PBATT+_C on TOP (solid shape): 268.38,10.69 268.38,9.67 268.37,9.66 267.88,7.59 268.3,5.51 268.31,5.48 266.51,3.68 265.99,3.68 265.2,2.89 265.2,1.86 264.76,1.42 262.03,1.42 261.58,1.86 261.58,4.66 262.69,5.76 263.13,5.76 263.24,5.87 263.24,6.5 265.58,8.85 265.58,11.07 265.9,11.39 267.68,11.39
PBATT_IN_SS on TOP (solid shape): 288.4,12.97 288.4,12.53 289.35,11.58 292.59,11.58 292.71,11.45 292.71,10.05 292.65,9.99 291.82,9.99 291.7,9.86 289.22,9.86 287,7.64 283.82,7.64 283.44,7.26 283.44,5.74 283.25,5.54 282.93,5.54 282.81,5.42 282.81,4.78 282.68,4.66 281.98,4.66 281.73,4.91 281.73,9.86 283.16,11.29 283.16,13.01 283.7,13.55 287.82,13.55
PBATT_IN_SS on TOP: 256.14,12.1 260.24,12.1 260.6,11.74 260.6,6.03 259.97,5.4 256.18,5.4 255.76,5.82 255.76,11.72
PBATT_IN_SS on IN1: 262.36,9.41 267.33,14.37 281.41,14.37 281.89,13.89 284.5,13.89 286.68,11.7 286.68,9.86 285.13,8.31 278.07,8.31 275.8,10.59 271.24,10.59 266.3,5.65 256.05,5.65 255.66,6.04 255.66,8.08 255.7,8.12 255.7,8.67 256.43,9.41
SNB_0.95V on TOP (solid shape): 327.3,14.31 327.3,13.8 327.56,13.55 328.32,13.55 328.51,13.36 328.51,11.6 328.35,11.44 326.6,11.44 326.16,11.88 326.16,12.6 326.04,12.72 326.03,12.73 326.03,14.31 326.22,14.5 327.11,14.5
SNUB_1.35V on TOP (solid shape): 64.6,19.71 64.6,17.23 64.03,16.66 62.77,16.66 62.62,16.81 62.62,17.5 62.74,17.62 63.28,17.62 63.53,17.87 63.53,19.71 63.59,19.77 64.54,19.77
SNUB_3V on TOP (solid shape): 346.1,26.82 347.01,26.82 347.3,26.53 347.3,25.62 347.31,25.61 347.31,24.72 347.18,24.59 345.4,24.59 345.02,24.98 345.02,27.01 345.15,27.13 345.78,27.13
SNUB_5V on TOP (solid shape): 354.65,38.97 354.65,36.89 354.49,36.74 353.15,36.74 352.83,37.05 352.83,39.04 352.89,39.1 354.52,39.1
SNUB_CHG on TOP (solid shape): 287.22,19.04 287.22,18.34 287.35,18.21 288.05,18.21 288.17,18.09 288.17,17.51 287.98,17.32 286.08,17.32 285.95,17.45 285.95,19.04 286.08,19.17 287.09,19.17
SW1 on TOP (solid shape): 352.19,42.37 354.42,42.37 354.61,42.18 354.61,39.87 354.22,39.48 352.77,39.48 352.49,39.2 348.51,39.2 348.45,39.14 346.8,39.14 346.32,39.61 346.32,42.66 346.74,43.07 351.49,43.07
SW1 on IN1 (solid shape): 344.26,39.96 344.26,37.93 347.64,34.55 349.48,34.55 349.59,34.44 349.59,33.74 349.47,33.61 349.21,33.61 349,33.83 347.09,33.83 343.5,37.42 343.5,39.96 343.62,40.09 344.13,40.09
SW1 on TOP: 350.56,32.17 350.61,32.12 350.7,32.12 350.76,32.17 350.76,34.53 350.66,34.63 348.84,34.63 348.47,34.26 348.47,33.93 348.6,33.8 350.32,33.8 350.49,33.63 350.49,33.21 350.56,33.15
SW1 on BOTTOM: 340.07,41.8 340.07,34.23 340.75,33.55 346.89,33.55 348.13,34.79 348.13,40.47 348.7,41.04 349.72,41.04 349.97,41.3 349.97,42.63 349.53,43.07 346.31,43.07 345.8,42.57 340.83,42.57
SW2 on TOP (solid shape): 350.78,30.12 350.78,28.91 350.79,28.91 350.79,28.14 350.59,27.94 350.59,27.49 350.18,27.08 350.18,20.06 348.62,18.5 343.24,18.5 340.19,21.55 340.19,22.94 340.32,23.07 341.39,23.07 341.58,23.26 341.58,23.78 341.89,24.09 347.16,24.09 347.62,24.55 347.62,26 350.55,28.93 350.55,30.09 350.63,30.17 350.73,30.17
SW_1.2V on TOP (solid shape): 71.54,22.12 71.57,22.12 71.82,21.86 71.82,19.03 71.54,18.75 67.54,18.75 67.35,18.56 67.35,18.12 67.16,17.93 66.32,17.93 66.07,18.18 66.07,19.2 65.07,20.2 65.07,22.12 65.57,22.63 71.04,22.63
SW_1.2V on BOTTOM (solid shape): 73.49,27.91 73.49,23.94 72.88,23.32 71.1,23.32 70.78,23.01 70.78,21.99 70.27,21.48 67.61,21.48 67.4,21.28 67.4,19.96 67.27,19.83 66.38,19.83 66.26,19.96 63.78,19.96 63.08,19.26 63.08,18.82 63.02,18.75 62.38,18.75 61.75,18.12 60.94,18.12 60.88,18.17 60.88,18.27 65.62,23.01 65.62,27.64 66.13,28.15 73.26,28.15
SW_+1VSP on TOP: 95.1,119.91 95.74,119.27 100.21,119.27 100.41,119.48 100.41,121.33 100.61,121.53 101.2,121.53 101.43,121.76 101.43,124 100.99,124.43 100.99,125.7 100.92,125.78 100.77,125.78 100.72,125.72 100.72,124.38 100.59,124.25 100.59,123.06 100,122.47 98.18,122.47 97.95,122.7 97.95,123.72 97.21,124.45 93.53,124.45 92.92,123.85 92.92,120.19 93.2,119.91
SW_+1VSP on BOTTOM: 97.88,122.05 98.02,122.19 98.02,125.47 97.58,125.92 94.07,125.92 93.15,124.99 93.15,122.65 93.74,122.05
SW_+V0.95SP on TOP (solid shape): 325.65,21.4 325.65,19.83 326.32,19.17 326.64,19.17 327.81,17.99 329.08,17.99 329.15,17.93 329.15,16.91 329.08,16.85 328.13,16.85 326.67,15.39 325.27,15.39 324.7,14.82 324.7,12.88 324.54,12.72 323.47,12.72 323.37,12.83 323.37,19.83 323.35,19.85 323.35,21.33 323.54,21.52 325.53,21.52
SW_EDRAMP on TOP (solid shape): 78.34,11.96 78.34,10.75 77.7,10.12 77.7,8.15 77.19,7.64 76.18,7.64 76.05,7.77 76.05,8.28 75.8,8.53 73.64,8.53 73.51,8.66 73.51,8.78 73.64,8.91 75.8,8.91 76.05,9.16 76.05,11.01 75.29,11.77 75.29,12.4 75.35,12.47 77.83,12.47
SW_EOPIOP on TOP (solid shape): 59.16,11.32 60.43,11.32 60.56,11.2 60.56,9.82 60.43,9.7 59.95,9.7 59.8,9.55 59.8,7.39 59.67,7.26 59.03,7.26 58.91,7.39 58.91,8.15 58.65,8.4 56.49,8.4 56.49,8.66 58.27,8.66 58.78,9.16 58.78,10.31 57.89,11.2 57.64,11.2 57.51,11.32 57.51,11.96 57.64,12.09 58.4,12.09
UG_3V on TOP (solid shape): 341.27,24.94 341.27,24.79 341.27,24.79 341.27,23.52 341.12,23.36 340.35,23.36 340.25,23.46 340.25,24.92 340.47,25.14 341.07,25.14
UG_3V on TOP (solid shape): 352.6,29.14 353.71,29.14 353.88,28.98 353.88,28.28 353.78,28.17 353.05,28.17 352.62,28.6 352,28.6 351.36,29.24 351.36,29.94 351.36,30.05 351.42,30.11 351.63,30.11
UG_3V on IN4 (solid shape): 353.83,28.92 353.83,25.13 350.95,22.25 341.46,22.25 340.32,23.39 340.32,23.4 340.15,23.56 340.15,24.98 340.27,25.09 340.85,25.09 340.98,24.95 340.98,24.14 341.32,23.81 341.87,23.26 350.53,23.26 352.75,25.48 352.75,28.92 352.89,29.06 353.68,29.06
UG_5V on TOP (solid shape): 346.08,41.94 346.08,39.56 345.91,39.39 345.15,39.39 345.02,39.52 345.02,40.41 345.01,40.41 345.01,41.92 345.14,42.06 345.96,42.06
UG_5V on TOP (solid shape): 352.37,33.5 352.37,32.93 351.63,32.19 351.42,32.19 351.36,32.25 351.36,33.05 351.74,33.43 351.87,33.43 352.06,33.62 352.25,33.62
UG_5V on IN1 (solid shape): 345.78,40.47 345.78,38.69 348.58,35.9 351.37,35.9 352.39,34.88 352.39,32.85 352.13,32.6 351.88,32.6 351.62,32.85 351.62,34.37 350.86,35.14 348.07,35.14 344.89,38.31 344.89,40.47 345.02,40.6 345.66,40.6
UG_+1VSP on IN4 (solid shape): 102.54,124.63 102.54,123.62 102.42,123.49 101.07,123.49 100.97,123.59 100.97,124.81 101.05,124.89 102.29,124.89
UG_+1VSP on IN4 (solid shape): 102.04,118.87 102.04,118.54 101.07,117.57 99.52,117.57 99.32,117.77 99.32,118.65 99.46,118.8 100.39,118.8 101.06,119.46 101.44,119.46
UG_+1VSP on TOP: 101.25,125.78 101.45,125.78 101.5,125.72 101.5,125.09 101.82,124.77 102.16,124.77 102.37,124.57 102.37,124.28 102.24,124.15 101.48,124.15 101.2,124.43 101.2,125.72
UG_+1VSP on TOP: 99.5,119.1 100.28,119.1 100.49,118.89 100.49,117.7 100.36,117.57 99.55,117.57 99.27,117.85 99.27,118.87
UGATE_CHG on TOP (solid shape): 276.82,33.11 276.82,32.77 276.69,32.64 276.48,32.64 276.33,32.79 275.95,32.79 275.8,32.93 274.71,32.93 274.66,32.98 274.66,33.09 274.74,33.16 275.74,33.16 275.85,33.27 276.66,33.27
UGATE_CHG on BOTTOM (solid shape): 283.5,24.45 283.5,23.88 283.25,23.63 281.45,23.63 281.14,23.94 281.14,24.81 283.14,24.81
UGATE_CHG on IN1 (solid shape): 277.41,33.11 277.41,31.94 277.26,31.8 276,31.8 275.77,32.03 275.77,33.11 275.94,33.28 277.23,33.28
UGATE_CHG on TOP: 282.41,24.56 282.41,24.55 282.26,24.55 282.11,24.4 282.11,23.9 282.17,23.83 284.52,23.83 284.71,24.02 284.71,24.43 284.58,24.56
UGATE_CHG on IN1: 283.22,25.95 282.14,25.95 281.89,25.7 281.89,23.84 282.11,23.62 283.18,23.62 283.47,23.91 283.47,25.7
VLDOIN_1.2V on BOTTOM: 62.32,16.78 61.98,17.12 60.94,17.12 60.88,17.06 60.88,16.98 60.94,16.92 61.74,16.92 61.98,16.68 61.98,16.23 63.03,15.19 63.85,15.19 63.87,15.21 63.87,15.62 64.43,15.62 64.43,15.62 64.43,15.79 64.42,15.8 63.93,15.8 63.91,15.79 63.87,15.83 63.87,16.19 63.88,16.2 63.29,16.78
N16717680 on BOTTOM: 39.68,47.39 38.14,47.39 37.89,47.14 37.89,45.8 38.84,44.85 42.4,44.85 42.7,44.55 42.7,43.35 43.13,42.92 43.74,42.92 44.15,42.51 44.15,41.68 44.33,41.5 45.52,41.5 45.55,41.52 45.55,42.08 46.36,42.9 46.36,43.45 46.15,43.66 45.34,43.66 45.29,43.61 44.33,43.61 43.95,43.99 43.95,44.32 42.83,45.44 40.16,45.44 39.93,45.66 39.93,47.14
N17684555 on TOP (solid shape): 286.11,7.2 286.11,4.53 286.1,4.52 286.1,3.85 285.75,3.5 285.35,3.5 285.28,3.56 285.28,5.23 284.84,5.67 284.84,7.32 284.9,7.39 285.92,7.39
N26822390 on TOP (solid shape): 277.89,33.1 277.89,32.33 277.78,32.22 276.06,32.22 275.79,32.49 274.77,32.49 274.68,32.59 274.68,32.71 274.73,32.76 275.78,32.76 275.88,32.66 276.27,32.66 276.44,32.48 276.78,32.48 276.96,32.66 276.96,33.19 276.99,33.23 277.77,33.23
N26822393 on TOP (solid shape): 279.4,35.26 279.4,33.87 279.22,33.05 279.22,32.21 278.27,32.21 278.16,32.32 278.16,34.33 278.27,34.44 278.27,35.24 278.41,35.38 279.28,35.38
N27069121 on TOP: 102.18,123.9 102.98,123.9 103.13,124.05 104.17,124.05 104.27,123.95 104.27,123.41 103.84,122.98 103.84,122.59 103.51,122.26 102.21,122.26 102.07,122.41 102.07,122.93 102.05,122.94 102.05,123.77
N27069164 on TOP: 92.94,118.97 94.77,118.97 94.9,118.84 94.9,118 94.67,117.77 94.31,117.77 94.16,117.62 94.16,116.99 94.09,116.91 93.43,116.91 93.37,116.96 92.36,116.96 92.05,117.27 92.05,118.05 92.82,118.82 92.82,118.84
N27207381 on BOTTOM (solid shape): 238.83,70.95 238.83,70.56 238.7,70.43 238.7,69.41 238.53,69.24 237.2,69.24 237.13,69.3 237.13,71.24 237.3,71.41 238.37,71.41
N27207408 on BOTTOM (solid shape): 236.02,71.55 236.17,71.52 236.33,71.55 236.85,71.55 236.93,71.47 236.93,70.53 236.86,70.46 234.8,70.46 234.69,70.57 234.69,70.65 234.79,70.76 235.53,70.76 235.78,71.01 235.53,71.27 234.79,71.27 234.76,71.27 234.68,71.35 234.68,71.49 234.74,71.55
N27207421 on BOTTOM (solid shape): 236.95,70.2 236.95,69.37 236.87,69.28 236.3,69.28 236.27,69.28 236.05,69.5 236.05,69.82 235.76,70.11 234.74,70.11 234.69,70.16 234.69,70.29 234.71,70.32 236.84,70.32
N27207822 on BOTTOM (solid shape): 231.58,71.47 231.58,70.15 231.53,70.11 230.55,70.11 230.47,70.19 230.47,71.33 230.65,71.51 231.54,71.51
N27208984 on BOTTOM (solid shape): 230.93,77 230.93,75.14 231.37,74.7 231.37,74.69 231.58,74.48 231.58,71.75 231.48,71.65 230.42,71.65 229.91,71.14 226.23,71.14 225.98,71.39 225.98,72.6 228.13,72.6 228.13,73.43 225.98,73.43 225.98,74.89 225.98,74.89 225.98,75.23 226.27,75.52 229.47,75.52 229.98,76.03 229.98,77.03 230.13,77.19 230.74,77.19
N27208988 on BOTTOM (solid shape): 229.83,79.94 229.83,77.56 229.52,77.24 229.52,76.92 229.51,76.92 229.51,75.97 229.39,75.84 228.82,75.84 228.69,75.97 228.69,80.04 228.88,80.24 229.54,80.24
N27209291 on BOTTOM (solid shape): 232.22,69.39 232.22,68.3 232.09,68.17 230.37,68.17 230.26,68.28 230.26,68.83 230.35,68.91 231.35,68.91 231.93,69.49 232.12,69.49
N27209291 on BOTTOM (solid shape): 229.2,68.56 229.2,67.93 228.94,67.67 227.1,67.67 226.97,67.8 226.97,68.69 227.1,68.82 228.94,68.82
N27222324 on BOTTOM (solid shape): 233.61,46.76 233.61,46.43 233.98,46.06 235.67,46.06 235.86,45.87 235.86,45.36 236.12,45.11 237.07,45.11 237.95,44.22 237.95,41.48 237.86,41.39 235.83,41.39 234.66,40.22 232.5,40.22 231.99,40.72 231.99,42.12 234.53,42.12 234.53,43.01 231.99,43.01 231.99,46.76 232.19,46.96 233.4,46.96
N27222328 on BOTTOM (solid shape): 237.2,47.39 237.2,45.74 237.07,45.61 236.18,45.61 236.05,45.74 236.05,46.44 235.8,46.69 233.85,46.69 233.76,46.78 233.76,47.34 233.88,47.45 237.13,47.45
N27222382 on BOTTOM (solid shape): 238.47,39.19 238.55,39.19 238.63,39.12 238.63,38.26 238.49,38.12 237.8,38.12 237.45,37.78 237.45,36.47 237.45,36.47 237.45,35.69 237.21,35.45 235.77,35.45 235.48,35.74 235.48,37.17 235.55,37.23 236.31,37.23 236.65,37.57 236.65,38.79 237.06,39.2 238.46,39.2
N27222513 on BOTTOM (solid shape): 244.67,41.04 244.67,38.93 244.54,38.8 243.92,38.8 243.68,39.04 243.68,41 243.83,41.16 244.55,41.16
N27222533 on BOTTOM (solid shape): 243.36,41.01 243.36,40.31 243.18,40.12 242.58,40.12 242.52,40.18 241.44,40.18 241.44,40.18 241.15,40.18 241.06,40.26 241.06,40.39 241.09,40.47 241.17,40.5 241.18,40.5 241.91,40.5 242.14,40.72 241.91,40.95 241.18,40.95 241.17,40.95 241.09,40.98 241.06,41.05 241.06,41.08 241.06,41.17 241.12,41.23 243.14,41.23
N27222595 on BOTTOM (solid shape): 237.93,41.24 237.99,41.18 237.99,39.88 237.9,39.79 237.08,39.79 237,39.87 237,41.14 237.1,41.24 237.88,41.24
N27229436 on BOTTOM (solid shape): 235.86,66.24 235.86,65.68 236.12,65.43 237.07,65.43 237.07,65.42 237.46,65.42 238,64.89 238,62.24 237.89,62.13 236.25,62.13 234.66,60.54 232.5,60.54 231.99,61.04 231.99,62.44 234.53,62.44 234.53,63.33 231.99,63.33 231.99,65.74 232.57,66.32 233.91,66.32 234.13,66.1 234.54,66.1 234.77,66.32 235.79,66.32
N27229440 on BOTTOM (solid shape): 237.27,68.16 237.27,65.92 236.96,65.61 236.19,65.61 236.05,65.74 236.05,66.76 235.8,67.01 235.79,67.01 235.75,67.05 234.87,67.05 234.78,67.14 234.78,67.65 234.91,67.77 235.75,67.77 236.22,68.24 237.19,68.24
N27229500 on BOTTOM (solid shape): 238.57,59.82 238.57,58.68 238.35,58.46 237.77,58.46 237.63,58.59 237.63,59.67 237.9,59.93 238.46,59.93
N27229500 on BOTTOM (solid shape): 235.48,58.69 235.48,58.06 235.23,57.81 233.39,57.81 233.26,57.93 233.26,58.82 233.39,58.95 235.23,58.95
N27229588 on BOTTOM (solid shape): 244.69,61.68 244.69,59.58 244.63,59.52 243.99,59.52 243.93,59.58 243.93,61.68 243.99,61.74 244.63,61.74
N27229600 on BOTTOM (solid shape): 243.33,61.82 243.33,60.81 243.31,60.78 242.51,60.78 242.37,60.92 241.07,60.92 241.02,60.97 241.02,61.09 241.07,61.13 241.68,61.13 241.74,61.2 241.86,61.2 242.09,61.43 241.86,61.65 241.75,61.65 241.68,61.72 241.07,61.72 241.03,61.77 241.03,61.88 241.07,61.93 243.22,61.93
