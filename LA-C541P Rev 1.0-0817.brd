# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SKL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AB29(-20.725,15.203) AB30(-21.376,15.203) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AK29(-20.725,21.502) AK30(-21.376,21.502) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) B3(-1.382,0.699) B37(-25.909,0.703) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BE29(-20.725,33.313) BE30(-21.376,33.313) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) U29(-20.725,11.266) U30(-21.376,11.266) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) AA11(-6.512,14.548) AA12(-7.162,14.548) AC11(-6.512,15.463) AC12(-7.162,15.463) AD11(-6.512,16.377) AD12(-7.162,16.377) AE11(-6.512,17.291) AE12(-7.162,17.291) AF11(-6.512,18.206) AF12(-7.162,18.206) AG11(-6.512,19.12) AG12(-7.162,19.12) AH11(-6.512,20.035) AH12(-7.162,20.035) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AL11(-6.512,21.863) AL12(-7.162,21.863) AM11(-6.512,22.778) AM12(-7.162,22.778) AN11(-6.512,23.692) AN12(-7.162,23.692) AP11(-6.512,24.607) AP12(-7.162,24.607) AR11(-6.512,25.521) AR12(-7.162,25.521) AT11(-6.512,26.435) AT12(-7.162,26.435) AU11(-6.512,27.35) AU12(-7.162,27.35) AW11(-6.512,28.264) AW12(-7.162,28.264) AY11(-6.512,29.179) AY12(-7.162,29.179) B5(-2.743,0.65) B34(-24.443,0.67) BA11(-6.512,30.093) BA12(-7.162,30.093) BB11(-6.512,31.007) BB12(-7.162,31.007) BC11(-6.512,31.922) BC12(-7.162,31.922) BD11(-6.512,32.836) BD12(-7.162,32.836) BF11(-6.512,33.751) BF12(-7.162,33.751) BG11(-6.512,34.665) BG12(-7.162,34.665) BH11(-6.512,35.579) BH12(-7.162,35.579) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BK1(0,37.037) BK13(-7.899,36.727) BL38(-26.628,37.176) BN2(-0.65,38.642) BN37(-25.965,38.665) BR5(-2.166,39.984) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) D37(-25.603,1.985) E2(-0.65,2.474) G1(0,3.581) G38(-26.628,3.671) K11(-6.512,5.48) K12(-7.162,5.48) L11(-6.512,6.319) L12(-7.162,6.319) M11(-6.512,7.233) M12(-7.162,7.233) N11(-6.512,8.147) N12(-7.162,8.147) P11(-6.512,9.062) P12(-7.162,9.062) R11(-6.512,9.976) R12(-7.162,9.976) T11(-6.512,10.891) T12(-7.162,10.891) V11(-6.512,11.805) V12(-7.162,11.805) W11(-6.512,12.719) W12(-7.162,12.719) Y11(-6.512,13.634) Y12(-7.162,13.634)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BL2(-0.65,37.438) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM2(-0.963,38.053) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BM37(-25.978,37.986) BN3(-1.3,38.701) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BN36(-25.314,38.638) BP3(-1.483,39.334) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BP35(-24.561,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BR34(-23.774,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) C36(-25.145,1.388) D4(-1.894,1.655) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E3(-1.3,2.474) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) E37(-25.978,2.604) F2(-0.65,3.16) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SN74LVC1G3157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
SSM3K7002FU_SC70-3
  oval 0.508x0.991 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
STARC_7300L30-100000-G4_30P-T
  round 0.762 hole 0.762 unplated: (-15.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0)
  rect 1.499x2.997 smd: 31(-17,2.125) 34(2.5,2.125)
  rect 2.794x1.499 smd: 32(-12.95,4.175) 33(-1.55,4.175)
SUYIN_200045GR009M28QZR_9P
  round 1.6 hole 0.991: 1(0,0) 2(2,0) 3(4,0) 4(6,0) 5(8,0) 6(10,0) 7(12,0) 8(14,0) 9(16,0)
  oval 1.6x3.454 hole 0.991x2.845: 10(-3.125,0) 11(19.125,0)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SS3-CMFTQR9_3P
  oval 0.991x2.489 smd: 1(0,0) 2(2,0) 3(4,0)
  round 1.651 hole 0.889: 4(-0.15,-3.75) 5(6.15,-3.75)
SY8003DFC_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.838 smd: 9(0.75,1.1)
SYX198DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.168x0.254 smd: 7(2.19,-0.675)
  rect 0.914x2.007 smd: 8(2.065,-2)
  custom 0.482x0.482 smd: 9(1.103,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
T-SOL_159-1000302602_10P
  round 0.889 hole 0.889 unplated: (8.485,-1.425) (8.675,-14.375)
  oval 0.508x1.245 smd: 1(0,0) 2(0.7,0) 3(1.4,0) 4(2.1,0) 5(2.8,0) 6(3.5,0) 7(4.2,0) 8(4.9,0) 9(5.6,0) 10(6.3,0)
  rect 0.889x1.397 smd: 11(8.955,0.075) 18(-1.155,0.075)
  rect 0.381x1.6 smd: 12(10.71,-2.475)
  rect 0.381x1.499 smd: 13(10.71,-9.325) 16(-3.62,-9.325)
  rect 1.092x1.092 smd: 14(10.345,-15.145) 15(-3.255,-15.145)
  rect 0.381x1.245 smd: 17(-3.62,-3.085)
TAI-T_HCB1608KF-121T3_L0603_2P
  rect 0.991x0.787 smd: 1(0,0) 2(1.6,0)
TAI-T_HCB2012KF-121T50_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAIYO_BRC2012T4R7MD_2P
  rect 0.61x1.448 smd: 1(0,0) 2(1.6,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SH125FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TOKO_FDVE1040-H-3R3M-P3_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.8,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TPS51285BRUKR_QFN20_3X3
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.702x1.702 smd: 21(0.8,1.488)
TS5A63157DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q32FVSSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI219LM-QREF-A0_QFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 2.997x2.997 smd: 49(3.05,-2.2)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.6V_DDR_VTT_ON: PR208.1 RD61.2 UD1.4
0.95V_MP_PWROK: PR315.2 PU300.2
1.2V_B+: PC202.1 PC203.1 PC204.1 PC205.1 PJP200.2 PQ201.5 PR205.1
1.2V_FB: PC211.1 PR204.1 PR207.1 PU200.6
1.2V_SUS_PWRGD: PR209.2 PU200.10 U9.2
3.3V_CAM_EN#: Q24.2 UH1.BD14
3.3V_RUN_GFX_ON: Q87.2 QH3.2 U46.A55 UZ26.3 UZ26.5
3.3V_TP_EN: RH79.2 UH1.BC27
3.3V_WWAN_EN: R720.1 U46.B42 UZ24.3
3V_5V_EN: PC119.1 PR113.2 PU101.6 PU101.20
5VUSB_OFF: JIO2.68 U46.A46
+0.6V_DDR_VTT: CD17.1 CD19.1 CD30.1 CD36.1 CD48.1 CD54.1 CD66.1 CD72.1 CD98.1 CD105.1 CD113.1 CD121.1 JDIMM1.258 JDIMM2.258 JDIMM3.258 JDIMM4.258 PJP202.1
+0.6V_P: PC207.1 PJP202.2 PU200.2 PU200.20
+0.9V_LAN: C462.1 C463.1 C466.1 C467.1 C468.1 C469.1 C1177.1 L29.2 U31.8 U31.11 U31.16 U31.22 U31.37 U31.40 U31.43 U31.46 U31.47
+1.0V_AAZPLL: RH240.2 UH1.AN19
+1.0V_ALW_PCH: PJP8.2 RH238.1 RH254.2 RH255.1 RH256.1 RH257.1 RH258.1 RH259.1 RH260.1 RH286.1 RH287.1 RH288.1 RH289.1 RH290.1
+1.0V_AMPHYPLL: CH267.1 RH289.2 UH1.A43 UH1.B43 UH1.C44 UH1.C45
+1.0V_APLLEBB: RH290.2 UH1.V28
+1.0V_AUSB: RH239.2 UH1.AJ5 UH1.AL5
+1.0V_CLK1: RH256.2 UH1.N17
+1.0V_CLK2: RH259.2 UH1.R17 UH1.V17
+1.0V_CLK3: RH257.2 UH1.R19
+1.0V_CLK4: RH258.2 UH1.U20
+1.0V_CLK5: CH29.1 CH32.1 CH46.1 RH171.1 RH241.2 UH1.K2 UH1.K3
+1.0V_DSW: CH35.1 RH255.2 UH1.BA29
+1.0V_DTS: RH288.2 UH1.AD15
+1.0V_DUSB: CH38.1 RH286.2 UH1.AC17
+1.0V_F24: RH241.1 RH260.2
+1.0V_MPHY: CH34.1 CH47.1 PJP8.1 UH1.U21 UH1.U23 UH1.U25 UH1.U26 UH1.V26
+1.0V_PRIM: CZ88.1 CZ90.1 PJP801.2 RC216.1 RH254.1 UH1.AA23 UH1.AA26 UH1.AA28 UH1.AC23 UH1.AC26 UH1.AC28 UH1.AE23 UH1.AE26 UH1.AJ20 UH1.AJ21 UH1.AJ23 UH1.AJ25 UH1.Y23 UH1.Y25 UZ18.1 UZ18.2 UZ18.7 UZ19.1 UZ19.2 UZ19.7 UZ23.1 UZ23.2
+1.0V_PRIM_XDP: CC33.1 CC37.1 JXDP1.43 JXDP1.44 RC6.2 RC138.2 RC216.2
+1.0V_PRIMP: PC806.1 PJP801.1 PL800.2 PR807.2
+1.0V_RUN: C401.1 PJP16.1 R866.2 U6.5
+1.0V_RUN_PWR: C1424.1 PJP16.2 UZ23.7 UZ23.8
+1.0V_VCCSFR: CC192.2 CPU1.H28 CPU1.J28 RC304.2
+1.0V_VCCST: CC191.2 CC193.2 CC194.2 CPU1.H30 PC1101.2 PJP6.1 PR1103.1 PR1104.1 PR1105.2 PR1199.1 RC155.1 RC157.1 RC164.2 RC166.2 RC172.2 RC304.1 RC317.2 RC326.2
+1.0V_VCCST_UZ18: CZ63.1 PJP6.2 UZ18.6
+1.0V_VCCSTG: CC186.2 CC195.2 CPU1.G30 CPU1.H29 PJP7.1 RC135.1 RC180.1 RC317.1 RH312.1 RH314.1 RH315.1
+1.0V_VCCSTG_C: CZ82.1 PJP7.2 UZ19.6
+1.2V_MEM: CC81.1 CC82.1 CC83.1 CC84.1 CC161.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC168.1 CC170.1 CC171.1 CC172.1 CD4.1 CD5.1 CD6.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD18.1 CD20.1 CD23.1 CD24.1 CD25.1 CD27.1 CD28.1 CD31.1 CD32.1 CD34.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD45.1 CD46.1 CD49.1 CD50.1 CD52.1 CD57.1 CD58.1 CD59.1 CD60.1 CD61.1 CD63.1 CD64.1 CD67.1 CD68.1 CD70.1 CD89.1 CD90.1 CD91.1 CD93.1 CD94.1 CD95.1 CD96.1 CD97.1 CD99.1 CD100.1 CD101.1 CD102.1 CD103.1 CD104.1 CD106.1 CD107.1 CD108.1 CD109.1 CD110.1 CD111.1 CD112.1 CD114.1 CD115.1 CD116.1 CD117.1 CD118.1 CD119.1 CD120.1 CD129.1 CD139.1 CD142.1 CD144.1 CPU1.AA6 CPU1.AE12 CPU1.AF5 CPU1.AF6 CPU1.AG5 CPU1.AG9 CPU1.AJ12 CPU1.AL11 CPU1.AP6 CPU1.AP7 CPU1.AR6 CPU1.AR12 CPU1.AT12 CPU1.AW6 CPU1.AY6 CPU1.J5 CPU1.J6 CPU1.K6 CPU1.K12 CPU1.L6 CPU1.L12 CPU1.R6 CPU1.T6 CPU1.W6 CZ97.1 JDIMM1.12 JDIMM1.33 JDIMM1.54 JDIMM1.75 JDIMM1.96 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM1.129 JDIMM1.130 JDIMM1.135 JDIMM1.136 JDIMM1.141 JDIMM1.142 JDIMM1.147 JDIMM1.148 JDIMM1.153 JDIMM1.154 JDIMM1.159 JDIMM1.160 JDIMM1.163 JDIMM1.178 JDIMM1.199 JDIMM1.220 JDIMM1.241 JDIMM2.12 JDIMM2.33 JDIMM2.54 JDIMM2.75 JDIMM2.96 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 JDIMM2.129 JDIMM2.130 JDIMM2.135 JDIMM2.136 JDIMM2.141 JDIMM2.142 JDIMM2.147 JDIMM2.148 JDIMM2.153 JDIMM2.154 JDIMM2.159 JDIMM2.160 JDIMM2.163 JDIMM2.178 JDIMM2.199 JDIMM2.220 JDIMM2.241 JDIMM3.12 JDIMM3.33 JDIMM3.54 JDIMM3.75 JDIMM3.96 JDIMM3.111 JDIMM3.112 JDIMM3.117 JDIMM3.118 JDIMM3.123 JDIMM3.124 JDIMM3.129 JDIMM3.130 JDIMM3.135 JDIMM3.136 JDIMM3.141 JDIMM3.142 JDIMM3.147 JDIMM3.148 JDIMM3.153 JDIMM3.154 JDIMM3.159 JDIMM3.160 JDIMM3.163 JDIMM3.178 JDIMM3.199 JDIMM3.220 JDIMM3.241 JDIMM4.12 JDIMM4.33 JDIMM4.54 JDIMM4.75 JDIMM4.96 JDIMM4.111 JDIMM4.112 JDIMM4.117 JDIMM4.118 JDIMM4.123 JDIMM4.124 JDIMM4.129 JDIMM4.130 JDIMM4.135 JDIMM4.136 JDIMM4.141 JDIMM4.142 JDIMM4.147 JDIMM4.148 JDIMM4.153 JDIMM4.154 JDIMM4.159 JDIMM4.160 JDIMM4.163 JDIMM4.178 JDIMM4.199 JDIMM4.220 JDIMM4.241 PJP203.1 PJP204.1 RC220.2 RC302.2 RD7.1 RD9.1 RD43.1 RD46.1 UD1.5 UZ30.1 UZ30.2 UZ30.7
+1.2V_MEN_P: PC201.1 PC211.2 PC214.1 PJP201.1 PJP203.2 PJP204.2 PL201.1 PR204.2 PU200.5
+1.8V_ALW: PJP901.2 RH247.2 UZ22.1 UZ22.2
+1.8V_ALW_PCHRES: RH247.1 RH250.1 RH294.1 RH295.1 RH296.1
+1.8V_RUN: PJP24.1 RH252.1 RH253.1
+1.8V_RUN_EDRAM: CC190.1 CPU1.BM14 RH252.2
+1.8V_RUN_EDRAM_ED2: CPU1.BJ35 RC226.2
+1.8V_RUN_PWR: C767.1 PJP24.2 UZ22.7 UZ22.8
+1.8VSP: PC903.1 PC904.1 PJP901.1 PR902.1 PU900.3 PU900.4
+1.8VSP_ON: PC902.1 PR900.2 PR901.1 PU900.8
+1.8VSP_VIN: PC901.1 PJP900.2 PU900.5 PU900.9
+1VSP_B+: PC801.1 PC802.1 PC803.1 PJP800.2 PQ800.5
+2.5V_MEM: CD2.1 CD3.1 CD7.1 CD8.1 CD33.1 CD35.1 CD37.1 CD38.1 CD51.1 CD53.1 CD55.1 CD56.1 CD69.1 CD71.1 CD73.1 CD74.1 JDIMM1.257 JDIMM1.259 JDIMM2.257 JDIMM2.259 JDIMM3.257 JDIMM3.259 JDIMM4.257 JDIMM4.259 PJP401.2
+2.5V_MEMP: PC402.1 PC403.1 PC404.1 PJP401.1 PL400.2 PR404.1
+2.5VSP_ON: PC401.1 PR401.1 PR402.1 PU400.7
+2.8V_FHV: RH287.2 UH1.AL22
+3.3V_1.8V_AZIO: CH269.1 RH292.2 RH295.2 UH1.BA15
+3.3V_1.8V_FUSE: RH300.2 UH1.BD3 UH1.BE3 UH1.BE4
+3.3V_1.8V_GPPA: RH291.2 RH294.2 UH1.BA31
+3.3V_1.8V_GPPD: RH293.2 RH296.2 UH1.BA45 UH1.BB45 UH1.BC44 UH1.BC45
+3.3V_1.8V_SPI: RH246.2 RH250.2 RH348.2 UH1.BE41 UH1.BE42 UH1.BE43
+3.3V_ALW: C90.1 C92.1 C723.1 C726.1 C778.1 C787.1 C1414.1 C1421.1 C1430.1 C1471.1 CH17.1 CZ4.1 CZ12.1 CZ15.1 JAPS1.3 JAPS1.7 JIO1.62 JIO2.38 JIO2.40 JIO2.42 JIO2.44 JIO2.46 JKBTP1.15 JPB1.4 JUSH1.11 JUSH1.12 JUSH1.13 PC151.2 PC310.1 PC506.1 PC1807.1 PJP12.1 PJP13.1 PJP100.2 PJP101.2 PJP400.1 PJP900.1 PR2.1 PR8.2 PR107.2 PR209.1 PR306.1 PR315.1 PR400.1 PR500.2 PR509.1 PR511.2 PR512.1 PR740.2 PR757.2 PR758.1 PR760.1 PR800.2 PR1025.2 PR1800.2 PR1810.1 PR1811.2 PR1812.1 PU105.5 PU300.7 PU500.10 PU1800.10 R11.1 R396.1 R415.1 R755.1 R759.1 R763.1 R773.1 R779.1 R800.1 R805.1 R814.1 R817.1 R822.1 R829.1 R835.1 R837.1 R838.1 R841.1 R847.1 R848.1 R849.1 R850.1 R858.1 R859.1 R860.1 R861.1 R864.1 R872.1 R875.1 R932.1 R1981.1 R2158.1 R3740.2 R3754.1 RC241.1 RE14.1 RE68.1 RE69.1 RE70.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE76.1 RE77.1 RH276.1 RH301.1 RP5.1 RP5.2 RP5.3 RP5.4 RP9.1 RP9.2 RP9.3 RP9.4 U9.5 U16.5 U17.5 U33.5 U58.5 U637.1 UC1.5 UC4.5 UC5.5 UC6.5 UC7.5 UZ20.6 UZ20.7 UZ21.1 UZ21.2 UZ24.1 UZ24.2 UZ25.1 UZ25.2 UZ25.6 UZ25.7 UZ26.6 UZ26.7 UZ27.1 UZ27.2 UZ28.1 UZ28.2
+3.3V_ALW2: JIO2.48 PC100.2 PQ1072.3 PR103.2 PR1013.1 PR1022.1 PR1099.1 PU101.3 R874.2 RZ70.1
+3.3V_ALW2_R: JUSH1.25 RZ70.2
+3.3V_ALW_PCH: JAPS1.1 PJP2.1 PJP15.1 R3728.1 RC74.2 RC75.2 RC76.2 RC133.2 RC316.2 RH56.1 RH65.1 RH67.1 RH77.1 RH78.1 RH80.1 RH81.1 RH86.1 RH95.2 RH128.2 RH203.2 RH204.2 RH279.1 RH298.1 RH299.1 RH300.1 RH303.1 RH304.1 RH305.1 RH306.1 RH309.1 RH310.2 RH311.1 RH327.2 RH329.2 RH341.1 RH343.2 RH345.1 RH349.1 RH351.1 RH352.1 RPH6.5 RPH6.6 RPH6.7 RPH6.8
+3.3V_ALW_PCH_PWR: C1445.1 PJP15.2 UZ27.7 UZ27.8
+3.3V_ALW_PCHRES: RH246.1 RH279.2 RH291.1 RH292.1 RH293.1
+3.3V_ALW_U46: C708.1 C709.1 C710.1 C717.1 C718.1 C719.1 PJP12.2 U46.A17 U46.A43 U46.A54 U46.B5 U46.B30
+3.3V_ALW_U51: C777.1 C780.1 C781.1 C782.1 C1345.1 C1348.1 C1355.1 PJP13.2 R834.1 R845.1 U51.A11 U51.A26 U51.A41 U51.A52 U51.B3 U51.B35
+3.3V_DSW: RH92.2 RH93.2 RH94.2 RH301.2 RH306.2 RH338.2 UH1.BA24
+3.3V_HDD: CN67.1 CN71.1 CN73.1 CN75.1 PJP3.2 PJP5.1 RN50.1 RN52.1 RN54.1 RN59.1 RN61.1 RN62.1 RN78.1 RN79.1 RN99.1 RN104.1 RN108.1 RN109.1 RN110.1 RN114.1 RN115.1 RN116.1 RN121.1 RN122.1 RN123.1 RN127.1 RN129.1 RN130.1 UN8.12 UN8.24 UN9.12 UN9.24
+3.3V_HDD1: C403.1 C404.1 JSATA2.27 JSATA2.28 JSATA2.29 JSATA2.30 PJP5.2 R3753.1
+3.3V_LAN: C472.1 C473.1 C474.1 C478.1 C481.1 C483.1 C1167.1 C1178.1 C1418.1 JLOM1.9 JLOM1.12 PJP11.1 R209.2 R377.1 R378.1 R545.1 R546.1 R549.1 R553.1 R554.1 R559.2 U15.5 U32.1 U32.4 U32.8 U32.14 U32.21 U32.30 U32.39
+3.3V_LAN_OUT: C464.1 R209.1 U31.4 U31.5 U31.15 U31.19 U31.29
+3.3V_LAN_PWR: PJP11.2 UZ25.8 UZ25.9
+3.3V_M: PJP19.1 RH344.2 RH348.1 RZ75.2
+3.3V_M_PWR: C513.1 PJP19.2 UZ28.7 UZ28.8
+3.3V_M_TPM: CZ6.1 CZ7.1 CZ8.1 PJP2.2 QZ2.3 RZ69.1 RZ75.1 RZ78.1 U637.14 U637.22
+3.3V_MXM: C8.1 C94.1 C332.1 JMXM1.268 JMXM1.270 JMXM1.306 JMXM1.308 PJP21.1 Q295.2 Q295.5 R1.1 R2.1 R3.1 R4.1 R5.1 R10.1 R37.1 R71.1 R1977.1 R1978.1 U14.5 U25.5 U27.5
+3.3V_MXM_PWR: C764.1 PJP21.2 UZ26.8 UZ26.9
+3.3V_PGPPBCH: CH63.1 RH61.1 RH304.2 UH1.BC42 UH1.BD40
+3.3V_PGPPEF: CH62.1 RH303.2 UH1.AJ41 UH1.AL41
+3.3V_PGPPG: CH64.1 RH305.2 UH1.AD41
+3.3V_PHVC: CH66.1 RH299.2 UH1.AN5
+3.3V_PRTC: CH33.1 CH65.1 RH297.2 UH1.BA22
+3.3V_PRTCPRIM: CH37.1 CH67.1 RH298.2 UH1.BA20
+3.3V_PUSBDSW: CH31.1 RH276.2 UH1.W15
+3.3V_RTC_LDO: PD1.3 PR103.1
+3.3V_RUN: C31.1 C32.1 C33.1 C34.1 C248.1 C301.1 C391.1 C392.1 C494.1 C495.1 C496.1 C497.1 C499.1 C500.1 C501.1 C502.1 C503.1 C504.1 C505.1 C506.1 C507.1 C508.1 C509.1 C554.1 C722.1 C725.1 C783.1 C784.1 C785.1 C786.1 CH10.1 CV27.1 CV28.1 CV29.1 CV30.1 CV31.1 CZ11.1 JDEG3.1 JEDP1.10 JIO1.64 JIO1.66 JIO1.68 JIO1.70 JIO1.72 JIO2.50 JIO2.52 JLPDE1.1 JLPDE1.2 JUSH1.8 PJP3.1 PJP14.1 PJP23.1 PR1114.1 Q24.3 Q343.3 Q343.6 Q366.2 Q366.5 Q369.3 Q369.6 QH4.2 QH4.5 R98.2 R99.2 R100.2 R102.2 R104.2 R105.2 R107.2 R109.2 R117.2 R118.2 R119.2 R120.2 R124.2 R125.2 R126.2 R127.2 R133.2 R140.2 R142.2 R143.2 R149.2 R151.2 R152.2 R153.2 R154.2 R159.2 R161.2 R162.2 R339.1 R363.2 R379.1 R381.2 R382.1 R383.1 R387.1 R403.1 R405.1 R407.1 R408.1 R409.1 R410.1 R413.1 R426.1 R501.1 R502.1 R503.1 R504.1 R513.1 R722.1 R782.2 R783.2 R2194.1 R2195.1 R2196.1 R2197.1 R2198.1 R3736.1 R3737.1 R3738.1 R3739.1 R3744.1 RC79.2 RD8.1 RD13.1 RD17.1 RD19.1 RD20.1 RD26.1 RD27.1 RD37.1 RD38.1 RD51.1 RD52.1 RD53.1 RD57.1 RD58.1 RD59.1 RD60.1 RD61.1 RE67.1 RH71.1 RH76.1 RH79.1 RH90.1 RH91.1 RH124.2 RH125.2 RH126.2 RH127.2 RH131.2 RH132.2 RH133.2 RH199.2 RH202.2 RH207.1 RH213.2 RH220.2 RH221.2 RH222.2 RH223.2 RH224.2 RH225.2 RH302.1 RH317.1 RH318.1 RH319.1 RH321.1 RH331.1 RH339.1 RH340.2 RH347.2 RH350.1 RH354.1 RH355.1 RP3.1 RP3.2 RP3.3 RP3.4 RV29.1 RV30.1 RV31.1 RV32.1 RV33.1 RV34.1 RV42.1 RV43.1 RV44.1 RV47.1 RV49.1 RZ77.1 RZ79.1 U3.5 U8.19 U8.34 U8.35 U88.2 U88.3 U88.9 U88.10 U629.21 U629.26 U629.35 U629.49 U629.60 U630.21 U630.26 U630.35 U630.49 U630.60 U631.21 U631.26 U631.35 U631.49 U631.60 U636.21 U636.26 U636.35 U636.49 U636.60 U639.5 UC3.5 UV2.5 UV2.21 UV2.30 UV2.51 UV2.57
+3.3V_RUN_ATS: CH36.1 RH302.2 UH1.AD13
+3.3V_RUN_DIMM1: CD21.1 CD22.1 JDIMM1.255 RD57.2
+3.3V_RUN_DIMM2: CD26.1 CD29.1 JDIMM2.255 RD58.2
+3.3V_RUN_DIMM3: CD44.1 CD47.1 JDIMM3.255 RD59.2
+3.3V_RUN_DIMM4: CD62.1 CD65.1 JDIMM4.255 RD60.2
+3.3V_RUN_PWR: C450.1 PJP23.2 UZ20.8 UZ20.9
+3.3V_SPI: C746.1 C1216.1 JSPI1.15 R3664.1 R3665.1 R3666.1 R3668.1 RC5.1 RH185.2 RH335.2 U52.8 U53.8
+3.3V_SPI_PWR: JSPI1.16 RH185.1 RH343.1 RH344.1
+3.3V_SSD1: C617.1 C618.1 C619.1 C621.1 C622.1 C623.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.62 JNGFF3.64 JNGFF3.66 PJP9.1 R385.1
+3.3V_SSD1_PWR: C400.1 PJP9.2 UZ21.7 UZ21.8
+3.3V_TP: C1410.1 JKBTP1.9 PJP14.2 RZ18.1 RZ19.1 RZ36.1 RZ37.1 RZ116.1 RZ117.1
+3.3V_VTR: C739.1 C1349.1 R834.2 U51.A22
+3.3V_WLAN: C603.1 C604.1 C605.1 C606.2 C607.2 C608.1 C1402.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 PJP10.1
+3.3V_WLAN_PWR: C536.1 PJP10.2 UZ25.13 UZ25.14
+3.3V_WWAN: C610.1 C611.1 C612.1 C613.1 C614.1 C615.1 C762.1 C1176.1 CZ93.1 CZ94.1 JNGFF2.2 JNGFF2.4 JNGFF2.62 JNGFF2.64 JNGFF2.66 PJP25.1 R384.1 RZ3.1 UZ29.1 UZ29.6 UZ29.10
+3.3V_WWAN_PWR: PJP25.2 UZ24.7 UZ24.8
+3VALWP: PC120.1 PJP100.1 PJP101.1 PL101.1 PR100.1
+5V_ALW: C6.1 C721.1 C724.1 C1431.1 CZ86.1 CZ89.1 CZ96.1 JIO1.78 JIO1.80 JIO1.82 JIO1.84 JIO1.86 JIO1.88 JIO1.90 JIO1.92 JIO1.94 JIO1.96 JIO1.98 JIO1.100 JIO2.35 JIO2.37 JIO2.39 JIO2.41 JIO2.43 JIO2.45 JIO2.47 JIO2.49 JIO2.51 JIO2.53 JLED1.1 JPB1.2 JUART1.1 JUSH1.9 PC805.1 PC900.1 PC1212.1 PC1213.1 PC1258.1 PC1412.1 PC1413.1 PC1458.1 PC1611.1 PC1704.1 PJP102.2 PJP103.2 PR11.1 PR203.1 PR210.2 PR1012.2 PR1151.1 PR1169.1 PR1170.1 PR1200.2 PR1203.2 PR1209.2 PR1400.2 PR1403.2 PR1409.2 PR1603.2 PR1606.2 PR1700.2 PU1.5 PU800.7 PU900.6 PU1200.3 PU1200.7 PU1200.31 PU1201.3 PU1201.7 PU1201.31 PU1202.3 PU1202.7 PU1202.31 PU1400.3 PU1400.7 PU1400.31 PU1401.3 PU1401.7 PU1401.31 PU1402.3 PU1402.7 PU1402.31 PU1600.27 PU1700.7 PU1700.31 Q86.3 UZ18.3 UZ19.3 UZ20.1 UZ20.2 UZ20.4 UZ21.4 UZ22.4 UZ23.4 UZ24.4 UZ25.4 UZ26.1 UZ26.2 UZ26.4 UZ27.4 UZ28.4 UZ30.3
+5V_ALW2: PC118.1 PU101.13 RZ72.1
+5V_ALW2_R: JUSH1.10 RZ72.2
+5V_HDD: C5.1 C395.1 C406.1 JSATA2.23 JSATA2.24 JSATA2.25 PJP4.2 R506.1
+5V_MXM: C7.1 C328.1 JMXM1.37 JMXM1.39 JMXM1.41 JMXM1.43 JMXM1.45 PJP20.1
+5V_MXM_PWR: C357.1 PJP20.2 UZ26.13 UZ26.14
+5V_RUN: C30.1 C310.1 C330.1 C364.1 C370.1 C763.1 C766.1 C1411.1 CZ10.1 JFAN1.1 JFAN2.1 JIO1.95 JIO1.97 JIO1.99 JIO2.55 JIO2.57 JKBTP1.16 JTS1.6 JUSH1.7 PJP4.1 PJP22.1 R721.1 R2189.1 R3746.1 RP6.1 RP6.2 RP6.3 RP6.4
+5V_RUN_PWR: C514.1 PJP22.2 UZ20.13 UZ20.14
+5VALWP: PC121.1 PJP102.1 PJP103.1 PL102.2 PR101.2 PU101.14
+V0.95SP_B+: PC300.1 PC303.1 PC311.1 PJP301.2 PU300.8
+VBUS_DC_SS: JIO2.17 PD702.3 PD704.2 PD1101.2 PD1103.2 PR768.1 PR1034.1
+VCC_CORE: CPU1.AA13 CPU1.AA31 CPU1.AA32 CPU1.AA33 CPU1.AA34 CPU1.AA35 CPU1.AA36 CPU1.AA37 CPU1.AA38 CPU1.AB29 CPU1.AB30 CPU1.AB31 CPU1.AB32 CPU1.AB35 CPU1.AB36 CPU1.AB37 CPU1.AB38 CPU1.AC13 CPU1.AC14 CPU1.AC29 CPU1.AC30 CPU1.AC31 CPU1.AC32 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AC36 CPU1.AD13 CPU1.AD14 CPU1.AD31 CPU1.AD32 CPU1.AD33 CPU1.AD34 CPU1.AD35 CPU1.AD36 CPU1.AD37 CPU1.AD38 CPU1.AE13 CPU1.AE14 CPU1.AE30 CPU1.AE31 CPU1.AE32 CPU1.AE35 CPU1.AE36 CPU1.AE37 CPU1.AE38 CPU1.AF35 CPU1.AF36 CPU1.AF37 CPU1.AF38 CPU1.K13 CPU1.K14 CPU1.L13 CPU1.L14 CPU1.N13 CPU1.N14 CPU1.N30 CPU1.N31 CPU1.N32 CPU1.N35 CPU1.N36 CPU1.N37 CPU1.N38 CPU1.P13 CPU1.P14 CPU1.P29 CPU1.P30 CPU1.P31 CPU1.P32 CPU1.P33 CPU1.P34 CPU1.P35 CPU1.P36 CPU1.R13 CPU1.R31 CPU1.R32 CPU1.R33 CPU1.R34 CPU1.R35 CPU1.R36 CPU1.R37 CPU1.R38 CPU1.T29 CPU1.T30 CPU1.T31 CPU1.T32 CPU1.T35 CPU1.T36 CPU1.T37 CPU1.T38 CPU1.U29 CPU1.U30 CPU1.U31 CPU1.U32 CPU1.U33 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.V13 CPU1.V14 CPU1.V31 CPU1.V32 CPU1.V33 CPU1.V34 CPU1.V35 CPU1.V36 CPU1.V37 CPU1.V38 CPU1.W13 CPU1.W14 CPU1.W29 CPU1.W30 CPU1.W31 CPU1.W32 CPU1.W35 CPU1.W36 CPU1.W37 CPU1.W38 CPU1.Y29 CPU1.Y30 CPU1.Y31 CPU1.Y32 CPU1.Y33 CPU1.Y34 CPU1.Y35 CPU1.Y36 PC1220.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PC1225.1 PC1226.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1233.1 PC1234.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1243.1 PC1244.1 PC1245.1 PC1246.1 PC1247.1 PC1248.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1255.1 PC1256.1 PC1257.1 PC1259.1 PC1260.1 PC1261.1 PC1262.1 PC1263.1 PC1264.1 PC1265.1 PC1266.1 PC1267.1 PC1268.1 PC1270.1 PC1271.1 PC1272.1 PC1273.1 PC1274.1 PC1275.1 PC1276.1 PC1277.1 PC1278.1 PC1279.1 PC1280.1 PC1281.1 PC1282.1 PC1283.1 PC1284.1 PC1285.1 PC1286.1 PC1287.1 PC1288.1 PC1289.1 PC1290.1 PC1291.1 PC1292.1 PC1293.1 PC1294.1 PC1295.1 PC1296.1 PC1297.1 PC1298.1 PC1299.1 PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PC1305.1 PC1306.1 PC1307.1 PC1308.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PL1200.4 PL1201.4 PL1202.4 PR1119.1
+VCC_EDRAM: CC175.1 CC176.1 CC177.1 CC178.1 CC179.1 CC180.1 CC181.1 CC182.1 CC183.1 CC184.1 CPU1.BJ17 CPU1.BJ19 CPU1.BJ20 CPU1.BK17 CPU1.BK19 CPU1.BK20 CPU1.BL16 CPU1.BL17 CPU1.BL18 CPU1.BL19 CPU1.BL20 CPU1.BL21 CPU1.BM17 CPU1.BN17 PJP500.2
+VCC_EDRAM_ED2: CPU1.BJ23 CPU1.BJ26 CPU1.BJ27 CPU1.BK23 CPU1.BK26 CPU1.BK27 CPU1.BL23 CPU1.BL24 CPU1.BL25 CPU1.BL26 CPU1.BL27 CPU1.BL28 CPU1.BM24 RC173.1
+VCC_EDRAM_FUSEPRG: CPU1.BL14 RH253.2
+VCC_EDRAM_FUSEPRG_ED2: CPU1.BJ36 RC226.1
+VCC_EDRAM_P: PC502.1 PC503.1 PC504.1 PJP500.1 PL501.2 PR505.1
+VCC_EOPIO: CC169.1 CC173.1 CC174.1 CPU1.BP15 CPU1.BR15 CPU1.BT15 PJP1800.2
+VCC_EOPIO_ED2: CPU1.BP16 CPU1.BR16 CPU1.BT16 RC175.2
+VCC_EOPIO_P: PC1802.1 PC1803.1 PC1804.1 PJP1800.1 PL1801.2 PR1805.1
