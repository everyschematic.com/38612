# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RD44  1K_0402_5%  [R_0402]  132.12 6.18 180 top
RD45  2_0402_1%  [R_0402]  139.68 56.23 270 top
RD46  1K_0402_5%  [R_0402]  105.61 53.24 90 top
RD47  1K_0402_5%  [R_0402]  106.5 54.16 270 top
RD51  0_0402_5%  [R_0402]  115.66 90.71 270 bottom
RD52  0_0402_5%  [R0402_0OHM]  113.82 90.71 270 bottom
RD53  0_0402_5%  [R_0402]  114.77 90.71 270 bottom
RD54  0_0402_5%  [R0402_0OHM]  116.55 89.8 90 bottom
RD55  0_0402_5%  [R0402_0OHM]  114.76 88.92 0 bottom
RD56  0_0402_5%  [R_0402]  113.83 88.92 180 bottom
RD57  0_0603_5%  [R0603_0OHM]  133.65 89.56 0 top
RD58  0_0603_5%  [R0603_0OHM]  124.99 90.44 270 bottom
RD59  0_0603_5%  [R0603_0OHM]  119.8 5.1 0 top
RD60  0_0603_5%  [R0603_0OHM]  106.37 90.52 0 bottom
RD61  330K_0402_5%  [R_0402]  47.13 9.8 0 top
RE1  33_0402_5%  [R_0402]  175.7 118.89 180 bottom
RE11  10_0402_1%  [R_0402]  180.68 147.52 90 top
RE12  10_0402_1%  [R_0402]  177.63 147.52 90 top
RE14  100K_0402_5%  [R_0402]  170.65 108.67 0 bottom
RE67  10K_0402_5%  [R_0402]  212.07 104.31 90 bottom
RE68  100K_0402_5%  [R_0402]  216.42 106.34 270 bottom
RE69  100K_0402_5%  [R_0402]  178.24 109.39 270 top
RE70  100K_0402_5%  [R_0402]  183.01 106.09 270 top
RE71  100K_0402_5%  [R_0402]  180.18 118.19 0 top
RE72  100K_0402_5%  [R_0402]  179.84 119.08 180 top
RE73  100K_0402_5%  [R_0402]  175.75 105.23 90 top
RE74  100K_0402_5%  [R_0402]  181.94 112.29 90 top
RE75  100K_0402_5%  [R_0402]  182.02 115.27 90 top
RE76  100K_0402_5%  [R_0402]  181.14 115.27 90 top
RE77  100K_0402_5%  [R_0402]  175.58 112.45 180 top
RH38  30_0402_5%  [R_0402]  144.92 118.97 180 top
RH39  30_0402_5%  [R_0402]  144.92 118.08 180 top
RH42  30_0402_5%  [R_0402]  141.45 117.67 0 top
RH43  0_0402_5%  [R0402_0OHM]  134.01 135.6 270 top
RH44  10M_0402_5%  [R_0402]  134.01 133.82 270 top
RH45  33_0402_5%  [R_0402]  145.47 130.07 180 top
RH46  33_0402_5%  [R_0402]  139.95 125.75 180 top
RH48  33_0402_5%  [R_0402]  145.47 132.04 180 top
RH50  33_0402_5%  [R_0402]  145.47 131.02 180 top
RH56  1K_0402_5%  [R_0402]  105.65 127.23 0 top
RH61  4.7K_0402_5%  [R_0402]  113.27 123.86 0 bottom
RH65  1K_0402_5%  [R_0402]  105.65 128.12 0 top
RH66  0_0402_5%  [R0402_0OHM]  141.79 124.64 270 top
RH67  499_0402_1%  [R_0402]  105.65 125.45 0 top
RH70  8.2K_0402_5%  [R_0402]  143.68 127.3 180 top
RH71  10K_0402_5%  [R_0402]  107.32 118.41 0 top
RH73  43_0402_1%  [R_0402]  142.36 115.89 180 top
RH74  10K_0402_5%  [R_0402]  141.45 116.78 0 top
RH75  620_0402_5%  [R_0402]  141.45 115.01 0 top
RH76  10K_0402_5%  [R_0402]  105.87 112.67 0 bottom
RH77  499_0402_1%  [R_0402]  105.65 126.34 0 top
RH78  4.7K_0402_5%  [R_0402]  105.44 124.3 0 bottom
RH79  10K_0402_5%  [R_0402]  120.88 128.37 270 bottom
RH80  1K_0402_5%  [R_0402]  105.65 124.5 0 top
RH81  1K_0402_5%  [R_0402]  105.65 123.61 0 top
RH83  1K_0402_5%  [R_0402]  130.17 118.32 180 bottom
RH84  0_0402_5%  [R_0402]  126.09 127.2 90 top
RH85  0_0402_5%  [R0402_0OHM]  127.11 126.82 90 top
RH86  4.7K_0402_5%  [R_0402]  120.77 128.13 270 top
RH90  10K_0402_5%  [R_0402]  106.33 108.92 0 bottom
RH91  10K_0402_5%  [R_0402]  106.52 107.27 0 top
RH92  1K_0402_5%  [R_0402]  130.03 129.48 90 bottom
RH93  10K_0402_5%  [R_0402]  129.14 129.48 90 bottom
RH94  8.2K_0402_5%  [R_0402]  128.24 129.47 90 bottom
RH95  10K_0402_5%  [R_0402]  125.22 129.69 90 bottom
RH96  22_0402_5%  [R_0402]  130.74 131.5 90 bottom
RH97  22_0402_5%  [R_0402]  131.63 131.5 90 bottom
RH98  22_0402_5%  [R_0402]  129.47 131.53 90 bottom
RH99  22_0402_5%  [R_0402]  128.59 131.53 90 bottom
RH124  10K_0402_5%  [R_0402]  124.33 127.21 90 top
RH125  10K_0402_5%  [R_0402]  125.22 127.21 90 top
RH126  10K_0402_5%  [R_0402]  121.66 127.21 90 top
RH127  10K_0402_5%  [R_0402]  123.44 127.21 90 top
RH128  10K_0402_5%  [R_0402]  110.86 131.78 180 bottom
RH131  10K_0402_5%  [R_0402]  122.55 127.21 90 top
RH132  10K_0402_5%  [R_0402]  118.55 127.21 90 top
RH133  10K_0402_5%  [R_0402]  119.44 127.21 90 top
RH152  0_0402_5%  [R0402_0OHM]  138.08 100.42 90 top
RH153  1M_0402_1%  [R_0402]  138.09 99.58 270 top
RH154  0_0402_5%  [R0402_0OHM]  138.02 108.4 0 top
RH155  0_0402_5%  [R0402_0OHM]  138.02 109.29 0 top
RH161  0_0402_5%  [R0402_0OHM]  140.97 104.85 180 top
RH166  0_0402_5%  [R0402_0OHM]  140.97 105.73 180 top
RH167  0_0402_5%  [R0402_0OHM]  139.99 107.7 0 top
RH168  0_0402_5%  [R0402_0OHM]  139.99 106.81 0 top
RH169  0_0402_5%  [R0402_0OHM]  138.93 104.08 180 top
RH170  0_0402_5%  [R0402_0OHM]  138.93 103.19 180 top
RH171  2.7K_0402_1%  [R_0402]  138.93 102.32 180 top
RH177  0_0402_5%  [R_0402]  157.24 122.35 270 bottom
RH178  0_0402_5%  [R_0402]  158.32 122.35 270 bottom
RH179  0_0402_5%  [R_0402]  159.52 122.35 270 bottom
RH180  0_0402_5%  [R0402_0OHM]  119.69 124.71 270 bottom
RH181  0_0402_5%  [R_0402]  160.6 122.35 270 bottom
RH182  0_0402_5%  [R_0402]  161.68 122.35 270 bottom
RH183  0_0402_5%  [R_0402]  162.76 122.35 270 bottom
RH184  0_0402_5%  [R_0402]  163.84 122.35 270 bottom
RH185  0_0402_5%  [R0402_0OHM]  165.76 122.34 180 bottom
RH187  0_0402_5%  [R_0402]  187.43 132.4 90 bottom
RH192  100_0402_1%  [R_0402]  126.72 99.16 270 top
RH193  113_0402_1%  [R_0402]  138.87 114.7 180 top
RH194  0_0402_5%  [R0402_0OHM]  186.47 131.34 0 bottom
RH195  0_0402_5%  [R0402_0OHM]  186.54 132.4 90 bottom
RH196  100K_0402_5%  [R_0402]  106.35 123.06 180 bottom
RH197  0_0402_5%  [R0402_0OHM]  106.43 122.14 270 bottom
RH198  330K_0402_5%  [R_0402]  130.67 130.39 180 top
RH199  100K_0402_5%  [R_0402]  138.03 123.92 0 top
RH200  20K_0402_5%  [R_0402]  133.7 130.45 0 bottom
RH201  20K_0402_5%  [R_0402]  133.39 131.52 180 bottom
RH202  8.2K_0402_5%  [R_0402]  138.03 124.81 0 top
RH203  10K_0402_5%  [R_0402]  121.64 129.23 90 top
RH204  10K_0402_5%  [R_0402]  123.68 129.62 135 top
RH207  100K_0402_5%  [R_0402]  113.42 119.83 0 bottom
RH210  0_0402_5%  [R_0402]  106.46 118.16 180 bottom
RH211  0_0402_5%  [R0402_0OHM]  106.45 120.16 180 bottom
RH212  0_0402_5%  [R0402_0OHM]  105.52 122.14 270 bottom
RH213  10K_0402_5%  [R_0402]  139.87 124.87 270 top
RH214  100K_0402_5%  [R_0402]  109.72 108.86 180 top
RH215  0_0402_5%  [R_0402]  131.5 122.45 180 bottom
RH220  2.2K_0402_5%  [R_0402]  107.9 131.16 180 bottom
RH221  2.2K_0402_5%  [R_0402]  107.9 132.05 180 bottom
RH222  2.2K_0402_5%  [R_0402]  134.85 123.51 90 bottom
RH223  2.2K_0402_5%  [R_0402]  133.84 123.51 90 bottom
RH224  2.2K_0402_5%  [R_0402]  134.14 126.39 0 bottom
RH225  2.2K_0402_5%  [R_0402]  134.14 127.27 0 bottom
RH238  0_0603_5%  [R_0603]  140.14 118.08 180 bottom
RH239  0_0603_5%  [R_0603]  136.01 118.34 180 bottom
RH240  0_0603_5%  [R_0603]  135.74 117.11 180 bottom
RH241  0_0603_5%  [R0603_0OHM]  132.46 98.93 270 top
RH246  0_0603_5%  [R_0603]  113.28 128.31 270 bottom
RH247  0_0603_5%  [R0603_0OHM]  137.96 131.34 270 bottom
RH250  0_0603_5%  [R_0603]  112.08 128.31 270 bottom
RH252  0_0603_5%  [R0603_0OHM]  175.78 13.38 0 bottom
RH253  0_0603_5%  [R0603_0OHM]  175.78 14.58 0 bottom
RH254  0_1206_5%  [R_1206]  109.33 109.75 270 bottom
RH255  0_0402_5%  [R_0402]  141.3 127.29 180 bottom
RH256  0_0402_5%  [R0402_0OHM]  137.36 109.51 180 bottom
RH257  0_0402_5%  [R0402_0OHM]  137.36 110.4 180 bottom
RH258  0_0402_5%  [R0402_0OHM]  137.36 111.29 180 bottom
RH259  0_0402_5%  [R0402_0OHM]  137.36 112.18 180 bottom
RH260  0_0402_5%  [R0402_0OHM]  138.35 109.51 0 bottom
RH276  0_0603_5%  [R0603_0OHM]  110.21 98.7 0 top
RH279  0_0603_5%  [R0603_0OHM]  109.83 129.81 0 bottom
RH286  0_0402_5%  [R0402_0OHM]  141.3 126.34 180 bottom
RH287  0_0402_5%  [R0402_0OHM]  142.16 127.29 0 bottom
RH288  0_0402_5%  [R0402_0OHM]  137.36 113.07 180 bottom
RH289  0_0402_5%  [R0402_0OHM]  109.06 103.65 0 top
RH290  0_0402_5%  [R0402_0OHM]  112.98 107.62 0 bottom
RH291  0_0402_5%  [R0402_0OHM]  116.9 130.1 270 bottom
RH292  0_0402_5%  [R0402_0OHM]  135.51 130.7 270 bottom
RH293  0_0402_5%  [R0402_0OHM]  108.38 125.45 0 top
RH294  0_0402_5%  [R_0402]  117.79 130.1 270 bottom
RH295  0_0402_5%  [R_0402]  136.4 130.7 270 bottom
RH296  0_0402_5%  [R_0402]  108.38 124.56 0 top
RH297  0_0402_5%  [R0402_0OHM]  124.27 130.6 270 bottom
RH298  0_0402_5%  [R0402_0OHM]  126.17 130.6 270 bottom
RH299  0_0402_5%  [R0402_0OHM]  135.52 119.42 180 bottom
RH300  0_0402_5%  [R0402_0OHM]  137.09 127.15 180 bottom
RH301  0_0603_5%  [R0603_0OHM]  120.7 130.69 270 bottom
RH302  0_0402_5%  [R0402_0OHM]  134.43 114.48 270 bottom
RH303  0_0402_5%  [R0402_0OHM]  114.81 116.09 90 bottom
RH304  0_0402_5%  [R0402_0OHM]  111.49 122.97 0 bottom
RH305  0_0402_5%  [R0402_0OHM]  110.92 114.08 0 bottom
RH306  0_0402_5%  [R_0402]  121.74 130.5 270 bottom
RH308  100K_0402_5%  [R_0402]  133.16 126.39 90 bottom
RH309  10K_0402_5%  [R_0402]  107.34 117.42 0 top
RH310  10K_0402_5%  [R_0402]  109.15 115.65 180 top
RH311  8.2K_0402_5%  [R_0402]  109.95 130.89 0 bottom
RH312  51_0402_5%  [R_0402]  140.83 121.56 180 bottom
RH313  51_0402_5%  [R_0402]  141.39 120.87 270 top
RH314  51_0402_5%  [R_0402]  140.07 120.67 180 bottom
RH315  51_0402_5%  [R_0402]  140.07 119.78 180 bottom
RH317  10K_0402_5%  [R_0402]  106.52 106.38 0 top
RH318  10K_0402_5%  [R_0402]  105.9 113.7 0 bottom
RH319  10K_0402_5%  [R_0402]  142.28 117.7 270 bottom
RH321  10K_0402_5%  [R_0402]  5.5 52.2 0 top
RH322  10K_0402_5%  [R_0402]  107.85 111.27 0 top
RH323  10K_0402_5%  [R_0402]  118.58 117.27 270 bottom
RH324  10K_0402_5%  [R_0402]  39.6 20.82 180 top
RH325  10K_0402_5%  [R_0402]  118.02 113.34 180 bottom
RH326  10K_0402_5%  [R_0402]  110.02 113.06 270 top
RH327  10K_0402_5%  [R_0402]  125.66 129.81 180 top
RH328  1K_0402_5%  [R_0402]  145.47 129.18 180 top
RH329  150K_0402_5%  [R_0402]  111.64 131.21 180 top
RH331  4.7K_0402_5%  [R_0402]  119.94 128.37 270 bottom
RH334  1K_0402_5%  [R_0402]  116.63 127.07 90 top
RH335  1K_0402_5%  [R_0402]  164.52 126.58 180 top
RH337  0_0402_5%  [R0402_0OHM]  109.33 122.22 270 top
RH338  100K_0402_5%  [R_0402]  130.01 128.54 0 bottom
RH339  10K_0402_5%  [R_0402]  118.72 129.13 270 bottom
RH340  10K_0402_5%  [R_0402]  132.44 123.51 90 bottom
RH341  10K_0402_5%  [R_0402]  107.36 109.89 270 top
RH342  0_0402_5%  [R_0402]  108.81 109.81 0 top
RH343  0_0402_5%  [R_0402]  166.7 121.28 270 bottom
RH344  0_0402_5%  [R_0402]  165.79 121.28 270 bottom
RH345  10K_0402_5%  [R_0402]  123.13 130.6 270 bottom
RH346  0_0402_5%  [R0402_0OHM]  109.05 123.16 180 top
RH347  150K_0402_5%  [R_0402]  113.44 132.1 180 top
RH348  0_0603_5%  [R_0603]  112.43 125.83 0 bottom
RH349  0_0402_5%  [R_0402]  104.75 120.8 0 top
RH350  0_0402_5%  [R_0402]  105.69 118.38 180 top
RH351  49.9K_0402_1%  [R_0402]  112.07 115.17 90 bottom
RH352  49.9K_0402_1%  [R_0402]  113.48 115.64 90 bottom
RH353  0_0402_5%  [R_0402]  112.53 131.21 0 top
RH354  49.9K_0402_1%  [R_0402]  112.68 118.89 0 bottom
RH355  49.9K_0402_1%  [R_0402]  111.08 120.04 270 bottom
RH356  1K_0402_5%  [R_0402]  129.28 115.97 180 bottom
RH357  0_0402_5%  [R0402_0OHM]  137.08 114.62 90 top
RH358  10K_0402_5%  [R_0402]  110.93 116.73 180 top
RH359  0_0402_5%  [R_0402]  170.35 117.23 90 bottom
RN50  10K_0402_5%  [R_0402]  22.08 33.4 0 top
RN51  10K_0402_5%  [R_0402]  30.59 24.73 0 top
RN52  10K_0402_5%  [R_0402]  24.36 24.29 90 top
RN53  4.99K_0402_1%  [R_0402]  21.44 29.99 180 top
RN54  10K_0402_5%  [R_0402]  24.82 33.85 270 top
RN55  10K_0402_5%  [R_0402]  33.33 28.37 270 top
RN57  10K_0402_5%  [R_0402]  43.77 29.99 90 top
RN58  4.99K_0402_1%  [R_0402]  32.41 29 270 top
RN59  10K_0402_5%  [R_0402]  33.95 33.12 270 top
RN60  10K_0402_5%  [R_0402]  21.52 27.5 270 top
RN61  10K_0402_5%  [R_0402]  32.72 34.11 270 top
RN62  10K_0402_5%  [R_0402]  33.68 24.68 0 top
RN78  10K_0402_5%  [R_0402]  22.08 35.17 0 top
RN79  10K_0402_5%  [R_0402]  33.61 34.08 0 top
RN99  10K_0402_5%  [R_0402]  22.08 32.51 0 top
RN100  10K_0402_5%  [R_0402]  22.99 31.62 180 top
RN101  10K_0402_5%  [R_0402]  22.99 34.28 180 top
RN102  10K_0402_5%  [R_0402]  23.45 25.2 270 top
RN103  10K_0402_5%  [R_0402]  23.93 32.94 90 top
RN104  10K_0402_5%  [R_0402]  29.67 23.95 90 top
RN105  10K_0402_5%  [R_0402]  28.81 24.86 270 top
RN106  10K_0402_5%  [R_0402]  30.18 31.16 0 top
RN107  10K_0402_5%  [R_0402]  30.18 28.49 0 top
RN108  10K_0402_5%  [R_0402]  31.09 30.27 180 top
RN109  10K_0402_5%  [R_0402]  31.09 29.38 180 top
RN110  10K_0402_5%  [R_0402]  21.62 25.06 0 top
RN111  10K_0402_5%  [R_0402]  22.53 24.18 180 top
RN114  10K_0402_5%  [R_0402]  22.41 26.59 90 top
RN115  10K_0402_5%  [R_0402]  30.26 27.63 270 top
RN116  10K_0402_5%  [R_0402]  31.81 34.11 270 top
RN117  10K_0402_5%  [R_0402]  32.24 31.34 270 top
RN118  10K_0402_5%  [R_0402]  33.15 31.34 270 top
RN119  10K_0402_5%  [R_0402]  35.51 25.19 270 top
RN120  10K_0402_5%  [R_0402]  34.07 31.36 270 top
RN121  10K_0402_5%  [R_0402]  42.37 32.81 180 top
RN122  10K_0402_5%  [R_0402]  42.8 31.87 180 top
RN123  10K_0402_5%  [R_0402]  42.75 29.48 180 top
RN124  10K_0402_5%  [R_0402]  41.84 28.62 0 top
RN125  10K_0402_5%  [R_0402]  41.46 33.7 0 top
RN126  10K_0402_5%  [R_0402]  41.89 31.01 0 top
RN127  10K_0402_5%  [R_0402]  31.5 27.15 0 top
RN128  10K_0402_5%  [R_0402]  32.34 25.65 180 top
RN129  10K_0402_5%  [R_0402]  34.19 27.45 90 top
RN130  10K_0402_5%  [R_0402]  44.71 28.98 90 top
RN131  0_0402_5%  [R_0402]  25.25 24.35 90 top
RN132  0_0402_5%  [R_0402]  26.14 24.35 90 top
RN133  0_0402_5%  [R_0402]  36.43 24.29 90 top
RN134  0_0402_5%  [R_0402]  37.32 24.29 90 top
RP3  100K_0804_8P4R_5%  [RP_0804_8P4R]  188.51 113.04 180 bottom
RP4  100K_0804_8P4R_5%  [RP_0804_8P4R]  171.18 114.88 180 bottom
RP5  2.2K_0804_8P4R_5%  [RP_0804_8P4R]  197.66 122.93 270 bottom
RP6  4.7K_0804_8P4R_5%  [RP_0804_8P4R]  192.44 119.98 270 top
RP7  100K_0804_8P4R_5%  [RP_0804_8P4R]  205.89 98.72 90 bottom
RP9  100K_0804_8P4R_5%  [RP_0804_8P4R]  188.54 110.04 180 bottom
RPH6  10K_0804_8P4R_5%  [RP_0804_8P4R]  106.99 113.18 180 top
RV28  1M_0402_5%  [R_0402]  155.05 117.48 90 top
RV29  4.7K_0402_5%  [R_0402]  158.42 110.28 90 top
RV30  4.7K_0402_5%  [R_0402]  167.74 117.72 180 top
RV31  4.7K_0402_5%  [R_0402]  167.74 116.7 180 top
RV32  4.7K_0402_5%  [R_0402]  167.74 115.69 180 top
RV33  4.7K_0402_5%  [R_0402]  167.74 114.67 180 top
RV34  4.7K_0402_5%  [R_0402]  165.19 112.59 180 bottom
RV35  4.7K_0402_5%  [R_0402]  158.39 113.2 90 top
RV36  4.7K_0402_5%  [R_0402]  164.29 117.72 0 top
RV37  4.7K_0402_5%  [R_0402]  164.29 115.69 0 top
RV38  4.7K_0402_5%  [R_0402]  164.29 116.7 0 top
RV39  4.7K_0402_5%  [R_0402]  164.29 114.67 0 top
RV40  4.7K_0402_5%  [R_0402]  164.27 113.61 0 bottom
RV41  4.99K_0402_1%  [R_0402]  152.04 110.55 270 bottom
RV42  4.7K_0402_5%  [R_0402]  165.69 112.8 180 top
RV43  4.7K_0402_5%  [R_0402]  153.06 109.64 90 bottom
RV44  4.7K_0402_5%  [R_0402]  163.15 111.02 90 top
RV45  1M_0402_5%  [R_0402]  158.86 117.42 90 top
RV46  0_0402_5%  [R_0402]  155.35 137.18 0 bottom
RV47  10K_0402_5%  [R_0402]  153.74 136.59 270 top
RV48  1M_0402_5%  [R_0402]  169.26 94.25 0 top
RV49  8.2K_0402_5%  [R_0402]  152.86 136.64 180 top
RZ3  0_0402_5%  [R0402_0OHM]  321.39 24.72 90 top
RZ10  1M_0402_5%  [R_0402]  64.73 44.86 270 top
RZ17  0_0402_5%  [R_0402]  191.62 133.89 270 bottom
RZ18  4.7K_0402_5%  [R_0402]  288.21 32.46 90 top
RZ19  4.7K_0402_5%  [R_0402]  288.21 35.15 270 top
RZ20  10K_0402_5%  [R_0402]  195.69 130.88 90 bottom
RZ26  33_0402_5%  [R_0402]  190.67 133.89 270 bottom
RZ29  33_0402_5%  [R_0402]  192.57 133.89 270 bottom
RZ30  33_0402_5%  [R_0402]  195.03 135.92 270 bottom
RZ35  33_0402_5%  [R_0402]  189.72 133.89 270 bottom
RZ36  4.7K_0402_5%  [R_0402]  293.93 43.29 270 top
RZ37  4.7K_0402_5%  [R_0402]  294.87 43.29 270 top
RZ69  10K_0402_5%  [R_0402]  190.04 134.62 270 top
RZ70  0_0402_5%  [R_0402]  64.98 34.51 270 top
RZ72  0_0402_5%  [R0402_0OHM]  75.44 40.74 180 top
RZ73  0_0402_5%  [R0402_0OHM]  74.07 33.19 180 top
RZ75  0_0603_5%  [R_0603]  190.35 122.97 180 top
RZ76  0_0402_5%  [R_0402]  65.61 47.75 270 top
RZ77  10K_0402_5%  [R_0402]  194.92 129.97 0 top
RZ78  0_0402_5%  [R_0402]  191.64 125.1 180 top
RZ79  0_0402_5%  [R_0402]  191.42 126.65 180 top
RZ80  0_0402_5%  [R_0402]  191.56 131.3 180 top
RZ82  10K_0402_5%  [R_0402]  193.12 122.35 180 top
RZ83  0_0402_5%  [R_0402]  195.75 129.26 270 bottom
RZ84  100_0402_5%  [R_0402]  197.54 129.99 270 top
RZ113  0_0402_5%  [R_0402]  335.96 27.06 90 bottom
RZ116  10K_0402_5%  [R_0402]  293.02 39.77 0 top
RZ117  10K_0402_5%  [R_0402]  295.77 39.77 180 top
RZ118  0_0402_5%  [R_0402]  331.86 33.87 270 bottom
RZ119  0_0402_5%  [R_0402]  330.97 33.87 270 bottom
SW1  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  205.97 154.82 270 top
SW2  SS3-CMFTQR9_3P  [SW_SS3-CMFTQR9_3P]  203.87 140.96 180 bottom
T1  PAD~D  [TPC12]  168.23 65.21 0 top
T2  PAD~D  [TPC12]  165.57 64.26 0 top
T3  PAD~D  [TPC12]  166.88 65.98 0 top
T4  PAD~D  [TPC12]  166.97 64.64 0 top
T5  PAD~D  [TPC12]  173.53 20.66 0 top
T6  PAD~D  [TPC12]  172.06 21.04 0 top
T7  PAD~D  [TPC12]  195.36 22.04 0 top
T8  PAD~D  [TPC12]  195.92 27.19 180 bottom
T9  PAD~D  [TPC12]  188.85 65.89 180 bottom
T10  PAD~D  [TPC12]  190.48 66.64 180 bottom
T11  PAD~D  [TPC12]  193.89 25.79 180 bottom
T12  PAD~D  [TPC12]  180.19 50.05 180 bottom
T13  PAD~D  [TPC12]  181.89 54.43 180 bottom
T14  PAD~D  [TPC12]  189.25 55.09 180 bottom
T15  PAD~D  [TPC12]  190.46 47.13 180 bottom
T16  PAD~D  [TPC12]  188.73 67.35 180 bottom
T17  PAD~D  [TPC12]  189.79 68.19 180 bottom
T18  PAD~D  [TPC12]  193.97 68.6 0 top
T19  PAD~D  [TPC12]  193.21 68.85 0 top
T20  PAD~D  [TPC12]  167.8 58.5 0 top
T21  PAD~D  [TPC12]  166.33 59.05 0 top
T22  PAD~D  [TPC12]  192.87 29.48 180 bottom
T23  PAD~D  [TPC12]  196.07 20.95 0 top
T24  PAD~D  [TPC12]  194.09 22.07 0 top
T25  PAD~D  [TPC12]  194.34 27.27 180 bottom
T26  PAD~D  [TPC12]  194.52 24.55 180 bottom
T27  PAD~D  [TPC12]  179.98 29.86 180 bottom
T28  PAD~D  [TPC12]  180.09 27.94 180 bottom
T29  PAD~D  [TPC12]  190.91 28.19 180 bottom
T30  PAD~D  [TPC12]  190.97 30.11 180 bottom
T31  PAD~D  [TPC12]  182.08 29.86 180 bottom
T32  PAD~D  [TPC12]  181.85 28.05 180 bottom
T33  PAD~D  [TPC12]  188.17 30.34 180 bottom
T34  PAD~D  [TPC12]  188.78 27.99 180 bottom
T35  PAD~D  [TPC12]  185.51 30.52 180 bottom
T36  PAD~D  [TPC12]  183.87 29.99 180 bottom
T37  PAD~D  [TPC12]  182.49 21.7 0 top
T38  PAD~D  [TPC12]  182.77 20.26 0 top
T39  PAD~D  [TPC12]  196.68 28.84 180 bottom
T40  PAD~D  [TPC12]  194.78 29.22 180 bottom
T41  PAD~D  [TPC12]  176.11 43.7 180 bottom
T42  PAD~D  [TPC12]  179.66 59.86 180 bottom
T43  PAD~D  [TPC12]  167.97 66.95 0 top
T44  PAD~D  [TPC12]  192.77 27.88 180 bottom
T45  PAD~D  [TPC12]  198.61 64.16 180 bottom
T46  PAD~D  [TPC12]  170.6 20.72 0 top
T47  PAD~D  [TPC12]  172.74 19.51 0 top
T48  PAD~D  [TPC12]  166.21 67.14 0 top
T49  PAD~D  [TPC12]  198.61 65.87 180 bottom
T50  PAD~D  [TPC12]  122.36 57.88 0 top
T51  PAD~D  [TPC12]  135.12 58.29 0 top
T52  PAD~D  [TPC12]  135.62 56.45 180 bottom
T53  PAD~D  [TPC12]  122.25 56.15 0 top
T54  PAD~D  [TPC12]  107.58 56.98 180 bottom
T55  PAD~D  [TPC12]  121.16 58 0 top
T56  PAD~D  [TPC12]  122.31 59.46 0 top
T57  PAD~D  [TPC12]  107.96 59.08 180 bottom
T58  PAD~D  [TPC12]  127.5 113.73 180 bottom
T59  PAD~D  [TPC12]  127.51 115.06 180 bottom
T60  PAD~D  [TPC12]  129.09 114.78 180 bottom
T61  PAD~D  [TPC12]  126.31 114.64 180 bottom
T62  PAD~D  [TPC12]  127.09 117.7 180 bottom
T63  PAD~D  [TPC12]  126.74 118.97 180 bottom
T66  PAD~D  [TPC12]  124.66 118.74 180 bottom
T67  PAD~D  [TPC12]  128.27 110.78 180 bottom
T68  PAD~D  [TPC12]  129.9 108.96 180 bottom
T69  PAD~D  [TPC12]  118.77 109.27 180 bottom
T70  PAD~D  [TPC12]  118.72 107.97 180 bottom
T71  PAD~D  [TPC12]  121.04 108 180 bottom
T72  PAD~D  [TPC12]  121.04 109.34 180 bottom
T74  PAD~D  [TPC12]  119.92 108.68 180 bottom
T75  PAD~D  [TPC12]  122.31 109.11 180 bottom
T76  PAD~D  [TPC12]  120.85 117.84 180 bottom
T142  PAD~D  [TPC12]  251.77 102.96 90 top
T143  PAD~D  [TPC12]  252.54 105.79 90 top
T155  PAD~D  [TPC12]  205.06 108.12 270 top
T156  MHPC_NS692417  [MHPC_NS692417_24P]  238.76 126.67 0 top
T165  PAD~D  [TPC12]  172.5 117.5 0 bottom
T178  PAD~D  [TPC12]  127.12 125.88 0 top
T179  PAD~D  [TPC12]  193.55 21.69 0 top
T180  PAD~D  [TPC12]  191.35 20.21 180 bottom
T181  PAD~D  [TPC12]  191.66 24.85 180 bottom
T182  PAD~D  [TPC12]  137.75 121.17 180 bottom
T183  PAD~D  [TPC12]  139.88 122.57 180 bottom
T184  PAD~D  [TPC12]  192.97 23.9 180 bottom
T185  PAD~D  [TPC12]  192.66 26.46 180 bottom
T186  PAD~D  [TPC12]  141.54 119.11 180 bottom
T187  PAD~D  [TPC12]  138.99 121.61 180 bottom
T188  PAD~D  [TPC12]  139.3 119.27 0 top
T189  PAD~D  [TPC12]  190.46 23.95 180 bottom
T190  PAD~D  [TPC12]  193.83 19.25 0 top
T191  PAD~D  [TPC12]  189.8 101.14 180 bottom
T192  PAD~D  [TPC12]  138.5 121.56 0 top
T194  PAD~D  [TPC12]  194.68 69.35 0 top
T199  PAD~D  [TPC12]  179.47 22.63 0 top
T201  PAD~D  [TPC12]  125.79 125.88 0 top
T207  PAD~D  [TPC12]  187.02 107.23 180 bottom
T208  PAD~D  [TPC12]  179.56 116.29 0 top
T209  PAD~D  [TPC12]  244.31 101.07 0 top
T210  PAD~D  [TPC12]  245.98 101.09 0 top
T211  PAD~D  [TPC12]  205.04 77.03 0 top
T212  PAD~D  [TPC12]  203.76 77.68 0 top
T213  PAD~D  [TPC12]  203.75 76.3 0 top
T214  PAD~D  [TPC12]  204.63 90.28 0 top
T215  PAD~D  [TPC12]  204.36 91.6 0 top
T216  PAD~D  [TPC12]  203.31 90.88 0 top
T217  PAD~D  [TPC12]  205.85 92.06 0 top
U3  -  [TC7SH125FU_SSOP5]  108.92 156.45 270 bottom
U6  -  [74AUP1G07GW_TSSOP5]  9.91 50.76 90 top
U8  -  [CY8C4245AXI-483_TQFP44_10X10]  254.44 89.41 180 top
U9  -  [SN74AHC1G08DCKR_SC70-5]  321.02 4.72 0 top
U14  -  [SN74AHC1G08DCKR_SC70-5]  149.95 75.06 90 top
U15  -  [SN74AHC1G08DCKR_SC70-5]  226.23 115.61 270 top
U16  -  [SN74AHC1G08DCKR_SC70-5]  174.87 73.3 180 top
U17  -  [MC74VHC1G09DFT2G_SC70-5]  217.26 76.07 90 top
U25  -  [SN74AHC1G08DCKR_SC70-5]  156.83 74.55 90 top
U27  -  [SN74AHC1G08DCKR_SC70-5]  144.74 75.06 90 top
U31  -  [WGI219LM-QREF-A0_QFN48_6X6]  253.33 112.99 270 top
U32  PI3L720ZHEX_TQFN42_9X3P5~D  [PI3L720ZHEX_TQFN42_9X3P5]  229.83 117.31 0 top
U33  -  [G524B1T11U_SOT23-5]  120.65 143.15 90 bottom
U46  ECE5048-LZY_DQFN132_11X11~D  [ECE5048-LZY_DQFN132_11X11]  175.55 116.21 0 bottom
U51  -  [MEC5085-LZY_DQFN132_11X11]  205.95 114.86 270 bottom
U52  -  [W25Q128FVSIQ_SO8]  173.19 127.99 0 bottom
U53  -  [W25Q32FVSSIQ_SO8]  181.89 127.93 0 bottom
U58  -  [SN74AHC1G08DCKR_SC70-5]  306.81 11.77 180 top
U88  -  [LNG2DMTR_LGA12_2X2]  6.06 45.78 270 top
U629  -  [PS8331BQFN60GTR-A0_QFN60_5X9]  181.99 133.82 180 bottom
U630  -  [PS8331BQFN60GTR-A0_QFN60_5X9]  152.01 133.69 180 bottom
U631  -  [PS8331BQFN60GTR-A0_QFN60_5X9]  152.8 103.1 270 bottom
U636  -  [PS8331BQFN60GTR-A0_QFN60_5X9]  164.58 97.12 0 bottom
U637  -  [NPCT650JAAYX_QFN32_5X5]  193.5 126.25 90 bottom
U638  -  [SN74AHC1G08DCKR_SC70-5]  106.77 119.88 0 top
U639  -  [SN74LVC1G3157DCKR_SC70-6]  7.36 35.66 0 top
UC1  -  [SN74AHC1G08DCKR_SC70-5]  204.53 99.75 270 top
UC3  -  [MC74VHC1G09DFT2G_SC70-5]  144.19 125.98 180 top
UC4  -  [SN74AHC1G08DCKR_SC70-5]  189.07 104.83 270 top
UC5  -  [SN74AHC1G08DCKR_SC70-5]  215.41 101.48 0 top
UC6  -  [74AUP1G07GW_TSSOP5]  221.44 105.3 90 top
UC7  -  [SN74AHC1G08DCKR_SC70-5]  86.7 20.46 0 top
UD1  -  [74AUP1G07GW_TSSOP5]  45.8 12.16 270 top
UH1  SKL-H-PCH_BGA837  [SKL-H-PCH_BGA_837P-T]  134.81 102.29 0 top
UN8  -  [PS8558BTQFN24GTR2-A_TQFN24_4X4]  27.96 31.18 270 top
UN9  -  [PS8558BTQFN24GTR2-A_TQFN24_4X4]  38.94 31.25 270 top
UV2  -  [PS8338BQFN60GTR-A0_QFN60_5X9]  161.69 113.2 180 bottom
UZ18  -  [TPS22961DNYR_WSON8]  188.62 100.06 270 top
UZ19  -  [TPS22961DNYR_WSON8]  202.13 99.07 90 top
UZ20  -  [EM5209VF_DFN14_3X2]  305.47 29.07 90 top
UZ21  -  [AOZ1336_DFN8_2X2]  17.62 40.71 0 top
UZ22  -  [AOZ1336_DFN8_2X2]  240.23 80.46 270 top
UZ23  -  [AOZ1336_DFN8_2X2]  185.08 99.14 90 top
UZ24  -  [AOZ1336_DFN8_2X2]  324.57 34.44 180 top
UZ25  -  [EM5209VF_DFN14_3X2]  220.67 123.33 270 top
UZ26  -  [EM5209VF_DFN14_3X2]  209.2 93.86 0 top
UZ27  -  [AOZ1336_DFN8_2X2]  152.72 123.73 90 top
UZ28  -  [AOZ1336_DFN8_2X2]  152.72 121.32 90 top
UZ29  -  [PI3PCIE3212ZBEX_TQFN20_2P5X4P5]  328.15 40.3 0 top
UZ30  -  [TPS22961DNYR_WSON8]  91.47 22.47 180 top
Y3  25MHZ_18PF_X3G025000DI1H-H  [Y_X3G025000DI1H-H_4P]  250.79 119.09 0 top
Y6  32.768KHZ_12.5PF_Q13FC135000040  [Y_Q13FC135000040_2P]  202.11 121.08 0 bottom
YH1  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  139.09 133.5 180 top
YH2  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  142.56 101.2 180 top

## Library data of the parts
C1 C3 C5 C296 C300 C330 C332 C357 C392 C396 C400 C403 C450 C462 C464 C479 C484 C486 C513 C608 C613 C702 C703 C714 C762 C764 C767 C782-C786 C1424 C1445 CC81-CC84 CC161 CC163-CC185 CC187-CC190 CC196-CC202 CC208 CC211-CC213 CC272 CD7-CD13 CD15 CD18 CD27 CD28 CD31 CD32 CD34 CD37-CD39 CD45 CD46 CD49 CD50 CD52 CD55-CD57 CD63 CD64 CD67 CD68 CD70 CD73 CD74 CD89-CD91 CD98 CD99 CD105-CD107 CD113-CD115 CD121 CH47 CZ8 CZ15 PC2 PC9 PC15 PC31 PC100 PC109-PC111 PC114 PC117-PC119 PC206 PC210 PC212 PC213 PC310 PC400 PC403 PC500 PC502 PC503 PC509 PC510 PC700 PC706 PC709 PC714 PC734 PC804 PC805 PC1004-PC1008 PC1130 PC1208-PC1215 PC1220-PC1235 PC1249 PC1250 PC1258 PC1269 PC1408-PC1431 PC1438-PC1442 PC1457 PC1458 PC1477 PC1606 PC1610 PC1613 PC1619-PC1626 PC1702-PC1705 PC1800 PC1802-PC1805 PC1809 PC1810 = C_0603
C2 C30 C328 C514 C622 C1177 C1178 CE6 CH29 CH44-CH46 PC14 PC30 PC102 PC202 PC305 PC707 PC708 PC715 PC718 PC719 PC803 PC901 PC904 PC1001 PC1200-PC1207 PC1216-PC1219 PC1400-PC1407 PC1433 PC1434 PC1436 PC1437 PC1601 PC1602 PC1604 PC1605 PC1700 PC1701 = C_0805
C4 C6-C8 C31-C36 C90 C92 C94 C97-C100 C141 C143 C248 C288 C291-C293 C298 C299 C301 C310 C320 C327 C340 C364-C380 C391 C395 C401 C404 C406 C425-C427 C431 C436-C444 C458-C461 C463 C466-C474 C477 C478 C483 C494-C497 C499-C509 C523-C532 C539-C578 C580 C581 C583-C598 C601 C603-C607 C610-C612 C614 C617 C618 C621 C623 C626-C629 C695-C701 C704 C708-C710 C713 C716-C719 C721-C726 C733-C737 C739-C741 C743 C744 C746 C747 C757 C759 C763 C766 C774 C777 C778 C787 C1167 C1216 C1343-C1346 C1348-C1356 C1410 C1411 C1414 C1418 C1420 C1421 C1423 C1425-C1428 C1430 C1431 C1437 C1438 C1444 C1446-C1471 CC1-CC33 CC35-CC37 CC44-CC64 CC67-CC77 CC186 CC191-CC195 CC203-CC205 CC209 CC210 CC269 CC273 CD2-CD6 CD16 CD17 CD19-CD24 CD26 CD29 CD30 CD33 CD35 CD36 CD40-CD42 CD44 CD47 CD48 CD51 CD53 CD54 CD58-CD60 CD62 CD65 CD66 CD69 CD71 CD72 CD75-CD82 CD92-CD97 CD100-CD104 CD108-CD112 CD116-CD120 CD122-CD124 CD127-CD129 CD136-CD140 CD142-CD144 CE1 CE8 CE9 CH4 CH5 CH10 CH13 CH14 CH17 CH31-CH38 CH40-CH42 CH49-CH51 CH62-CH68 CH266-CH269 CN63-CN67 CN69-CN76 CN79-CN81 CN83 CN85 CN87 CN88 CN91 CN92 CN95 CN97 CV27-CV31 CV42 CZ1-CZ7 CZ9-CZ12 CZ25 CZ26 CZ30 CZ31 CZ57 CZ58 CZ63 CZ65-CZ67 CZ82 CZ86 CZ88-CZ97 PC4 PC5 PC11 PC103 PC105 PC151 PC204 PC205 PC209 PC211 PC214 PC215 PC300 PC304 PC311 PC312 PC401 PC405 PC508 PC702-PC705 PC710-PC713 PC717 PC720 PC721 PC737 PC741 PC800-PC802 PC807 PC900 PC902 PC903 PC1002 PC1003 PC1009 PC1100-PC1129 PC1131-PC1136 PC1140 PC1238-PC1248 PC1251-PC1257 PC1259-PC1268 PC1333-PC1338 PC1443-PC1456 PC1459-PC1476 PC1478-PC1480 PC1550-PC1555 PC1600 PC1603 PC1607-PC1609 PC1611 PC1612 PC1614-PC1618 PC1627 PC1640 PC1642-PC1644 PC1690 PC1707 PC1708 PC1801 PC1806-PC1808 = C_0402
C249 C779 = C_0603: room: CRT
C272 C273 C535 C537 C538 = C_0402: room: HDMI
C297 C776 = C_1206
C339 = C_0402: room: LAN
C424 = C_0402: room: EC
C480 = C_0603: room: TP
C481 = C_0603: room: FAN
C485 = C_1808
C536 = C_0603: room: HDMI
C615 C619 C1176 C1402 PC120 PC121 = C_D2E
C780 C781 = C_0402: room: CRT
CD14 CD25 CD43 CD61 PC806 PC1236 PC1237 PC1432 PC1435 PC1549 PC1641 PC1706 = C_D2
CMOS1 JTAG1 PWRSW1 = SHORTPADS: User Part Number: PART#
CPU1 = SKL-H_BGA_1440P-T
D7 D8 D18 D64-D66 D68 D69 D71 D92 D94 D95 = RB751VM-40TE-17_SOD323-2
D20 = L30ESDL5V0C3-2_SOT23-3
D21 D22 PD4 PD6 = PESD5V0U2BT_SOT23-3
D31 = RB751S40T1G_SOD523-2: room: LAN
D32 D36 D59 D62 D90 D97-D100 DZ1-DZ3 = RB751S40T1G_SOD523-2
D33 = L30ESD24VC3-2_SOT23-3
D93 PD701 PD702 PD1010 = BAT54CW_SOT323-3
FD1-FD4 = FIDUCIAL_C40M80: room: SCREW HOLD
H1-H4 H23 = H_3P8: room: SCREW HOLD
H5 H9 H10 = H_2P8: room: SCREW HOLD
H6 H7 H13 H17-H20 H22 H30 = H_2P8
H12 = H_3P3: room: SCREW HOLD
H14 = H_3P8
H15 = H_2P1: room: SCREW HOLD
H27 = H_3P3
H29 = H_2P6X2P1
H31 = H_2P6X2P1N
JAPS1 = ACES_50506-01841-P01_18P
JDEG2 JLPDE1 = ACES_50506-01041-P01_10P
JDEG3 JPB1 JTS1 = ACES_50228-0067N-001_6P
JDIMM1 = BELLW_80888-6021_260P-T: room: RAM
JDIMM2 = LOTES_ADDR0106-P005A_260P-T
JDIMM3 = BELLW_80888-2021_260P-T
JDIMM4 = LOTES_ADDR0107-P005A_260P-T
JDOCK1 = FOX_QL01723-D265G1-8H_144P
JEDP1 = ACES_50398-04041-001_40P
JFAN1 = ACES_50273-0040N-001_4P: room: FAN
JFAN2 = ACES_50273-0040N-001_4P
JIO1 = FOX_QT50A01-29100-9H_100P-T-S: room: USB3.0
JIO2 = FOX_QT50A61-29100-9H_160P-T-S
JKBTP1 = ACES_50559-02001-001_20P
JLED1 = ACES_50554-00641-001_6P-T
JLOM1 = SINGA_2RJ1672-000111F_13P
JMXM1 = JAE_MM70-314-310B1-1-_310P-S
JNGFF1 = BELLW_80148-4221_67P
JNGFF2 = BELLW_80149-3221_67P
JNGFF3 = BELLW_80159-3221_67P
JRTC1 = ACES_50271-0020N-001_2P
JSATA2 = STARC_7300L30-100000-G4_30P-T
JSIM1 = T-SOL_159-1000302602_10P
JSPI1 = E-T_6712K-Y20N-07L_20P
JUART1 = ACES_50207-00471-P01_4P-T
JUSH1 = ACES_50559-02601-001_26P-T
JXDP1 = SAMTE_BSH-030-01-L-D-A_60P
L10 L11 = INPAQ_MCM1012B900F06BP_4P: room: CRT
L29 = TAIYO_BRC2012T4R7MD_2P
LED5 = LED_LTW-270US5_2P
PBATT1 = SUYIN_200045GR009M28QZR_9P
PC1 PC1141 PC1142 = C_EEEFK1E101YP
PC101 = C_0805: room: DCIN
PC201 = C_D2: room: BATT CONN
PC203 = C_0805: room: BATT CONN
PC207 = C_0805: room: OTP
PC301 PC302 PC309 = C_0603: room: CHARGER
PC303 PC306-PC308 = C_0805: room: CHARGER
PC402 = C_0402: room: 3_5V
PC404 = C_0603: room: 3_5V
PC501 PC506 PC507 = C_0402: room: 1.5V
PC504 PC505 = C_0603: room: 1.5V
PC1270-PC1301 PC1303 PC1315-PC1325 PC1328-PC1332 PC1481-PC1548 PC1628-PC1639 = C_0201
PC1302 PC1304-PC1314 PC1326 PC1327 = C_0201: room: GPU_CAP
PD1 = BAS40CW_SOT323-3
PD2 PD3 = TVNST52302AB0_SOT523-3
PD5 PD704 PD1100-PD1103 = SDMK0340L-7-F_SOD323-2
PD8 = D_0603
PD700 = SBR3A40SA-13_SMA2
PD703 = MM3Z22VST1G_SOD323-2
PD1001 PD1002 = PDS5100H-13_POWERDI5-3
PH1100-PH1104 PH1600 PH1601 PR1 PR2 PR7-PR13 PR16 PR18 PR20 PR22 PR100 PR102 PR104-PR107 PR113 PR114 PR204-PR209 PR309-PR311 PR400 PR405 PR500 PR505 PR509-PR514 PR700 PR703 PR704 PR709 PR712 PR713 PR715 PR718-PR720 PR722 PR725 PR730 PR737 PR738 PR740 PR744 PR745 PR757 PR758 PR760-PR762 PR764 PR766-PR773 PR800 PR802 PR804 PR806-PR809 PR901-PR903 PR1001-PR1003 PR1013 PR1018 PR1028 PR1030 PR1031 PR1033-PR1037 PR1099-PR1101 PR1103-PR1105 PR1109-PR1114 PR1116-PR1120 PR1123-PR1125 PR1127 PR1129-PR1150 PR1152-PR1164 PR1167-PR1170 PR1199 PR1204 PR1205 PR1210 PR1404 PR1405 PR1410 PR1600-PR1602 PR1604-PR1613 PR1616-PR1621 PR1800-PR1802 PR1805-PR1815 R1-R5 R8-R13 R19 R21-R30 R37-R43 R51 R60 R71 R96-R107 R109 R115-R143 R146-R162 R222 R317 R339 R360-R363 R370 R371 R373-R379 R381-R387 R389 R396 R399 R400 R403 R405 R407-R411 R413-R418 R422 R423 R425-R430 R432 R435 R492 R501-R504 R506 R519 R545 R546 R549 R553 R554 R557 R559 R561 R562 R571-R574 R720-R723 R755-R759 R763 R773 R775 R779 R782 R783 R795 R800 R803-R805 R807 R810 R811 R814 R817 R819 R820 R822 R825 R829 R835-R838 R841 R843 R847-R850 R858-R864 R869 R870 R872 R874-R877 R879 R880 R885 R892 R895 R897 R899-R901 R932 R935 R936 R940 R943 R944 R953 R955 R956 R1069 R1137 R1138 R1167 R1170 R1171 R1977 R1978 R1981 R2158 R2160 R2164-R2179 R2189 R2194-R2198 R3664-R3670 R3722 R3727 R3728 R3730 R3736-R3741 R3744-R3748 R3750 R3752-R3755 R3757 R3758 RC1 RC2 RC5 RC6 RC66 RC74-RC76 RC79 RC121 RC122 RC124 RC126-RC129 RC132 RC133 RC135 RC138 RC143 RC144 RC155-RC159 RC164 RC166-RC168 RC171 RC172 RC177-RC181 RC217 RC221 RC222 RC227-RC229 RC241 RC301-RC303 RC306 RC312-RC318 RC320-RC330 RD3-RD5 RD7-RD10 RD12-RD14 RD16 RD18-RD23 RD26 RD27 RD30 RD34 RD40-RD47 RD51 RD53 RD56 RD61 RE1 RE11 RE12 RE14 RE67-RE77 RH38 RH39 RH42 RH44-RH46 RH48 RH50 RH56 RH61 RH65 RH67 RH70 RH71 RH73-RH81 RH83 RH84 RH86 RH90-RH99 RH124-RH128 RH131-RH133 RH153 RH171 RH177-RH179 RH181-RH184 RH187 RH192 RH193 RH196 RH198-RH204 RH207 RH210 RH213-RH215 RH220-RH225 RH255 RH294-RH296 RH306 RH308-RH315 RH317-RH319 RH321-RH329 RH331 RH334 RH335 RH338-RH345 RH347 RH349-RH356 RH358 RH359 RN50-RN55 RN57-RN62 RN78 RN79 RN99-RN111 RN114-RN134 RV28-RV49 RZ10 RZ17-RZ20 RZ26 RZ29 RZ30 RZ35-RZ37 RZ69 RZ70 RZ76-RZ80 RZ82-RZ84 RZ113 RZ116-RZ119 = R_0402
PJP1 PJP7 PJP17 PJP18 PJP22 PJP100 PJP102 PJP103 PJP203 PJP204 PJP300 PJP801 = JUMP_43X118
PJP2 PJP4 PJP6 PJP12-PJP14 PJP202 PJP700 PJP900 PJP901 PJP1100 = JUMP_43X39
PJP3 PJP5 PJP8-PJP11 PJP15 PJP16 PJP19-PJP21 PJP23-PJP26 PJP200 PJP301 PJP400 PJP401 PJP500 PJP800 PJP1800 = JUMP_43X79
PJP101 = JUMP_43X118: room: DCIN
PJP201 = JUMP_43X39: room: BATT CONN
PJPDC1 = ACES_50493-0110N-001_11P
PL1 PL4 PL5 = CHENG_SMB3025500YA_2P
PL2 PL6 = TAIYO_FBMJ4516HS720NT_2P
PL3 = MURAT_BLM15HG601SN1D_2P
PL100 PL700 PL800 = L_5X5X3_M_2P
PL101 = PANAS_ETQP3W2R2WFN_2P: room: DCIN
PL102 = TOKO_FDVE1040-H-3R3M-P3_2P
PL201 = L_7X7X3_M_2P: room: BATT CONN
PL301 = L_5X5X3_M_2P: room: CHARGER
PL400 = L_4X4X2_F_2P
PL500 PL1800 = TAI-T_HCB1608KF-121T3_L0603_2P
PL501 PL1801 = MAG_MLV-FY12N1R0M-O1L_2P
PL701 = L_7X7X3_M_2P
PL1100 PL1101 = TAI-T_HCB2012KF-121T50_2P
PL1200-PL1202 PL1400-PL1402 = CYNTE_PCME064T-R15MS_4P
PL1600 PL1700 = MAG_MMD05CZR47M_4P
PQ1 PQ700 PQ702 PQ703 PQ706 PQ1072 = NTR4502PT1G_SOT23-3
PQ2 = FDV301N_NL_SOT23-3
PQ3 = MMST3904-7-F_SOT323-3
PQ5 PQ701 PQ1001 PQ1003 PQ1004 = SI7447DP_SO8_5P
PQ8 = IMD2AT-108_SC74-6
PQ100 PQ101 PQ800 = SIS412DN-T1-GE3_POWERPAK8-5
PQ102 PQ103 PQ705 = FDMC7692S_MLP8-5
PQ201 PQ202 PQ704 = SIR472DP-T1-GE3_POWERPAK8-5
PQ707 Q29 Q74 Q295 Q325 Q343 Q347 Q353 Q355 Q364-Q367 Q369 QE2 QH4 = DMN66D0LDW-7_SOT363-6
PQ708 PQ1005 PQ1073 PQ1074 = DMN65D8LDW-7_SOT363-6
PQ801 = SI7716ADN-T1-GE3_POWERPAK8-5
PQ1002 = SI4835DDY-T1-E3_SO8
PQ1011 = SSM3K7002FU_SC70-3
PR3 RP3-RP7 RP9 RPH6 = RP_0804_8P4R
PR19 PR1011 = R_0805
PR33 PR103 PR108 PR308 PR314 PR316 PR710 PR711 PR714 PR716 PR721 PR726-PR729 PR743 PR900 PR1004 PR1006 PR1009 PR1012 PR1014 PR1016 PR1017 PR1019-PR1025 PR1027 PR1032 PR1106-PR1108 PR1115 PR1121 PR1122 PR1126 PR1128 PR1165 PR1166 PR1198 R7 R72 R372 R388 R555 R556 R558 R797 R802 R834 R840 R845 R866 R878 R881 R1068 R1144 R1970-R1972 R1985 RC154 RC169 RC220 RC307-RC309 RC319 RD6 RD11 RD15 RD17 RD28 RD29 RD31 RD35-RD39 RD52 RD54 RD55 RH43 RH66 RH85 RH152 RH154 RH155 RH161 RH166-RH170 RH180 RH185 RH194 RH195 RH197 RH211 RH212 RH256-RH260 RH286-RH293 RH297-RH300 RH302-RH305 RH337 RH346 RH357 RZ3 RZ72 RZ73 = R0402_0OHM
PR101 = R_0402: room: DCIN
PR109 PR110 PR200 PR210 PR312 PR403 PR706 PR765 PR801 PR1007 PR1008 PR1010 PR1015 PR1026 PR1029 PR1102 PR1151 PR1200-PR1203 PR1208 PR1209 PR1400-PR1403 PR1408 PR1409 PR1603 PR1615 PR1700 PR1701 PR1803 R213 RC173-RC176 RC223 RC224 RC226 RC230 RH238-RH240 RH246 RH250 RH348 RZ75 = R_0603
PR111 PR112 PR305 PR504 PR717 PR724 PR805 PR1005 PR1206 PR1207 PR1211 PR1406 PR1407 PR1411 PR1614 PR1702 PR1804 RH254 = R_1206
PR201 = R_0402: room: BATT CONN
PR202 = R_1206: room: BATT CONN
PR203 = R_0603: room: BATT CONN
PR303 PR306 PR307 PR315 = R_0402: room: CHARGER
PR401 = R0402_0OHM: room: 3_5V
PR402 PR404 = R_0402: room: 3_5V
PR501 PR502 PR506-PR508 = R_0402: room: 1.5V
PR503 = R_0603: room: 1.5V
PR701 PR723 = R_1206_4P-D
PT1 T1-T35 T37-T63 T66-T72 T74-T76 T142 T143 T155 T165 T178-T192 T194 T199 T201 T207-T217 = TPC12
PU1 = TS5A63157DCKR_SC70-6
PU101 = TPS51285BRUKR_QFN20_3X3
PU105 = TC7SH08FU_SSOP5
PU200 = RT8207MZQW_WQFN20_3X3
PU300 = SYX198DQNC_QFN10_3X3
PU400 = SY8003DFC_DFN8_2X2
PU500 PU1800 = NB681GD-Z_QFN13_2X3
PU700 = BQ24780RUYR_WQFN28_4X4
PU800 = TPS51212DSCR_SON10_3X3
PU900 = AP7175SP-13_SO-8EP-8
PU1001 = CD3301RHHR_QFN36_6X6
PU1100 = NCP81205MNTXG_QFN52_6X6
PU1200-PU1202 PU1400-PU1402 PU1700 = NCP81382MNTXG_QFN39_4X6
PU1600 = NCP81210MNTWG_QFN40_5X5
Q4 Q5 Q22 Q87 Q327 Q359 Q370 QH3 QH5 QN5 QV1 = DMN65D8LW-7_SOT323-3
Q14-Q17 Q26-Q28 = MMBT3904WT1G_SC70-3
Q21 = DMP3050LVT-7_TSOT26-6
Q24 = LP2301ALT1G_SOT23-3: room: KBL
Q86 = DDTA114EUA-7-F_SOT323-3
Q186 = AO4435L_SO8
QZ2 = LP2301ALT1G_SOT23-3
R63-R70 R208 R209 RC216 RC304 RD57-RD60 RH241 RH247 RH252 RH253 RH276 RH279 RH301 = R0603_0OHM
R336 = R_0402: room: HDMI
R513 = R_0402: room: PBTN
SW1 = SW_SKRBAAE010_4P: room: PBTN
SW2 = SW_SS3-CMFTQR9_3P
T36 = TPC12: room: LAN
T156 = MHPC_NS692417_24P
U3 = TC7SH125FU_SSOP5
U6 UC6 UD1 = 74AUP1G07GW_TSSOP5
U8 = CY8C4245AXI-483_TQFP44_10X10
U9 U14-U16 U25 U27 U58 U638 UC1 UC4 UC5 UC7 = SN74AHC1G08DCKR_SC70-5
U17 UC3 = MC74VHC1G09DFT2G_SC70-5
U31 = WGI219LM-QREF-A0_QFN48_6X6
U32 = PI3L720ZHEX_TQFN42_9X3P5
U33 = G524B1T11U_SOT23-5: room: USB3.0
U46 = ECE5048-LZY_DQFN132_11X11
U51 = MEC5085-LZY_DQFN132_11X11
U52 = W25Q128FVSIQ_SO8
U53 = W25Q32FVSSIQ_SO8
U88 = LNG2DMTR_LGA12_2X2
U629-U631 U636 = PS8331BQFN60GTR-A0_QFN60_5X9
U637 = NPCT650JAAYX_QFN32_5X5
U639 = SN74LVC1G3157DCKR_SC70-6
UH1 = SKL-H-PCH_BGA_837P-T
UN8 UN9 = PS8558BTQFN24GTR2-A_TQFN24_4X4
UV2 = PS8338BQFN60GTR-A0_QFN60_5X9
UZ18 UZ19 UZ30 = TPS22961DNYR_WSON8
UZ20 UZ25 UZ26 = EM5209VF_DFN14_3X2
UZ21-UZ24 UZ27 UZ28 = AOZ1336_DFN8_2X2
UZ29 = PI3PCIE3212ZBEX_TQFN20_2P5X4P5
Y3 = Y_X3G025000DI1H-H_4P
Y6 = Y_Q13FC135000040_2P
YH1 = Y_9H03200042_2P
YH2 = Y_X3G024000DC1H_4P

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50273-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 2.108x2.997 smd: 5(-2.55,-2.9) 6(6.3,-2.9)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50493-0110N-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_50506-01041-P01_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(-2.1,-3.05) 12(6.6,-3.05)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50554-00641-001_6P-T
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3)
  rect 0.787x1.499 smd: 7(-1,0) 8(-1,3) 9(3.5,0) 10(3.5,3)
ACES_50559-02001-001_20P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3) 13(6,0) 14(6.5,3) 15(7,0) 16(7.5,3) 17(8,0) 18(8.5,3) 19(9,0) 20(9.5,3)
  rect 0.787x1.499 smd: 21(-1,0) 22(-1,3) 23(10.5,0) 24(10.5,3)
ACES_50559-02601-001_26P-T
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3) 13(6,0) 14(6.5,3) 15(7,0) 16(7.5,3) 17(8,0) 18(8.5,3) 19(9,0) 20(9.5,3) 21(10,0) 22(10.5,3) 23(11,0) 24(11.5,3) 25(12,0) 26(12.5,3)
  rect 0.787x1.499 smd: 27(-1,0) 28(-1,3) 29(13.5,3) 30(13.5,0)
AO4435L_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
AOZ1336_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AP7175SP-13_SO-8EP-8
  oval 0.813x1.753 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.25) 6(2.54,5.25) 7(1.27,5.25) 8(0,5.25)
  rect 3.505x2.616 smd: 9(1.905,2.625)
BAS40CW_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_80148-4221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(3.75,-7.55) 9(4,0) 10(4.25,-7.55) 11(4.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BELLW_80149-3221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BELLW_80159-3221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BELLW_80888-2021_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1) 262(67.175,16.1)
BELLW_80888-6021_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 2.007x3.505 smd: 261(-4.375,16.1) 262(71.125,12.1)
