# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_SPI_PWR: length 5.7
  BOTTOM w0.102: v1(167.67,121.28) RH343.1
  BOTTOM w0.305: RH343.1 RH344.1 165.76,121.31 RH185.1 165.76,122.66 164.62,123.79 JSPI1.16
+3.3V_SSD1: length 304.6
  TOP w0.508: v2(304.47,4.9) 304.21,4.63 R385.1 ; C618.1 v2(6.01,12.76) ; C621.1 v2(6.9,12.76) ; v2(3.47,12.89) C617.1
  IN1 w0.508: v2(177.65,12.41) 177.65,11.11 180.05,8.72 180.05,6.84 182.08,4.8 226.9,4.8 228.22,6.12 241.74,6.12 242.86,4.99 244.2,4.99 244.34,5.14 270.03,5.14 270.7,4.47 290.13,4.47 290.66,5 293.17,5 293.57,5.39 303.98,5.39 v2(304.47,4.9)
  IN3 w0.508: v2(177.65,12.41) 174.86,12.41 171.53,9.08 164.38,9.08 161.9,11.56 140.73,11.56 136.97,7.81 129.03,7.81 128.36,8.47 110.21,8.47 106.45,12.24 94.15,12.24 91.67,14.71 81.18,14.71 80.71,15.18 68.3,15.18 66.35,13.23 59.07,13.23 57.83,11.98 56.25,11.98 54.73,10.46 45.54,10.46 45.15,10.06 40.24,10.06 38.94,8.76 28.08,8.76 23.91,12.93 v2(21.22,12.93)
  vias: v2(3.47,13.85) v2(5.45,14.26) v2(5.88,13.62) v2(13.63,42.18) v2(13.63,41.55) v2(13.63,40.91) v2(14.27,42.18) v2(14.27,41.55) v2(14.27,40.91) v2(17.11,9.1) v2(17.79,9.1) v2(18.5,9.1) v2(19.26,9.1) v2(20.58,12.93) v3(24.73,16.86)
+3.3V_SSD1_PWR: length 1.3
  TOP w0.102: C400.1 v1(16.47,45.54)
+3.3V_TP: length 25.6
  TOP w0.508: 291.91,39.77 291.91,38.07 290.95,37.11 289.3,37.11 v1(289.03,36.85) 288.21,35.7 RZ19.1 287.34,35.15 286.94,34.74 286.94,33.18 287.66,32.46 RZ18.1 288.21,32.18 288.79,31.59 ; 291.91,39.77 v2(291.91,40.71) 291.91,42.17 293.03,43.29 RZ36.1 RZ37.1 ; 291.91,39.77 RZ116.1 ; RZ117.1 296.18,40.18 v2(296.18,40.65)
  IN3 w0.508: v2(296.18,40.65) 295.65,40.12 292.28,40.12 291.91,40.48 v2(291.91,40.71)
+3.3V_VTR: length 4
  BOTTOM w0.279: C739.1 201.38,103.76 201.75,104.13 v1(201.75,104.63) U51.A22
  BOTTOM w0.508: R834.2 202.46,103.49 C1349.1 C739.1
+3.3V_WLAN:
  vias: v2(221.47,128.57) v2(221.51,127.97) v2(221.64,129.13) v2(221.72,111.02) v2(221.92,111.57) v2(221.91,110.45) v2(222.1,128.61) v3(218.98,137.53)
+3.3V_WLAN_PWR:
  vias: v1(224.31,125.67)
+3.3V_WWAN: length 53
  TOP w0.254: 333.68,40.18 333.56,40.3 UZ29.10 ; UZ29.6 v2(330.7,38.4) ; UZ29.1 327.44,40.3 v2(327.18,40.56)
  TOP w0.508: R384.1 298.98,4.31 v2(298.77,4.52) ; 333.68,40.18 CZ94.1 v2(334.34,38.93)
  IN2 w0.508: v2(334.34,38.93) 333.2,40.08 332.67,40.08 330.99,38.4 v2(330.7,38.4) 330.7,39.02 330.28,39.44 328.6,39.44 327.49,40.56 v2(327.18,40.56)
  IN4 w0.508: v2(298.77,4.52) 299.27,4.02 306.06,4.02 311.8,9.76 311.8,19.81 313.41,21.42 316.03,21.42 316.79,22.18 320.74,22.18 v2(321.67,23.11)
  BOTTOM w0.102: v3(335.21,38.93) v2(334.34,38.93)
  vias: v2(322.05,41.35) v2(322.1,23.64) v2(322.18,40.76) v2(322.48,24.21) v2(322.84,40.86) v2(324.16,38.98) v2(324.74,39.01) v2(325.35,39.01) v2(327.03,36.01)
+3.3V_WWAN_PWR: length 1.9
  TOP w0.102: 322.81,31.01 321.29,31.01 v1(321.03,30.75)
+3VALWP: length 27.7
  TOP w0.254: v2(344.39,29.93) 344.89,30.44 PR100.1
  IN1 w0.254: v2(344.39,29.93) 344.39,28.15 349.75,22.78 349.75,12.67 348.7,11.62 346.65,11.62 v2(344.51,9.48)
  vias: v1(341.91,12.38)
+5V_ALW: length 559.1
  TOP w0.203: PU1400.3 233.7,17.31 v2(233.74,17.34) ; UZ26.4 210.4,93.4 210.67,93.13 v2(210.67,92.98) ; PC1458.1 230.7,36.6 230.94,36.36 PU1402.7 ; PU1401.3 233.7,27.8 v2(233.81,27.91) ; PC1412.1 230.55,15.63 PU1400.7 ; v2(257.34,24.34) 257.47,24.47 257.47,24.85 257.62,25 PU1600.27 ; v2(233.74,38.03) 233.68,37.97 PU1402.3 ; v2(306.35,30.18) 306.26,30.27 UZ20.4 ; PC1413.1 230.72,26.44 230.99,26.18 PU1401.7
  TOP w0.254: v2(219.03,122.01) 219.16,122.13 UZ25.4 ; UZ23.4 185.08,101.55 v2(185.4,101.87) ; 154.14,124.86 154.14,125.01 153.82,125.34 153.28,125.34 153.17,125.23 UZ27.4 ; 154.14,124.86 154.14,123.58 153.38,122.82 UZ28.4 ; 154.14,124.86 v2(154.12,124.86) ; UZ24.4 323.07,34.79 322.89,34.97 322.58,34.97 322.48,34.87 v2(322.48,34.64) ; 100.17,124.29 100.34,124.46 PU800.7 ; v2(18.82,39.9) 19.12,40.2 UZ21.4 ; UZ18.3 188.2,98.76 187.71,98.27 CZ89.1 ; PR1012.2 330.36,59.34 v2(329.97,58.95)
  TOP w0.305: UZ19.3 202.9,100.37 CZ86.1 ; CZ96.1 v2(90.28,23.08) 90.17,22.97 UZ30.3
  TOP w0.381: PU1.5 v2(11.35,17.98)
  TOP w0.457: PR1606.2 258.46,24 v2(258.37,24.09)
  TOP w0.508: CZ89.1 187,98.27 186.61,97.87 186.61,95.59 186.42,95.4 v2(186.42,93.69) ; v2(228.97,69.5) 229.2,69.27 v2(234.78,69.27) 234.78,69.76 235.53,70.51 235.53,72.83 236.31,73.62 240.39,73.62 240.75,73.97 240.75,76.18 240.58,76.35 240.58,77.68 241.02,78.13 ; v2(99.99,122.59) PC805.1 99.99,124.11 100.17,124.29 ; JLED1.1 291.05,4.07 290.68,3.7 289.31,3.7 288.9,4.11 C6.1 288.9,5.04 v2(288.96,5.1) ; 241.22,77.55 241.72,77.05 243.65,77.05 v2(244.82,78.22) ; v2(66.1,36.65) 66.1,41.24 66.65,41.8 JUSH1.9 ; PR1400.2 PC1412.1 v2(229.26,16.23) ; v2(250.51,49.71) 250.51,50.48 251.31,51.28 PR1169.1 ; CZ86.1 203.8,100.78 v2(203.99,100.59) ; v2(229.29,36.6) PC1458.1 PR1409.2 ; PR1170.1 250.32,42.44 250.32,43.15 249.9,43.57 PR1151.1 249.45,46.18 v2(249.07,46.57) ; JPB1.2 289,43.23 289.31,42.92 290.61,42.92 291.86,44.18 295.97,44.18 v2(298.41,41.74) ; Q86.3 306.73,6.32 v2(306.73,5.98) ; PR11.1 v2(12.3,25.99) ; v2(229.26,26.44) PC1413.1 PR1403.2 ; v2(258.3,23.01) 258.37,22.93 PC1611.1
  IN1 w0.381: v2(236.37,40.79) 236.37,39.98 237.51,38.84 238.74,38.84 239.54,38.04 v2(239.54,37.5)
  IN1 w0.508: v2(229.26,26.44) 230.28,26.44 230.88,25.84 230.88,17.84 v2(229.26,16.23) ; v2(219.03,122.01) 216.99,122.01 215.62,123.38 215.62,125.69 216.43,126.49 216.43,129.49 215.07,130.85 215.07,131.68 214.97,131.78 214.97,132.2 214.63,132.53 214.63,135.97 211.16,139.44 209.19,139.44 v2(209.17,139.43) ; v2(306.73,5.98) 306.68,6.03 293.3,6.03 292.91,5.63 289.5,5.63 v2(288.96,5.1) ; v2(99.99,122.59) 99.99,120.05 101.12,118.92 101.12,117.23 97.2,113.3 97.2,106.9 97.51,106.59 97.51,104.04 97.93,103.62 v2(98.16,103.62) ; v2(236.37,40.79) 236.93,41.35 236.93,47.5 235.28,49.15 v2(235.28,49.42) 236.18,49.42 237.05,50.29 237.05,57.79 v2(235.23,59.61)
  IN2 w0.381: v2(166.91,122.81) 166.81,122.71 165.81,122.71 164.74,123.78 156.18,123.78 155.1,124.86 v2(154.12,124.86)
  IN2 w0.508: v2(60.43,30.56) 60.9,30.56 61.7,29.77 61.7,26.91 60.52,25.74 60.52,21.5 59.94,20.91 58.2,20.91 57.25,19.96 54.64,19.96 53.91,19.23 v2(53.91,18.94) ; v2(229.26,26.44) 229.8,26.44 230.56,27.2 230.56,27.61 230.93,27.98 230.93,35.8 230.13,36.6 v2(229.29,36.6) ; v2(241.07,49.3) 241.29,49.08 247.23,49.08 247.92,48.39 247.92,46.97 248.32,46.57 v2(249.07,46.57) 249.2,46.57 251.11,48.48 251.11,49.23 250.63,49.71 v2(250.51,49.71) ; v2(203.14,144.15) 202.4,144.89 197.94,144.89 194.98,147.86 191.51,147.86 190.93,148.44 187.72,148.44 187,149.17 187,149.39 186.25,150.14 171.22,150.14 170.8,149.72 170.56,149.72 169.5,148.66 168.32,148.66 167.96,149.02 167.96,150.27 168.33,150.64 v2(168.33,150.65)
  IN3 w0.508: v2(186.42,93.69) 186.61,93.88 186.61,95.02 185.4,96.22 v2(185.4,101.87) ; v2(209.17,139.43) 209.17,140.22 207.15,142.23 204.11,142.23 203.42,142.92 203.42,143.87 v2(203.14,144.15) ; v2(306.35,30.18) 306.35,29.8 306.87,29.28 v2(306.87,29.04) ; v2(238.23,86.25) 237.34,86.25 235.2,88.4 234.47,88.4 v2(232.29,90.57) ; v2(203.99,100.59) 203.99,97.43 204.77,96.65 204.77,95.4 205.97,94.19 208.48,94.19 v2(208.64,94.03) ; v2(99.99,122.59) 103.01,122.59 104.25,121.36 104.25,118.74 104.88,118.1 108.13,118.1 108.41,117.83 v2(108.92,117.83) ; v2(168.33,150.65) 167.78,150.11 167.78,149.14 166.27,147.62 166.27,142.55 164.1,140.38 164.1,126.96 166.75,124.31 166.75,122.98 v2(166.91,122.81)
  IN4 w0.508: v2(329.97,58.95) 336.7,58.95 338.33,57.32 338.33,53.19 v2(340.19,51.33) ; v2(306.73,5.98) 309.57,8.81 309.57,27.87 v2(309.35,28.09)
  BOTTOM w0.203: PU1200.7 236.54,60.23 PC1212.1 ; PU1200.3 239.67,58.65 v2(239.56,58.54) ; PC1213.1 236.47,49.94 237.44,49.94 PU1201.7 ; v2(239.58,48.24) 239.67,48.34 PU1201.3 ; PC1258.1 236.5,39.26 236.77,39.52 PU1202.7 ; v2(239.54,37.5) 239.54,37.89 239.72,38.07 PU1202.3
  BOTTOM w0.254: PU1700.7 230.64,69.81 230.37,69.54 230.33,69.54 230.24,69.45
  BOTTOM w0.457: v2(210.67,92.98) 210.24,93.42 v3(209.41,93.42) v2(208.68,93.42)
  BOTTOM w0.508: PR210.2 57.43,22.56 55.97,22.56 55.33,21.93 PR203.1 55.33,21.57 54.44,20.68 54.44,19.95 53.91,19.41 v2(53.91,18.94) ; v2(306.35,30.18) 306.18,30.18 300.91,35.45 300.91,39.32 298.49,41.74 v2(298.41,41.74) ; PR1700.2 PC1704.1 ; PC1704.1 230.24,69.45 ; PC1704.1 229.02,69.45 v2(228.97,69.5) ; PU900.6 233.96,90.28 PC900.1 232.52,90.34 v2(232.29,90.57) ; v2(15.45,38.22) 15.45,30.22 12.3,27.07 v2(12.3,25.99) 13,25.29 13,22.18 11.09,20.28 11.09,18.23 v2(11.35,17.98) ; v2(98.16,103.62) 99.04,102.74 v3(99.04,102.64) 99.04,101.87 101.07,99.84 v3(101.07,98.19) 101.07,97.49 95.33,91.75 95.33,88.94 96.88,87.4 96.88,83.67 v2(99.36,81.2) ; JUART1.1 109.53,118.1 109.25,117.83 v2(108.92,117.83) ; PR1200.2 PC1212.1 v2(235.23,59.61) ; PR1209.2 235.98,38.26 PC1258.1 235.98,40.39 v2(236.37,40.79) ; v2(210.67,92.98) 211.85,94.17 211.85,96.53 213.8,98.47 213.8,99.36 214.27,99.84 214.27,101.02 214.67,101.43 214.67,101.87 215.8,103 215.8,103.41 216.85,104.46 217.09,104.46 217.72,105.09 217.72,106.8 217.42,107.1 217.31,107.1 216.16,108.25 215.73,108.25 215.27,108.71 215.27,110.25 215.81,110.8 215.81,116.43 215.94,116.56 215.94,116.81 216.2,117.07 216.2,120.39 217.81,122.01 v2(219.03,122.01) ; v2(60.43,30.56) 61.04,31.17 61.04,32.34 59.39,33.99 v2(58.98,33.99) ; v2(235.28,49.42) 235.31,49.45 PC1213.1 PR1203.2 ; v2(258.37,24.09) 258.3,24.02 v2(258.3,23.01)
  vias: v2(57.71,34.63) v2(57.71,33.99) v2(58.34,34.63) v2(58.34,33.99) v2(58.98,34.63) v2(208.09,93.47) v2(208.61,92.79) v2(208.59,92.2) v2(235.2,37.46) v2(235.45,16.25) v2(235.48,26.65) v2(241,59.57) v2(241.14,39.05) v2(262.74,32.21) v2(263.34,32.2) v2(306.24,29) v2(306.24,28.4) v2(306.87,28.4) v2(307.16,27.79) v2(307.51,29) v2(307.51,28.4) v2(307.7,27.52) v2(308.08,28.72) v2(308.08,28.09) v2(308.4,27.52) v2(308.72,28.72) v2(308.72,28.09) v2(309.35,28.72) v2(333.67,35.33) v2(333.82,37.31) v2(333.82,36.65) v2(333.79,35.99) v2(334.3,35.33) v2(334.43,37.31) v2(334.44,36.65) v2(334.43,35.99) v2(335.05,37.31) v2(334.95,35.33) v2(335.06,36.67) v2(335.06,36.01) v2(339.81,50.76) v2(340.45,50.76) v2(340.85,51.96) v2(340.83,51.33) v2(341.08,50.76) v2(341.48,51.96) v2(341.46,51.33) v2(341.72,50.76) v2(342.12,51.96) v2(342.1,51.33) v2(342.75,51.96) v2(344.97,51.9) v2(344.96,50.76) v2(345.34,51.33) v2(345.61,51.9) v2(345.59,50.76) v2(345.97,51.33) v2(346.24,51.9) v2(346.23,50.76) v2(346.61,51.33) v2(346.88,51.9) v2(346.86,50.76) v2(347.24,51.33)
+5V_ALW2: length 362.2
  TOP w0.203: PU101.13 PC118.1
  TOP w0.508: v2(353.1,18.05) 353.1,23.26 354.54,24.7 354.54,25.14 v1(354.54,25.14) 354.54,25.15 354.54,30.14 354.1,30.58 PC118.1 ; RZ72.1 v2(76.23,40.74)
  IN2 w0.508: v2(262.93,17.74) 262.93,22.48 261.26,24.15 261.26,26.87 260.14,28 260.14,31 258.8,32.33 254.91,32.33 254.53,32.71 249.29,32.71 248.7,32.12 248.7,18.37 246.68,16.34 242.9,16.34 240.11,19.12 235.28,19.12 234.78,18.61 229.86,18.61 229.38,18.13 224.97,18.13 223.69,16.85 209.91,16.85 205.78,20.98 202.23,20.98 198.13,16.88 188.61,16.88 187.3,15.58 181.65,15.58 180.72,14.65 176.5,14.65 171.31,19.83 166.91,19.83 164.75,17.67 160.7,17.67 160.32,18.05 v2(160.32,18.69)
  IN3 w0.508: v2(262.93,17.74) 262.93,17.48 263.59,16.82 271.96,16.82 273.79,14.99 273.84,14.94 283.32,14.94 284.4,14.94 285,15.55 297.79,15.55 300.12,13.23 311.29,13.23 312.62,14.56 327.07,14.56 327.77,15.26 327.77,16.15 328.21,16.59 334.13,16.59 335.65,18.12 335.65,20.78 337.19,22.32 350.55,22.32 353.1,19.77 v2(353.1,18.05) ; v2(76.23,40.74) 88.72,28.25 88.72,20.37 90.81,18.28 92.46,18.28 96.85,13.89 107.15,13.89 109.08,11.96 110.09,10.94 135.8,10.94 140.18,15.32 143.49,15.32 146.48,18.31 159.94,18.31 v2(160.32,18.69)
+5V_ALW2_R: length 3.8
  TOP w0.508: RZ72.2 73.77,40.74 v2(73.56,40.95) 73.56,40.92 73.18,41.3 JUSH1.10
+5V_HDD: length 39.9
  TOP w0.508: v2(10.22,39.95) R506.1
  IN3 w0.508: v2(10.22,39.95) 10.22,39.09 9.06,37.93 9.06,33.29 13.5,28.85 17.75,28.85 18.51,28.09 18.51,25.94 20.54,23.91 22.14,23.91 23.22,22.83 23.22,21.26 23.91,20.57 v2(25.69,20.57) 26.42,21.29 31.09,21.29 31.92,20.47 v2(32.24,20.47)
  BOTTOM w0.508: v2(25.69,20.57) v3(24.87,20.57)
  vias: v2(32.3,19.83) v2(32.81,20.15)
+5V_MXM:
  vias: v2(209.85,100.07) v2(210.24,99.64) v2(210.48,100.22) v2(210.82,89.25) v2(210.86,99.72) v2(211.31,99.33) v2(211.86,89.81) v2(211.86,89.21) v2(212.52,89.81) v2(212.49,89.2) v3(213.23,89.66)
+5V_MXM_PWR:
  vias: v1(208.02,97.33)
+5V_RUN: length 536.3
  TOP w0.508: 96.69,94.39 v2(95,94.39) ; 96.69,94.39 96.69,90.94 95.95,90.21 92.54,90.21 68.24,65.91 68.24,65.88 68.18,65.81 68.18,54.08 62.79,48.7 62.79,44.99 v2(62.31,44.51) ; 96.69,94.39 98.43,94.39 99.04,95 C30.1 99.03,96.21 C364.1 95.98,96.21 94.78,95.02 93.32,95.02 92.66,94.35 JFAN1.1 ; v2(63.8,42.06) 63.91,42.17 CZ10.1 64.74,42.18 66.02,42.18 66.63,42.8 JUSH1.7 ; v2(188.4,130.51) 188.19,130.51 187.43,129.75 187.43,126.91 187.98,126.36 187.98,124.9 187.55,124.47 187.55,122.94 188.54,121.95 191.17,121.95 191.94,121.18 191.94,120.94 ; JKBTP1.16 v2(296.06,27.85) 296.12,27.91 C1411.1 ; R3746.1 169.96,100.82 169.4,101.38 169.05,101.38 168.4,102.03 168.4,102.99 168.72,103.31 168.72,105.11 168.71,105.13 168.71,105.13 v2(168.72,105.13) ; JTS1.6 139.3,130.98 140.99,132.67 C310.1 141.2,131.86 v2(140.78,131.44)
  IN1 w0.508: v2(62.31,44.51) 62.31,43.55 v2(63.8,42.06)
  IN2 w0.508: v2(168.37,120.45) 168.31,120.51 164.55,120.51 163.72,121.34 162.73,121.34 162.47,121.08 154.02,121.08 151.98,123.12 150.96,123.12 150.54,122.7 145.86,122.7 v2(145.49,122.33) ; v2(188.4,130.51) 187.66,130.51 185.97,132.2 184.57,132.2 183.77,131.4 179.61,131.4 179.17,131.85 168.31,131.85 167.43,132.72 167.19,132.96 167.15,132.96 v2(167.09,133.03) 166.96,133.03 166.59,133.4 165.34,133.4 164.38,134.35 160.32,134.35 159.87,134.81 156.83,134.81 155.27,136.36 155.27,136.92 154.92,137.28 154.07,137.28 152.91,136.13 150.18,136.13 149.58,135.53 146.32,135.53 144.99,134.2 143.14,134.2 142.8,133.86 142.48,133.86 142.03,133.4 142.03,132.69 v2(140.78,131.44)
  IN2 w1.524: 74.15,9.8 76.08,9.8 78.72,12.44 78.76,12.4 103.05,12.4 104.16,13.51 111.84,13.51 113.07,12.28 119.24,12.28 119.56,11.96 139.01,11.96 139.94,12.89 149.02,12.89 ; 161.15,12.78 162.19,11.73 162.91,11.73 164.33,10.31 185.82,10.31 187.66,8.47 190.79,8.47 194.92,4.34 227.75,4.34 229.25,5.85 239.93,5.85 240.65,5.13
  IN3 w0.381: v2(145.49,122.33) 145.35,122.33 144.26,123.41 144,123.41 142.85,124.56 142.85,125.76 141.39,127.22 141.39,129.54 141.44,129.59 141.44,130.78 v2(140.78,131.44)
  IN3 w0.508: v2(96.72,104.91) 97.08,105.27 97.08,113.28 95.18,115.18 93.1,115.18 91.01,117.27 91.01,125.06 97.79,131.85 97.79,132.2 98.15,132.56 98.15,135.58 98.99,136.42 106.63,136.42 107.71,137.5 111.1,137.5 111.36,137.75 112.37,137.75 113.31,138.69 113.31,140.7 113.67,141.05 115.15,141.05 117.15,139.05 117.15,138.62 120.29,135.48 121.29,135.48 122.05,134.72 130.91,134.72 132.66,132.98 134.38,132.98 135.65,131.71 140.52,131.71 v2(140.78,131.44) ; v2(63.8,42.06) 63.8,41.36 60.3,37.87 60.3,37.35 v2(58.69,35.74) 55.91,35.74 55.06,34.88 53.04,34.88 52.06,33.9 52.06,29.87 50.54,28.34 45.93,28.34 44.33,29.94 43.41,29.94 42.57,29.1 41.57,29.1 41.21,29.46 40.49,29.46 40.04,29.01 40.04,27.6 39.37,26.93 39.37,25.17 40.19,24.35 40.19,23.21 38.82,21.84 38.82,15.92 38.46,15.56 v2(38.46,12.34)
  BOTTOM w0.508: v2(95,94.39) 95,94.42 97.01,96.43 97.01,100.48 96.09,101.39 96.09,104.23 96.12,104.26 96.12,104.3 v2(96.72,104.91) 96.75,104.94 v3(96.75,105.62) ; v2(168.37,120.45) 168.37,120.03 166.74,118.41 166.74,110.84 168.38,109.2 168.38,108.07 169.02,107.43 169.02,106.69 168.6,106.27 168.6,105.76 168.74,105.62 168.74,105.15 168.72,105.13 v2(168.72,105.13) ; v2(167.09,133.03) 167.11,133.05 R721.1 ; R2189.1 145.86,122.7 v2(145.49,122.33)
  vias: v2(38.08,11.75) v2(38.79,11.75) v2(39.2,12.31) v2(282.83,43.91) v2(283.42,43.91) v2(300.4,24.66) v2(300.91,24.98) v2(301.35,24.59) v2(301.79,24.98) v2(302.24,24.59) v2(302.68,24.98) v2(313.45,19.9) v2(313.45,19.31) v2(313.46,20.51) v2(314.03,19.9) v2(314.06,20.53) v2(316.24,23.18) v2(316.31,22.56) v2(316.84,22.94)
+5V_RUN_PWR:
  vias: v1(301.53,26.88)
+5VALWP: length 36.7
  IN4 w0.508: v2(351.37,47.33) 352.43,47.33 354.45,45.3 354.45,32 354.16,31.71 v2(353.15,31.71)
  BOTTOM w0.254: PC121.1 353.9,45.62 354.6,44.92 354.6,36.97 v1(353.92,36.29) 352.5,34.87 350.65,34.87 349.51,33.73 PR101.2
+V0.95SP_B+:
  vias: v1(333.68,12.24)
+VBUS_DC_SS: length 392.8
  TOP w0.254: JIO2.17 54.93,26.35 v2(54.53,26.75) ; PR768.1 v2(33.38,40.41) 34.52,40.41 34.78,40.15 PD704.2 ; PD702.3 287.92,40.51 288.97,39.46 v2(288.97,39.11) 288.97,38.58 287.43,37.04 280.14,37.04 278.3,38.88 277.98,38.88 276.97,39.9 274.24,39.9 v2(272.18,41.96) ; PD1103.2 322.77,44.55 v2(322.87,44.65)
  IN2 w0.254: v2(33.38,40.41) 33.38,38.58 39.41,32.55 39.41,25.83 40.86,24.38 40.86,22.94 41.32,22.49 41.32,21.45 43.54,19.23 47.45,19.23 v2(47.95,18.72)
  IN3 w0.254: v2(272.18,41.96) 272.18,40.89 271.5,40.22 270.43,40.22 268.77,38.56 266.84,38.56 266.52,38.25 266.52,36.73 265.85,36.06 265.85,28.35 267.57,26.63 267.57,25.22 264.44,22.1 264.44,20.86 261.79,18.21 261.79,16.87 254.1,9.18 251.83,9.18 v2(251.82,9.16) ; v2(288.97,39.11) 288.97,39.57 289.86,40.46 289.86,43.65 291.38,45.17 301.51,45.17 301.83,44.85 307.54,44.85 307.94,44.45 307.94,42.17 309.42,40.69 310.6,40.69 312.07,42.16 317.62,42.16 320.65,45.19 322.33,45.19 v2(322.87,44.65)
  IN4 w0.254: v2(251.82,9.16) 251.25,8.59 250,8.59 247.43,6.02 246.4,6.02 246.05,6.36 242.85,6.36 242.31,5.82 242.31,4.34 241.86,3.89 238.61,3.89 237.15,5.36 227.49,5.36 226.29,4.16 179.3,4.16 179.12,3.97 142.49,3.97 138.38,8.08 115.07,8.08 112.5,5.51 50.36,5.51 46.34,9.53 46.34,17.11 v2(47.95,18.72) 50.14,20.91 51.1,20.91 52.87,22.69 52.87,25.99 53.64,26.75 v2(54.53,26.75)
  BOTTOM w0.254: PD1101.2 266.42,43.07 266.81,43.45 v1(268.46,43.45) 270.11,43.45 270.63,42.93 PR1034.1 270.79,41.96 v2(272.18,41.96)
+VCC_CORE: length 57.4
  TOP w0.089: CPU1.P31 v2(194.08,56.2)
  TOP w0.203: v2(180.48,53.39) 180.15,53.05 CPU1.V14 ; CPU1.W35 v2(196.03,52.27) ; CPU1.AF37 197.66,46.43 v2(197.99,46.76) 198.31,46.43 CPU1.AF38 ; v2(196.68,48.33) CPU1.AD36 ; v2(196.68,48.33) CPU1.AC36 ; v2(196.68,48.33) CPU1.AD35 ; CPU1.AC33 v2(194.73,49.12) CPU1.AC32 ; CPU1.W29 CPU1.W30 v2(193.44,52.27) CPU1.W31 ; CPU1.AA38 198.31,50.37 v2(198.64,50.69) ; CPU1.P30 CPU1.P29 192.39,55.79 v2(191.87,55.79) ; CPU1.T35 v2(196.68,54.63) CPU1.T36 ; CPU1.AF35 v2(196.68,46.76) CPU1.AF36 ; CPU1.AD34 v2(195.38,48.33) CPU1.AD33 ; v2(194.08,51.48) CPU1.W32 ; v2(194.08,51.48) CPU1.Y32 ; v2(194.08,51.48) CPU1.Y31 ; CPU1.Y34 v2(196.03,50.69) ; v2(196.03,50.69) CPU1.AA34 ; v2(196.03,50.69) CPU1.AA35 ; CPU1.R33 v2(194.73,55.42) CPU1.R32 ; CPU1.N36 v2(196.68,56.2) CPU1.N35 ; CPU1.AE30 193.14,47.07 193.69,47.07 CPU1.AE31 ; CPU1.Y35 v2(196.68,51.48) CPU1.Y36 ; CPU1.U33 v2(194.73,53.84) CPU1.U32 ; CPU1.W38 198.31,51.95 v2(198.64,52.27) ; CPU1.R34 v2(196.03,55.42) CPU1.R35 ; CPU1.AC29 CPU1.AC30 193.06,48.74 v2(193.44,49.12) ; CPU1.Y29 CPU1.Y30 ; CPU1.AB37 v2(197.99,49.91) CPU1.AB38 ; CPU1.R36 v2(197.33,55.42) CPU1.R37 ; CPU1.U34 v2(196.03,53.84) CPU1.U35 ; CPU1.AA37 v2(197.33,50.69) CPU1.AA36 ; v2(194.08,49.91) CPU1.AB32 ; v2(194.08,49.91) CPU1.AA31 ; v2(194.08,49.91) CPU1.AB31 ; CPU1.AE35 v2(196.03,47.54) ; CPU1.R38 198.64,54.7 v2(198.64,54.63) ; CPU1.AB36 v2(196.68,49.91) CPU1.AB35 ; v2(193.44,49.12) CPU1.AB30 CPU1.AB29 ; v2(193.44,49.12) CPU1.AC31 ; CPU1.K13 179.61,59.49 v2(179.61,58.95) 179.72,59.06 CPU1.K14 ; CPU1.V35 v2(196.68,53.05) CPU1.V36 ; CPU1.T31 v2(194.08,54.63) CPU1.T32 ; CPU1.V32 v2(194.08,53.05) CPU1.V31 ; v2(194.08,46.76) CPU1.AE32 ; v2(194.73,50.69) CPU1.AA32 ; v2(194.73,50.69) CPU1.Y33 ; v2(194.73,50.69) CPU1.AA33 ; CPU1.AD37 v2(197.99,48.33) CPU1.AD38 ; v2(198.64,47.54) 198.31,47.22 CPU1.AE38 ; CPU1.W37 v2(197.33,52.27) CPU1.W36 ; CPU1.U36 197.03,53.47 v2(197.33,53.84) ; CPU1.AE36 v2(197.33,47.54) CPU1.AE37 ; CPU1.AC34 v2(196.03,49.12) CPU1.AC35 ; CPU1.V33 v2(195.38,53.05) CPU1.V34 ; v2(198.64,53.05) 198.31,52.73 CPU1.V38 v2(197.99,53.05) 197.74,52.75 CPU1.V37 ; CPU1.AD31 v2(194.08,48.33) CPU1.AD32 ; CPU1.W13 CPU1.W14 180.15,51.89 v2(180.48,51.56) ; CPU1.T38 v2(197.99,54.63) CPU1.T37
  TOP w0.254: CPU1.T30 193.06,54.22 v2(193.44,53.84) ; CPU1.P14 180.15,55.78 v2(179.82,56.11) ; v2(193.44,53.84) 193.76,53.52 CPU1.U31 ; v2(193.44,53.84) 193.06,53.46 CPU1.U30 CPU1.U29 ; CPU1.P13 179.5,55.52 v2(179.82,55.2) ; CPU1.N13 179.5,56.66 v2(179.82,56.99) 180.15,56.66 CPU1.N14 ; CPU1.L14 180.15,58.25 v2(180.49,57.91)
  BOTTOM w0.508: PR1119.1 219.37,42.37 220.07,43.07
  vias: v2(185.05,54.65) v2(185.62,52.56) v2(185.68,50.78) v2(185.75,49.06) v2(187.46,54.84) v2(187.46,53.38) v2(187.53,51.73) v2(187.53,50.21) v2(187.53,48.81) v2(189.3,54.02) v2(189.3,52.56) v2(189.3,51.03) v2(189.3,49.57) v2(189.3,48.11) v2(191.08,54.84) v2(191.08,53.32) v2(191.08,51.79) v2(191.08,50.33) v2(191.08,48.87) v2(191.1,47.51) v2(191.88,51.23) v2(193.44,56.2) v2(198.65,56.2) v2(203.64,46.27) v2(204.96,45.42) v2(206.18,46.46) v2(208.36,55.99) v2(208.36,53.33) v2(208.36,50.66) v2(208.42,47.99) v2(209.56,57.39) v2(209.63,54.66) v2(209.63,52.06) v2(209.63,49.33) v2(209.63,46.72) v2(210.77,58.91) v2(210.77,55.99) v2(210.77,53.39) v2(210.9,50.66) v2(210.96,47.99) v2(211.42,53.93) v2(212.43,51.33) v2(212.43,48.72) v2(212.43,46.12) v2(214.34,53.93) v2(215.35,51.33) v2(215.35,48.72) v2(215.35,46.12) v2(216.8,50.6) v2(216.93,49.07) v2(216.93,47.8) v2(216.99,46.53) v2(218.07,49.9) v2(218.13,48.37) v2(218.2,47.17) v2(218.2,45.77) v2(219.28,50.53) v2(219.28,49.07) v2(219.4,47.8) v2(219.4,46.53) v2(219.53,45.07) v2(224.77,43.64) v2(224.77,43.01) v2(224.77,42.37) v2(224.77,41.72) v2(225.4,43.64) v2(225.4,43.01) v2(225.4,42.37) v2(225.4,41.74) v2(226.4,49.93) v2(226.42,49.3) v2(226.53,65.81) v2(226.55,65.17) v2(226.53,60.15) v2(226.55,59.52) v2(226.47,56.15) v2(226.48,55.52) v2(226.47,45.99) v2(226.48,45.36) v2(227.12,56.15) v2(227.12,55.52) v2(227.05,49.93) v2(227.05,49.3) v2(227.12,45.99) v2(227.12,45.36) v2(227.18,65.81) v2(227.18,65.17) v2(227.18,60.15) v2(227.18,59.52) v2(227.69,49.93) v2(227.69,49.3) v2(227.82,65.81) v2(227.82,65.17) v2(227.82,60.15) v2(227.82,59.52) v2(227.75,56.15) v2(227.75,55.52) v2(227.75,45.99) v2(227.75,45.36) v2(228.32,49.93) v2(228.32,49.3) v2(228.39,56.15) v2(228.39,55.52) v2(228.39,45.99) v2(228.39,45.36) v2(228.45,65.81) v2(228.45,65.17) v2(228.45,60.15) v2(228.45,59.52) v3(222.62,43.05)
+VCC_EDRAM: length 9.5
  TOP w0.203: CPU1.BK17 CPU1.BJ17 ; CPU1.BL16 182.4,27.01 182.54,27.01 CPU1.BM17 182.79,26.69 v2(182.47,26.36) 182.8,26.04 CPU1.BN17 ; CPU1.BL18 183.58,27.34 v2(183.25,27.01) 183.19,27.01 CPU1.BL17
  TOP w0.254: v2(183.24,27.63) 182.89,27.99 CPU1.BK17 182.83,27.99 v2(182.47,27.63) 182.76,27.34 CPU1.BL17 ; CPU1.BL20 185.51,27.62 v2(185.61,27.62) ; CPU1.BJ19 184.44,28.96 v2(184.66,29.18) 185.2,28.64 CPU1.BJ20 ; CPU1.BK20 185.25,27.99 v2(185.61,27.62) ; CPU1.BL19 184.73,27.63 v2(184.83,27.63) 184.48,27.99 CPU1.BK19 ; CPU1.BL21 185.72,27.62 v2(185.61,27.62)
  vias: v2(82.77,7.32) v2(82.77,6.69) v2(83.4,7.32) v2(83.4,6.69) v2(84.04,7.32) v2(84.04,6.69) v2(84.67,7.32) v2(84.67,6.69) v2(85.31,7.32) v2(85.31,6.69) v2(185.95,19.7) v2(186.52,7.32) v2(187.16,7.32) v2(187.59,23.31) v2(187.59,21.41) v2(187.79,7.32) v2(188.43,7.32) v2(189.06,7.32) v2(189.7,7.32) v2(190.35,7.32) v3(185.38,12.59)
+VCC_EDRAM_ED2: length 3.2
  TOP w0.305: CPU1.BM24 CPU1.BL24
  BOTTOM w0.254: RC173.1 v3(187.05,31.16) 187.09,31.12 187.09,29.96 v2(187.17,29.88)
+VCC_EDRAM_FUSEPRG: length 34.4
  TOP w0.203: CPU1.BL14 180.43,27.34 v2(180.1,27.01)
  IN4 w0.508: v2(178.48,17.04) 178.16,17.04 178.03,16.91 178.03,13.91 179.69,12.25 179.69,12.14 180.25,11.58 181.21,11.58 182.1,12.47 182.1,13.29 181.78,13.61 181.78,23.77 183.94,25.93 183.94,27.77 183.37,28.34 180.95,28.34 180.1,27.49 v2(180.1,27.01)
  BOTTOM w0.508: RH253.2 177.18,15.42 177.46,15.7 177.46,16.87 v1(177.86,17.27) 178.25,17.27 v2(178.48,17.04)
+VCC_EDRAM_FUSEPRG_ED2: length 13.3
  TOP w0.254: v2(197.33,28.65) 197.01,28.32 CPU1.BJ36
  TOP w0.508: RC226.1 199.43,20.11 v2(199.48,20.15)
  IN3 w0.508: v2(197.33,28.65) 197.33,28.28 197.84,27.77 199.31,27.77 200.7,26.37 200.7,21.05 199.81,20.15 v2(199.48,20.15)
+VCC_EDRAM_P: length 14.2
  TOP w0.127: v2(70.34,13.61) 70.34,14.35 v1(70.87,14.88)
  TOP w0.508: v2(70.34,13.61) 70.34,13.61 PR505.1
  IN4 w0.508: v2(70.34,13.61) 71.86,12.09 80.18,12.09 80.81,11.45 v2(80.81,10.75)
+VCC_EOPIO: length 1.6
  TOP w0.254: CPU1.BP15 181.4,25.39 181.55,25.24 181.55,25 CPU1.BR15 CPU1.BT15
  vias: v2(65.89,9.04) v2(66.27,7.77) v2(66.53,9.04) v2(179.75,19.77) v2(179.67,19.01) v2(179.72,17.74) v2(180,20.4) v2(182.29,8.97) v2(182.92,8.97) v2(183.56,8.97) v2(184.19,8.97) v4(65.26,9.04) v4(65.26,8.4) v4(65.57,7.77) v4(65.89,8.4) v4(66.53,8.4)
+VCC_EOPIO_ED2: length 9.5
  TOP w0.254: RC175.2 181.17,18.48 181.46,18.77 v1(181.46,19.73) 181.46,22.36 182.03,22.93 182.03,24.04 CPU1.BT16 CPU1.BR16 CPU1.BP16
+VCC_EOPIO_P: length 14
  TOP w0.254: PR1805.1 52.47,13.55 v1(52.63,13.71) 52.79,13.86 v2(53.45,13.86)
  IN1 w0.254: v2(53.45,13.86) 55.85,13.86 58.77,10.94 61.95,10.94 62.76,10.14 v2(62.76,8.92)
+VCC_GT: length 83.4
  TOP w0.089: v2(179.82,40.56) 179.5,40.24 CPU1.AP13
  TOP w0.203: CPU1.AK31 193.76,43.28 v2(194.08,43.61) ; v2(196.68,34.16) 196.36,33.84 CPU1.BB35 ; v2(196.68,34.16) 197.01,34.49 CPU1.BA36 ; v2(196.68,34.16) 197.01,33.83 CPU1.BB36 ; CPU1.BE34 195.71,31.47 v2(196.03,31.79) 196.36,31.47 CPU1.BE35 ; CPU1.AM36 197.01,41.7 v2(196.68,42.03) 196.36,41.71 CPU1.AM35 ; CPU1.AW35 196.36,36.19 v2(196.03,36.52) 195.71,36.2 CPU1.AW34 ; CPU1.AN32 194.41,40.92 v2(194.73,41.24) ; CPU1.BA31 193.76,34.62 v2(193.44,34.94) ; CPU1.BE37 197.66,31.47 v2(197.33,31.79) 197.01,31.47 CPU1.BE36 ; CPU1.AT31 193.76,38.56 v2(194.08,38.88) 194.41,38.55 CPU1.AT32 ; CPU1.AN31 193.76,40.92 v2(193.44,41.24) 193.76,41.57 CPU1.AM31 ; v2(194.08,38.11) 194.41,37.78 CPU1.AU32 ; v2(180.46,33.25) 180.15,33.56 CPU1.BB14 ; CPU1.AL37 197.66,42.49 v2(197.33,42.82) 197.01,42.5 CPU1.AL36 ; CPU1.AT36 197.01,38.55 v2(196.68,38.88) ; v2(196.68,38.88) 196.36,38.56 CPU1.AT35 ; v2(196.68,38.88) 197.01,39.21 CPU1.AR36 ; CPU1.AP31 194.08,40.38 v2(194.08,40.46) 194.41,40.13 CPU1.AP32 ; CPU1.AM14 180.15,41.8 v2(179.82,41.48) 179.5,41.15 CPU1.AN13 ; CPU1.BC38 198.31,33.05 v2(198.64,33.37) ; CPU1.AW36 197.01,36.2 v2(197.33,36.52) 197.66,36.19 CPU1.AW37 ; v2(180.66,33.91) 180.15,34.43 CPU1.BA14 ; CPU1.AT34 195.71,38.55 v2(195.38,38.88) 195.06,38.56 CPU1.AT33 ; CPU1.AW33 195.06,36.19 v2(194.73,36.52) 194.41,36.2 CPU1.AW32 ; CPU1.BD33 195.06,32.26 v2(195.38,32.58) 195.71,32.25 CPU1.BD34 ; CPU1.AJ29 CPU1.AJ30 193.06,44.01 v2(193.44,44.39) 193.76,44.07 CPU1.AJ31 194.08,43.68 v2(194.08,43.61) ; CPU1.BN36 197,25.71 v2(196.84,25.55) ; CPU1.BA35 196.36,34.62 v2(196.03,34.94) 195.71,34.62 CPU1.BA34 ; v2(194.08,43.61) 194.41,43.28 CPU1.AK32 ; CPU1.AU29 191.91,37.2 v2(191.91,36.67) ; CPU1.BE32 194.41,31.47 v2(194.73,31.79) 195.06,31.47 CPU1.BE33 ; CPU1.BF38 198.31,30.68 v2(197.99,31.01) 197.66,30.69 CPU1.BF37 ; CPU1.AN38 198.31,40.92 v2(198.64,41.24) ; CPU1.AK36 197.01,43.28 v2(196.68,43.61) 196.36,43.28 CPU1.AK35 ; CPU1.BF36 197.01,30.68 v2(196.68,31.01) 196.36,30.69 CPU1.BF35 ; CPU1.BB33 195.06,33.84 v2(195.38,34.16) 195.71,33.83 CPU1.BB34 ; v2(194.73,41.24) 195.06,40.91 CPU1.AN33 ; v2(194.73,41.24) 194.41,41.57 CPU1.AM32 ; v2(194.73,41.24) 195.06,41.57 CPU1.AM33 ; CPU1.AR32 194.41,39.35 v2(194.73,39.67) 195.06,39.34 CPU1.AR33 ; CPU1.AV36 197.01,36.98 v2(196.68,37.31) 196.36,36.99 CPU1.AV35 ; CPU1.AV31 193.76,36.99 v2(194.08,37.31) 194.41,36.98 CPU1.AV32 ; CPU1.AT37 197.66,38.56 v2(197.99,38.88) 198.31,38.55 CPU1.AT38 ; CPU1.AN35 196.36,40.91 v2(196.03,41.24) 195.71,40.92 CPU1.AN34 ; CPU1.AY31 193.76,35.41 v2(194.08,35.73) 194.41,35.4 CPU1.AY32 ; v2(198.64,36.52) 198.31,36.2 CPU1.AW38 ; CPU1.BF31 193.76,30.69 v2(194.08,31.01) 194.41,30.68 CPU1.BF32 ; CPU1.AV33 195.06,36.99 v2(195.38,37.31) 195.71,36.98 CPU1.AV34 ; CPU1.AL38 198.31,42.5 v2(198.64,42.82) ; v2(196.03,42.82) 196.36,42.49 CPU1.AL35 ; CPU1.BG34 195.71,29.9 v2(196.03,30.22) 196.36,29.89 CPU1.BG35 ; CPU1.BA33 195.06,34.62 v2(194.73,34.94) 194.41,34.62 CPU1.BA32 ; CPU1.AY36 197.01,35.4 v2(196.68,35.73) 196.36,35.41 CPU1.AY35 ; CPU1.AU36 197.01,37.77 v2(197.33,38.09) ; CPU1.AU30 193.06,37.71 v2(193.44,38.09) 193.76,37.77 CPU1.AU31 ; CPU1.BC37 197.66,33.04 v2(197.33,33.37) 197.01,33.05 CPU1.BC36 ; CPU1.AN36 197.01,40.92 v2(197.33,41.24) 197.66,40.91 CPU1.AN37 ; CPU1.AL31 194.08,42.1 v2(194.08,42.03) 194.41,42.36 CPU1.AL32 194.41,42.5 v2(194.73,42.82) ; CPU1.AR35 196.36,39.34 v2(196.03,39.67) 195.71,39.35 CPU1.AR34 ; CPU1.AP37 197.66,40.14 v2(197.99,40.46) 198.31,40.13 CPU1.AP38 ; CPU1.AN14 180.65,41.02 v2(180.67,41) ; CPU1.BD32 194.41,32.25 v2(194.08,32.58) 193.76,32.9 CPU1.BC31 ; CPU1.BB37 197.66,33.84 v2(197.99,34.16) 198.31,33.83 CPU1.BB38 ; v2(198.64,31.79) 198.31,31.47 CPU1.BE38 ; CPU1.AY37 197.66,35.41 v2(197.99,35.73) 198.31,35.4 CPU1.AY38 ; v2(194.73,30.22) 195.06,29.89 CPU1.BG33 ; CPU1.AP36 197.01,40.13 v2(196.68,40.46) 196.36,40.14 CPU1.AP35 ; 191.91,39.67 192.27,40.06 CPU1.AP29 ; CPU1.BD36 197.01,32.25 v2(196.68,32.58) 196.36,32.26 CPU1.BD35 ; CPU1.AJ32 194.41,44.07 v2(194.73,44.39) 195.06,44.06 CPU1.AJ33 ; CPU1.BB31 193.76,33.84 v2(194.08,34.16) 194.41,33.83 CPU1.BB32 ; CPU1.AP14 180.15,40.06 v2(180.6,39.6) ; CPU1.BF30 193.06,30.6 v2(193.44,30.22) ; CPU1.AR30 193.06,39.29 v2(193.44,39.67) 193.76,39.35 CPU1.AR31 ; CPU1.AK38 198.31,43.28 v2(197.99,42.82) ; v2(197.95,28.65) 197.66,28.36 CPU1.BJ37 ; CPU1.AK34 195.71,43.28 v2(195.38,43.61) 195.06,43.28 CPU1.AK33 ; CPU1.BH37 197.66,29.11 v2(197.99,29.43) 198.31,29.1 CPU1.BH38 198.31,29.03 v2(198.7,28.65) 198.36,28.3 CPU1.BJ38 ; CPU1.AJ34 195.71,44.07 v2(196.03,44.39) 196.36,44.06 CPU1.AJ35 ; CPU1.BG29 192.27,29.83 v2(191.83,30.22) 192.27,30.61 CPU1.BF29
  TOP w0.254: CPU1.AU38 198.21,37.8 197.77,37.8 CPU1.AU37 197.66,37.77 v2(197.33,38.09) ; CPU1.BH34 196.03,29.36 v2(196.03,29.43) 196.36,29.1 CPU1.BH35 ; CPU1.BG29 CPU1.BG30 193.06,29.84 v2(193.44,30.22) 193.76,29.9 CPU1.BG31 194.08,29.51 v2(194.08,29.43) CPU1.BG32 ; v2(195.38,29.41) 195.06,29.1 CPU1.BH33 ; CPU1.BG36 197.01,29.76 v2(196.68,29.43) 197.01,29.1 CPU1.BH36 ; CPU1.BA29 CPU1.BA30 193.06,34.57 v2(193.44,34.94) ; CPU1.BD13 179.5,32.01 v2(179.82,32.34) 180.15,32.01 CPU1.BD14
  vias: v2(182.64,40.17) v2(182.72,36.78) v2(183.27,40.17) v2(183.35,36.78) v2(183.84,40.17) v2(183.93,36.78) v2(184.48,40.17) v2(184.49,36.78) v2(185.11,40.17) v2(185.13,36.78) v2(185.14,33.55) v2(185.14,32.85) v2(185.14,32.15) v2(187.21,42.84) v2(187.21,41.44) v2(187.21,40.11) v2(187.21,38.65) v2(187.21,37.25) v2(187.21,35.86) v2(187.21,34.46) v2(188.29,33.37) v2(188.92,36.55) v2(188.99,42.21) v2(188.99,40.81) v2(188.99,39.35) v2(188.99,38.02) v2(188.99,35.22) v2(189.05,33.89) v2(190.33,33.37) v2(190.76,42.78) v2(190.76,41.51) v2(190.76,40.05) v2(190.76,38.71) v2(190.76,37.32) v2(190.76,35.86) v2(191.78,42.14) v2(191.91,33.37) v2(191.91,32.56) v2(191.91,31.92) v2(193.44,32.58) v2(198.64,34.94) v2(202.8,41.93) v2(203.7,41.95) v2(208.42,37.96) v2(208.42,35.16) v2(208.42,27.23) v2(208.48,32.43) v2(208.48,29.77) v2(209.63,33.83) v2(209.69,39.04) v2(209.69,36.56) v2(209.69,25.89) v2(209.75,31.1) v2(210.9,35.23) v2(210.9,32.43) v2(211.02,29.77) v2(210.96,27.23) v2(212.29,38.09) v2(212.29,35.04) v2(212.29,32.18) v2(212.29,29.2) v2(213.07,11.89) v2(213.07,11.01) v2(213.83,11.89) v2(213.83,11.01) v2(215.1,12.85) v2(215.73,12.85) v2(216.37,12.85) v2(217,12.85) v2(218.72,13.99) v2(218.72,13.36) v2(218.72,12.72) v2(218.72,12.09) v2(219.35,13.99) v2(219.35,13.36) v2(219.35,12.72) v2(219.35,12.09) v2(220.5,36.09) v2(220.5,35.45) v2(220.5,31.14) v2(220.5,30.5) v2(220.5,25.93) v2(220.5,25.29) v2(220.5,20.98) v2(220.5,20.34) v2(220.5,15.77) v2(220.5,15.13) v2(221.13,36.09) v2(221.13,35.45) v2(221.13,31.14) v2(221.13,30.5) v2(221.13,25.93) v2(221.13,25.29) v2(221.13,20.98) v2(221.13,20.34) v2(221.13,15.77) v2(221.13,15.13) v2(221.77,36.09) v2(221.77,35.45) v2(221.77,31.14) v2(221.77,30.5) v2(221.77,25.93) v2(221.77,25.29) v2(221.77,20.98) v2(221.77,20.34) v2(221.77,15.77) v2(221.77,15.13) v2(222.4,36.09) v2(222.4,35.45) v2(222.4,31.14) v2(222.4,30.5) v2(222.4,25.93) v2(222.4,25.29) v2(222.4,20.98) v2(222.4,20.34) v2(222.4,15.77) v2(222.4,15.13) v3(217.13,18.76)
+VCC_GTU: length 17.1
  TOP w0.203: v2(196.03,45.97) CPU1.AF34 ; v2(196.03,45.97) CPU1.AG34 ; v2(196.03,45.97) CPU1.AG35 196.36,45.65 v2(196.68,45.97) 197.01,45.64 197.01,45.58 CPU1.AG36 ; v2(194.08,45.18) CPU1.AG31 ; v2(194.08,45.18) CPU1.AH31 ; v2(194.08,45.18) CPU1.AH32 ; CPU1.AH29 191.88,44.79 ; CPU1.AF29 191.88,46.36
  TOP w0.254: CPU1.AG33 195.06,45.64 v2(194.73,45.97) ; CPU1.AF33 195.06,46.3 v2(194.73,45.97) ; v2(194.73,45.97) 194.41,46.29 CPU1.AF32 ; v2(194.73,45.97) 194.41,45.65 CPU1.AG32 ; v2(202.44,44.57) 202.44,44.55 202.54,44.44 PR1621.1 ; CPU1.AF30 CPU1.AF29 ; CPU1.AH30 CPU1.AH29
  TOP w0.305: v2(180.46,46.05) 180.15,45.74 CPU1.AG14 CPU1.AG13
  BOTTOM w0.254: 196.7,45.49 197.46,45.49 197.72,45.74 198.86,45.74 200.13,44.47 202.34,44.47 v2(202.44,44.57)
  vias: v2(180.46,45.14) v2(180.46,44.22) v2(183.84,46.02) v2(185.05,45.44) v2(186.32,46.08) v2(186.32,44.87) v2(187.59,45.51) v2(188.92,46.08) v2(188.92,45) v2(189.88,46.71) v2(189.88,45.13) v2(191.34,21.41) v2(191.58,44.22) v2(193.1,22.68) v2(203.94,11.96) v2(204.58,11.96) v2(204.58,11.32) v2(205.21,11.96) v2(205.21,11.32) v2(205.21,10.69) v2(205.21,10.05) v2(205.85,11.96) v2(205.85,11.32) v2(205.85,10.69) v2(205.85,10.05) v2(206.48,11.96) v2(206.48,11.32) v2(206.48,10.69) v2(206.48,10.05) v2(251.09,18.28) v2(251.09,17.64) v2(251.09,17.01) v2(251.09,16.37) v2(251.09,15.74) v2(251.09,15.1) v2(251.73,18.28) v2(251.73,17.64) v2(251.73,17.01) v2(251.73,16.37) v2(251.73,15.74) v2(252.36,18.28) v2(252.36,17.64) v2(252.36,17.01) v2(252.36,16.37) v2(252.36,15.74) v2(253.05,16.35) v2(253.03,15.73) v3(192.83,19.13)
+VCC_IO: length 139.1
  TOP w0.203: CPU1.H27 CPU1.J27 190.96,59.31 190.47,58.81 ; CPU1.H26 CPU1.J26 190.18,59.16 190.47,58.87 190.47,58.81 ; 190.47,58.81 v2(190.47,58.19) ; v2(179.2,46.05) 179.17,45.92 CPU1.AG12 ; v2(181.52,58.93) CPU1.J15 CPU1.H15
  TOP w0.305: v2(184.82,58.93) 184.67,59.08 CPU1.J19 CPU1.H19 CPU1.G19 ; v2(185.45,58.93) CPU1.J20 CPU1.H20 ; v2(186.07,58.76) 186.24,58.93 CPU1.J21 CPU1.H21 CPU1.G21 ; v2(183.09,58.93) CPU1.J17 CPU1.H17 CPU1.G17 ; v2(182.3,58.93) CPU1.J16 CPU1.H16 CPU1.H15 CPU1.G15
  TOP w0.508: v2(202.49,66.01) RC1.1 ; RC2.1 166.73,62.44 163.93,59.64 163.93,47.42 v2(164.2,47.15) ; RC132.2 161.52,15.34 161.02,15.84 160.89,15.84 v2(160.88,15.84)
  IN2 w0.508: v2(160.88,15.84) 160.88,15.7 160.44,15.26 159.55,15.26 159.24,15.58 159.24,23.26 168.43,32.45 174.46,32.45 175.3,33.29 175.3,46.44 174.54,47.2 164.25,47.2 v2(164.2,47.15)
  IN3 w0.254: v2(164.2,47.15) 164.6,47.55 174.17,47.55 175.2,46.52 178.73,46.52 v2(179.2,46.05)
  IN3 w0.508: v2(210.93,78.57) 210.63,78.57 209.85,79.35 200.53,79.35 199.38,80.5 199.38,84.35 198.99,84.74 198.99,88.53 199.37,88.91 199.37,90 201.11,91.74 201.11,92.92 200.54,93.49 200.06,93.49 199.65,93.9 199.65,94.32 197.3,96.67 197.3,96.9 v2(197.27,96.92)
  BOTTOM w0.508: Q370.1 195.93,97.68 R435.1 197.27,97.57 v2(197.27,96.92)
  vias: v2(315.81,18.88) v2(315.81,18.24) v2(315.81,17.61) v2(315.81,16.97) v2(315.81,16.34) v2(316.45,18.88) v2(316.45,18.24) v2(316.45,17.61) v2(316.45,16.97) v2(316.45,16.34) v3(202.17,64.96)
+VCC_IOP: length 27.1
  TOP w0.254: PC304.1 333.84,24.52 PR311.1 v2(333.86,25.29)
  IN4 w0.254: v2(333.86,25.29) 333.86,25.24 330.61,21.99 324.95,21.99 323.94,20.98 318.05,20.98 317.29,20.21 316.42,20.21 315.32,19.11 315.32,15.96 315.95,15.32 v2(316.15,15.32)
  vias: v1(319.89,21.04)
+VCC_SA: length 11.9
  TOP w0.203: CPU1.L32 194.41,58.24 v2(194.08,58.57) 193.76,58.25 CPU1.L31 ; CPU1.L35 196.36,58.1 v2(196.68,57.78) 196.68,57.71 CPU1.M36 ; CPU1.M31 193.76,57.46 v2(194.08,57.78) 194.41,57.45 CPU1.M32 CPU1.M33 195.06,57.46 v2(195.38,57.78) 195.71,57.45 CPU1.M34 ; v2(191.87,57.34) 192.37,57.34 CPU1.M29 CPU1.M30 ; CPU1.K35 196.36,58.9 v2(196.03,58.57) 195.71,58.89 CPU1.K34 ; v2(198.89,58.41) 198.66,58.18 198.66,58.17 CPU1.L38
  TOP w0.254: CPU1.K33 195.06,58.9 v2(194.73,58.57) 194.41,58.89 CPU1.K32
  TOP w0.508: CC213.1 221.64,69.27 223.51,69.27 v2(223.63,69.4)
  vias: v2(197.33,58.57) v2(213.64,64.47) v2(214.53,64.47) v2(216.69,65.36) v2(217.13,65.81) v2(217.58,66.25) v2(218.02,66.7) v2(218.47,67.14) v2(218.91,67.52) v2(219.35,68.03) v2(219.8,68.47) v2(220.24,68.92) v2(220.69,69.36) v3(209.75,65.11)
+VCC_SFR_OC: length 84.2
  TOP w0.203: v2(179.2,29.59) 179.5,29.27 CPU1.BH13
  TOP w0.305: CPU1.G11 178.31,60.81 178.26,60.77 v2(177.97,60.49)
  BOTTOM w0.508: v2(91.7,17.67) 92.05,17.67 98.15,11.58 105.38,11.58 106.33,12.53 143.83,12.53 144.7,13.39 144.7,17.86 149.91,23.07 162.86,23.07 164.32,24.53
  vias: v3(165.23,24.03)
+VCC_VDDQ_CLK: length 17.6
  TOP w0.203: v2(178.56,51.54) 178.85,51.25 CPU1.Y12
  TOP w0.508: v2(165.91,54.87) 165.29,54.25 CC185.1
  IN3 w0.254: v2(165.91,54.87) 166.79,54.87 169.66,51.99 178.1,51.99 v2(178.56,51.54)
  BOTTOM w0.254: v2(178.56,51.54) 178.83,51.54 RC220.1
+VCCAUSB_VCCAAZPLL_1P0: length 1.7
  BOTTOM w0.089: v1(134.92,115.78) 134.92,116.1 135.74,116.92 RH240.1
AGND: length 9.3
  IN1 w0.508: v2(250.46,48.8) 252.62,48.8 255.17,46.25 v2(255.87,46.25)
  BOTTOM w0.508: PC1130.2 250.46,46.74 PC1128.1 PC1127.2 v2(250.46,48.8)
  vias: v2(255.87,44.09) v2(256.95,45.17) v2(258.22,46.25) v2(258.22,44.09) v3(256.69,46.6) v3(256.68,43.78) v3(259.27,43.47)
GND: length 5070.1
  TOP w0.089: 127.06,102.95 127.06,102.74 ; 127.64,99.64 127.36,99.35
  TOP w0.102: 127.06,102.95 127.06,103.23 127.32,103.49 UH1.D16 ; 127.06,102.74 127.06,102.48 127.06,102.48 127.06,102.41 127.09,102.39 127.09,102.16 127.11,102.15 127.11,102.05 127.16,101.99 127.16,100.91 127.64,100.43 127.64,99.64 ; 127.36,99.35 127.36,98 127.04,97.68 126.35,97.68 125.53,98.5 125.53,100.01 126.45,100.93 v2(126.45,101.67)
  TOP w0.152: 121.29,115.04 UH1.AF29 121.29,114.26 ; 121.29,115.04 UH1.AF28 ; 121.29,115.04 UH1.AH28 ; 121.29,115.04 UH1.AH29 v2(121.29,115.81) ; UH1.AE20 125.16,114.26 ; UH1.AE20 v2(125.94,113.49) ; UH1.AE20 v2(125.94,114.26) ; UH1.AE20 v2(125.16,113.49) ; 125.16,114.26 UH1.AF21 ; 125.16,114.26 UH1.AE21 ; 125.16,114.26 UH1.AF20 ; UH1.AC21 v2(124.39,113.49) UH1.AE21 ; UH1.AC21 v2(124.39,112.71) UH1.AA21 ; UH1.AC21 125.1,112.77 v2(125.16,112.71) ; UH1.AC21 v2(125.16,113.49) ; UH1.AJ15 UH1.AJ17 v2(126.71,115.81) ; UH1.AJ15 UH1.AJ14 ; UH1.AJ15 UH1.AH17 v2(126.71,115.81) ; UH1.AF21 124.39,114.26 ; UH1.AF21 124.39,115.04 ; UH1.AF21 125.16,115.04 ; v2(126.71,115.81) UH1.AJ18 v2(125.94,115.81) ; v2(126.71,115.81) UH1.AH18 ; UH1.AE28 121.29,113.49 ; UH1.AE28 121.29,114.26 ; UH1.AE28 122.06,114.26 ; 121.29,113.49 UH1.AC29 v2(121.29,112.71) UH1.AA29 v2(121.29,111.94) ; 121.29,113.49 UH1.AE29 121.29,114.26 ; 125.16,115.04 UH1.AH21 124.39,115.04 ; 125.16,115.04 UH1.AH20 ; 125.16,115.04 UH1.AF20 ; UH1.U17 v2(126.71,110.39) ; v2(126.71,110.39) UH1.U18 v2(125.94,110.39) ; v2(126.71,110.39) UH1.V18 ; UH1.AC18 v2(125.94,113.49) ; UH1.AC18 v2(126.71,112.71) ; UH1.AC18 v2(125.94,112.71) ; v2(125.94,113.49) UH1.AC20 ; v2(125.94,113.49) UH1.AE18 v2(125.94,114.26) ; UH1.V20 v2(125.94,110.39) ; UH1.V20 v2(125.16,111.16) ; UH1.V20 v2(125.94,111.16) ; v2(125.94,110.39) UH1.V18 ; UH1.AH20 v2(125.94,115.04) ; UH1.AH20 v2(125.94,115.81) ; 122.06,114.26 UH1.AF28 ; 122.06,114.26 UH1.AF26 ; UH1.AF28 122.06,115.04 ; UH1.AF28 121.29,114.26 ; UH1.AH28 122.06,115.04 ; UH1.AH28 v2(121.29,115.81) ; UH1.AH28 v2(122.06,115.81) ; 122.06,115.04 UH1.AH26 ; 122.06,115.04 UH1.AF26 ; UH1.AG38 v2(116.94,115.33) ; 122.84,115.04 UH1.AF26 ; 122.84,115.04 UH1.AH25 ; 122.84,115.04 UH1.AF25 ; 122.84,115.04 UH1.AH26 ; UH1.AF26 122.84,114.26 ; UH1.AH1 135.28,115.38 v2(135.3,115.41) ; UH1.AC20 v2(125.94,112.71) ; UH1.AC20 v2(125.16,113.49) ; v2(125.94,115.04) UH1.AF18 v2(125.94,114.26) ; v2(125.94,115.04) UH1.AF20 ; v2(125.94,115.04) UH1.AH18 ; UH1.AW37 117.01,120.76 v2(116.93,120.43) 117.29,120.09 UH1.AU36 ; v2(116.17,120.78) UH1.AY38 ; v2(120.47,120.85) 120.47,120.88 UH1.AW29 ; UH1.AN4 133.32,118.25 UH1.AP4 ; v2(126.92,125.17) 126.92,124.88 126.27,124.22 UH1.BE18 ; UH1.AF25 123.61,115.04 ; UH1.AF25 123.61,114.26 ; UH1.AF25 122.84,114.26 ; 123.61,115.04 UH1.AH25 ; 123.61,115.04 UH1.AH23 124.39,115.04 ; 123.61,115.04 UH1.AF23 ; CPU1.C37 197.84,63.31 198.31,62.84 CPU1.D38 ; v2(125.94,112.71) UH1.AA20 ; v2(125.94,112.71) UH1.AA18 ; UH1.AL32 v2(119.99,116.75) UH1.AJ32 ; UH1.D31 120.06,103.77 UH1.D30 ; v2(125.94,111.94) UH1.AA18 ; v2(125.94,111.94) UH1.AA20 ; v2(125.94,111.94) UH1.Y20 ; v2(125.94,111.94) UH1.Y18 ; UH1.AA18 v2(126.71,111.94) ; UH1.AA18 v2(126.71,112.71) ; UH1.AT15 127.92,119.73 v2(127.48,120.16) 127.3,120.16 UH1.AV17 ; v2(121.29,111.94) UH1.Y28 v2(122.06,111.94) UH1.Y26 v2(122.84,111.16) UH1.V25 v2(123.61,111.16) UH1.V23 v2(124.39,111.16) ; v2(121.29,111.94) UH1.Y29 ; UH1.K27 v2(121.77,106.04) UH1.H27 ; UH1.AH25 v2(122.84,115.81) ; 124.39,115.04 UH1.AF23 ; UH1.V45 112.57,110.82 v2(112.45,110.69) ; UH1.AF23 124.39,114.26 ; UH1.AF23 123.61,114.26 ; 124.39,114.26 UH1.AE21 ; v2(128.5,107.72) 128.48,107.7 UH1.L15 ; v2(128.5,107.72) 128.48,107.74 UH1.N15 ; v2(128.5,107.72) UH1.L13 ; UH1.AL38 116.61,117.24 v2(117.13,117.79) ; v2(131.05,124.32) 130.84,124.11 UH1.BE9 ; v2(126.71,111.94) UH1.AA17 v2(126.71,112.71) ; v2(126.71,111.94) UH1.Y17 ; v2(126.71,111.94) UH1.Y18 ; UH1.AH26 v2(122.06,115.81) ; UH1.AH26 v2(122.84,115.81) ; v2(122.06,115.81) UH1.AJ26 v2(122.84,115.81) ; v2(122.06,115.81) UH1.AJ28 ; v2(121.29,115.81) UH1.AJ29 UH1.AL29 ; v2(121.29,115.81) UH1.AJ28 ; UH1.H35 v2(117.42,105.93) UH1.K36 ; UH1.BE14 128.54,124.05 128.81,124.32 128.81,125.41 v2(128.86,125.46) ; v2(126.45,101.67) 126.28,101.85 UH1.A18 ; v2(119.51,101.79) 119.46,101.84 UH1.A32 ; 123.61,114.26 UH1.AE25 122.84,114.26 ; UH1.B25 UH1.A25 122.77,101.83 v2(122.71,101.76) ; v2(120.54,105.9) 120.96,105.69 UH1.H29 ; UH1.A37 117.08,102.36 UH1.B37 UH1.C37 ; UH1.AA20 v2(125.16,112.71) ; UH1.AA20 v2(125.16,111.94) ; UH1.Y21 v2(125.16,111.16) ; UH1.Y21 v2(125.16,111.94) ; UH1.Y21 v2(124.39,111.16) ; UH1.Y21 v2(124.39,111.94) UH1.AA21 ; v2(125.16,111.16) UH1.V21 v2(124.39,111.16) ; v2(125.16,111.16) UH1.Y20 ; UH1.P45 v2(112.72,108.55) ; v2(125.16,112.71) UH1.AA21 ; UH1.H24 v2(122.81,106.04) ; v2(121.29,110.39) UH1.U29 UH1.R29 ; v2(121.29,110.39) UH1.V29 ; v2(121.29,110.39) UH1.U28 ; v2(125.94,115.81) UH1.AH18 ; UH1.AA21 v2(125.16,111.94) ; v2(132.78,100.91) 132.78,101.05 132.95,101.21 132.95,101.42 132.43,101.94 132.3,101.94 132.17,102.06 132.17,102.4 132.19,102.42 132.19,102.45 ; UH1.R33 v2(118.7,108.53) ; UH1.AJ36 v2(117.7,116.75) ; UH1.V18 v2(125.94,111.16) ; v2(125.94,114.26) UH1.AF20 ; v2(125.16,111.94) UH1.Y20 ; UH1.Y20 v2(125.94,111.16) ; UH1.AK4 133.12,116.22 133.12,115.94 133.07,115.89 133.07,115.43 v2(133.18,115.33) ; UH1.AL29 UH1.AM29 ; UH1.AL29 121.41,116.91 v2(121.57,116.72) 121.68,116.6 UH1.AJ28 ; v2(112.43,113.04) 112.48,113.09 UH1.AC45 ; UH1.AC25 v2(123.61,112.71) UH1.AA25 ; v2(119.02,124.06) 119.17,123.91 UH1.BE32 ; 125.2,121.48 125.4,121.28 UH1.AW19 ; v2(135.36,113.24) 135.23,113.11 UH1.AC1 ; v2(121.72,120.18) 122.15,120.51 UH1.AV27 ; v2(125.94,111.16) UH1.Y18 ; UH1.N22 v2(125.19,108.33) UH1.P22 UH1.R22 ; UH1.AD33 v2(119.23,114.29) UH1.AD32 ; UH1.L4 133.83,107.33 v2(133.86,107.35) ; UH1.AV33 v2(119.5,120.06) UH1.AV31 ; v2(112.7,120.15) 112.91,119.94 UH1.AU45 ; UH1.AU35 117.92,119.61 v2(117.92,119.41) UH1.AT36 ; UH1.BE23 124.03,123.91 124.4,124.29 124.4,124.45 v2(124.39,124.45) ; UH1.AD36 v2(117.7,114.29) ; UH1.AM45 v2(112.6,117.64) ; UH1.T2 UH1.T1 134.89,109.6 135,109.5 v2(135,109.12) ; v2(121.82,124.89) 121.75,124.83 121.75,124.82 121.65,124.72 121.65,124.12 121.72,124.05 UH1.BE28 ; UH1.H17 v2(127.65,106.14)
  TOP w0.203: v2(197.33,34.94) 197.66,34.62 CPU1.BA37 197.76,34.55 197.8,34.61 198.18,34.61 198.22,34.55 CPU1.BA38 ; CPU1.BN21 CPU1.BN20 184.9,25.71 v2(184.83,25.71) 184.5,26.04 CPU1.BN19 ; CPU1.BN21 186.34,26.36 v2(186.4,26.36) 186.08,26.69 CPU1.BM21 185.95,26.69 v2(185.63,27) ; CPU1.BN21 185.91,25.93 185.91,25.49 CPU1.BP21 ; UH1.AN8 131.26,118.44 v2(131.47,118.64) 131.98,118.14 UH1.AN7 ; v2(193.44,33.37) 193.06,33.75 CPU1.BB30 CPU1.BB29 ; CPU1.BK13 179.84,27.99 180.1,27.73 ; CPU1.AH34 v2(195.38,45.18) CPU1.AH33 ; v2(176.65,46.05) 176.65,46 CPU1.AG8 CPU1.AG7 175.47,45.72 CPU1.AG6 CPU1.AH6 CPU1.AJ6 ; UH1.AR9 131.08,118.87 v2(130.85,118.64) 130.5,118.29 UH1.AN10 ; CPU1.A34 196.15,64.89 196.06,64.98 196.06,65.34 v2(195.91,65.49) ; UH1.U8 131.41,109.8 v2(131.06,109.45) ; v2(191.86,29.07) 192.18,28.79 CPU1.BJ29 192.87,28.56 CPU1.BJ30 192.63,27.98 CPU1.BK29 192.52,27.55 CPU1.BL29 CPU1.BM29 ; CPU1.BC33 195.06,33.04 v2(194.73,33.37) ; CPU1.BE5 174.61,31.79 v2(174.61,31.86) 174.94,32.19 CPU1.BD6 ; CPU1.BE5 174.16,31.47 174.14,31.49 174.11,31.46 173.76,31.46 173.74,31.48 173.73,31.47 CPU1.BE4 173.51,31.47 173.5,31.48 173.21,31.48 173.19,31.47 CPU1.BE3 ; CPU1.BE5 174.43,31.33 174.8,31.33 CPU1.BE6 ; UH1.C28 121.57,103.37 UH1.D29 120.99,103.7 v2(120.55,103.25) ; v2(194.73,27.86) 194.41,28.18 CPU1.BJ32 194.31,28.15 193.86,28.15 CPU1.BJ31 ; CPU1.BN9 177.42,26.04 v2(177.74,26.36) ; CPU1.W3 172.99,51.47 v2(172.66,51.14) ; CPU1.W3 CPU1.W2 CPU1.W1 171.2,51.58 v2(170.76,51.14) ; CPU1.W3 CPU1.W4 CPU1.W5 174.69,51.98 174.69,52.17 CPU1.V6 CPU1.U6 175.03,53.26 CPU1.T7 CPU1.T8 ; v2(194.73,52.27) CPU1.W33 v2(195.38,51.48) CPU1.W34 ; UH1.AB15 UH1.AB14 128.37,112.32 v2(128.77,111.91) 128.37,111.51 UH1.W14 ; UH1.G42 114.57,105.31 114.48,105.4 v2(114.39,105.4) 113.7,104.71 UH1.F44 ; CPU1.AD29 192.34,47.94 v2(191.97,48.3) ; UH1.AP11 130.04,119.26 v2(130.09,119.31) 130.09,119.32 130.09,119.55 UH1.AT10 ; UH1.U38 116.69,109.8 v2(117.04,109.45) 116.69,109.09 UH1.R38 ; CPU1.AU8 176.65,37.77 v2(176.65,37.82) ; CPU1.AU8 CPU1.AU7 ; CPU1.AU8 CPU1.AU9 ; CPU1.BN7 CPU1.BM7 176.03,26.44 176.31,26.44 CPU1.BM8 176.81,26.44 177.1,26.44 CPU1.BM9 177.42,26.69 v2(177.74,26.36) ; CPU1.BN7 175.7,26.11 v2(175.24,26.11) 174.86,26.48 CPU1.BM6 ; CPU1.BN7 CPU1.BP7 CPU1.BR7 175.96,24.55 v2(175.96,23.75) 175.96,22.92 174.9,21.86 174.9,20.95 v2(175.2,20.65) ; v2(179.32,27.01) 179.25,27.01 CPU1.BM12 178.85,26.69 v2(178.53,26.36) ; v2(179.32,27.01) 179.64,27.34 CPU1.BL13 180.1,27.73 ; v2(179.32,27.01) 179.64,26.69 CPU1.BM13 ; 180.1,27.73 180.36,27.99 CPU1.BK14 CPU1.BK15 CPU1.BJ15 181.26,28.66 v2(181.26,29.33) ; v2(194.73,60.14) 194.41,60.46 CPU1.H32 194.17,60.78 194.17,61.34 194.11,61.39 CPU1.F31 ; v2(194.73,60.14) 194.41,59.82 CPU1.J32 ; v2(194.73,60.14) 195.06,59.81 CPU1.J33 ; v2(177.19,61.14) 177.51,60.81 CPU1.G10 ; v2(177.19,61.14) 176.86,60.81 CPU1.G9 ; v2(177.19,61.14) 176.86,61.46 CPU1.F9 176.72,61.46 v2(176.4,61.79) ; v2(187.42,63.74) 187.75,63.41 CPU1.C23 188.21,63.01 188.35,63.01 CPU1.D24 ; CPU1.BD37 197.66,32.26 v2(197.99,32.58) 198.31,32.25 CPU1.BD38 ; v2(184.27,63.74) 184.6,63.41 CPU1.C19 185.06,63.01 185.2,63.01 CPU1.D20 ; v2(210.38,94.91) 210.4,94.93 UZ26.11 ; UH1.AB10 130.65,112.33 v2(131.07,111.91) 131.41,112.26 UH1.AB8 ; CPU1.AL9 CPU1.AL10 177.92,43.23 v2(177.92,43.31) 177.29,43.31 ; CPU1.AL9 CPU1.AL8 CPU1.AL7 175.29,43.16 175.29,43.26 175.27,43.28 175.27,43.34 175.19,43.42 175.19,43.79 CPU1.AJ6 ; CPU1.AL9 176.9,42.92 177.29,43.31 ; CPU1.AP9 176.9,40.33 v2(176.65,40.56) ; CPU1.BP33 194.42,25.64 194.28,25.64 CPU1.BN31 193.57,26.35 v2(193.49,26.35) 193.41,26.35 CPU1.BN30 ; UH1.AL13 129.03,117.22 v2(129.41,117.6) 129.79,117.22 UH1.AL11 ; CPU1.T8 176.65,54.23 v2(176.65,54.28) v2(177.29,54.28) ; CPU1.T8 CPU1.T9 ; v2(177.92,35.08) 177.55,34.71 CPU1.BA10 ; 177.19,63.01 177.33,63.01 CPU1.D10 ; 177.19,63.01 CPU1.C9 176.72,63.41 v2(176.4,63.74) ; 177.19,63.01 CPU1.D9 ; UH1.E31 119.04,104.21 UH1.E33 118.82,104.34 v2(118.47,104.69) ; CPU1.AC3 CPU1.AC2 CPU1.AC1 v2(171.14,49.07) ; CPU1.AC3 CPU1.AC4 CPU1.AC5 CPU1.AC6 ; CPU1.AC3 172.99,48.85 v2(172.76,48.62) ; v2(192.15,63.74) 192.21,63.74 CPU1.C29 192.94,63.01 193.08,63.01 CPU1.D30 ; CPU1.BM29 CPU1.BM28 CPU1.BM27 190.67,26.69 v2(190.35,27) ; CPU1.BM29 CPU1.BN29 CPU1.BP29 CPU1.BR29 ; CPU1.G26 190.2,60.81 190.51,60.5 v2(190.58,60.5) 190.62,60.54 190.62,60.97 190.71,61.06 190.71,61.21 CPU1.F27 ; CPU1.AJ38 198.24,44 198.2,43.96 197.77,43.96 197.73,44 CPU1.AJ37 197.66,43.93 v2(197.34,43.61) ; v2(188.21,61.14) 187.89,61.46 CPU1.F23 187.75,61.46 v2(187.42,61.79) ; v2(188.21,61.14) 187.89,60.81 CPU1.G23 187.73,60.81 v2(187.42,60.5) ; v2(188.21,61.14) 188.54,60.81 CPU1.G24 ; v2(116.94,111.91) 116.59,112.27 UH1.AB38 ; v2(176.65,40.56) v2(177.29,40.56) ; v2(176.65,40.56) 176.65,40.51 CPU1.AP8 175.81,40.55 175.46,40.55 175.32,40.69 CPU1.AN6 174.89,40.64 CPU1.AN5 174.25,40.64 173.96,40.92 v2(173.96,41.13) ; v2(177.29,40.56) 177.55,40.31 CPU1.AP10 ; v2(177.29,40.56) 177.92,40.56 v2(177.92,40.57) ; v2(170.9,29.1) 171.3,28.7 CPU1.BH1 172.08,28.7 CPU1.BH2 ; PU1402.26 234.48,34.36 v2(234.4,34.28) ; v2(175.28,48.73) 175.11,48.56 175.11,48.41 174.94,48.24 CPU1.AD6 CPU1.AE6 174.53,46.98 174.07,46.98 CPU1.AF4 173.56,46.63 173.06,46.63 CPU1.AF3 172.91,46.63 172.41,46.63 CPU1.AF2 ; v2(175.28,48.73) 175.6,48.41 CPU1.AD7 CPU1.AD8 ; v2(175.28,48.73) 174.94,49.07 CPU1.AC6 ; v2(179.05,23.49) 178.92,23.62 CPU1.BT12 CPU1.BR12 178.92,24.81 178.86,24.88 178.86,25.25 178.92,25.31 CPU1.BP12 178.87,25.44 178.87,25.99 CPU1.BN12 178.6,26.36 v2(178.53,26.36) ; v2(178.56,54.28) 178.85,53.99 CPU1.T12 ; v2(178.56,54.28) 177.93,54.28 v2(177.92,54.29) ; v2(178.56,54.28) 178.85,54.57 CPU1.R12 179.11,55 179.11,55.39 CPU1.P12 179.11,55.91 179.11,56.31 CPU1.N12 ; v2(178.56,54.28) 178.2,53.92 CPU1.T11 ; v2(125.2,121.46) 125.2,121.54 125.3,121.64 125.3,122.35 UH1.BB21 ; CPU1.BA9 CPU1.BA8 ; CPU1.BA9 CPU1.BA10 ; CPU1.BA9 177.28,35.01 v2(177.28,35.07) ; CPU1.BA8 CPU1.BA7 175.35,34.37 175.32,34.37 CPU1.BB6 ; CPU1.BA8 176.65,35.02 v2(176.65,35.07) ; UH1.AG13 129.13,114.92 v2(129.53,115.33) 129.89,114.97 UH1.AG11 ; v2(194.73,38.09) 195.06,37.77 CPU1.AU33 ; PU1401.26 234.48,24.18 v2(234.4,24.1) ; v2(185.58,65.43) 185.45,65.3 CPU1.A20 ; UH1.AL33 118.9,117.2 v2(119.47,117.76) 119.83,118.13 UH1.AN31 ; CPU1.D26 189.93,63.01 189.79,63.01 CPU1.C25 189.32,63.41 v2(189,63.74) ; CPU1.A24 v2(188.6,65.35) ; CPU1.F25 189.32,61.46 v2(189,61.79) ; v2(183.3,29.3) 183.3,28.98 CPU1.BJ18 CPU1.BK18 ; CPU1.AP34 195.71,40.13 v2(195.38,40.46) 195.06,40.14 CPU1.AP33 ; UH1.D36 117.38,103.37 UH1.C37 ; UH1.D36 117.78,103.77 UH1.D35 118.23,103.29 v2(118.21,103.27) 118.21,103.27 118.21,103.3 118.22,103.29 118.48,103.29 118.53,103.34 118.53,103.34 118.71,103.53 118.72,103.53 118.89,103.7 UH1.D33 ; UH1.D36 117.69,103.73 117.39,104.03 117.39,105.9 v2(117.42,105.93) ; 172.66,61.23 172.66,61.23 CPU1.F2 ; 172.66,61.23 v2(172.66,61.16) ; 172.66,61.23 CPU1.F3 173.09,61.45 CPU1.F4 ; CPU1.AC6 CPU1.AB6 175.24,50.21 175.24,50.31 175.43,50.5 175.43,50.91 CPU1.Y7 CPU1.Y8 ; CPU1.P37 v2(197.99,56.2) CPU1.P38 ; v2(170.22,38.88) 170.35,39.01 CPU1.AR1 CPU1.AR2 CPU1.AR3 CPU1.AR4 CPU1.AR5 ; CPU1.AU11 CPU1.AU10 CPU1.AU9 ; CPU1.AU11 178.16,37.4 178.16,37.58 178.1,37.63 178.1,37.65 v2(177.92,37.83) ; CPU1.AU11 CPU1.AU12 179.11,37.1 179.11,36.71 CPU1.AW12 179.11,36.19 179.11,35.93 178.85,35.67 CPU1.AY12 178.56,35.25 v2(178.56,35.08) 178.56,34.98 CPU1.BA11 ; v2(180.46,46.97) 180.46,46.82 CPU1.AF14 CPU1.AF13 CPU1.AF12 178.85,46.37 178.72,46.24 178.72,46.21 v2(178.56,46.05) 178.56,45.96 CPU1.AG11 ; CPU1.BT5 174.5,23.53 v2(174.58,23.44) ; v2(173.83,62.62) 173.84,62.63 173.85,62.63 173.94,62.71 173.94,62.85 174.43,63.35 CPU1.C5 174.86,63.85 174.86,64.22 175.16,64.52 175.16,64.64 CPU1.A6 ; v2(174.61,58.69) 174.61,58.8 CPU1.K5 CPU1.K4 ; CPU1.BC12 178.85,32.94 v2(179.16,33.25) 178.85,33.56 CPU1.BB12 179.17,34.03 v2(179.17,34.16) 178.85,34.49 CPU1.BA12 CPU1.BA11 ; CPU1.BC12 CPU1.BC13 CPU1.BC14 180.15,32.66 v2(180.47,32.34) ; CPU1.BC12 178.85,32.62 v2(178.56,32.34) 178.2,31.97 CPU1.BD11 ; v2(174.8,61.79) 174.45,61.44 CPU1.F5 174.43,60.91 CPU1.G5 ; CPU1.AL34 195.71,42.36 v2(195.38,42.03) 195.06,42.35 CPU1.AL33 ; CPU1.BB6 CPU1.BB5 CPU1.BB4 CPU1.BB3 172.99,33.87 v2(172.66,33.54) 172.66,33.66 CPU1.BB2 CPU1.BB1 171.28,33.98 v2(170.84,33.54) ; CPU1.BB6 CPU1.BA6 ; CPU1.BB6 174.94,33.87 v2(174.61,33.54) 174.61,33.47 CPU1.BC6 CPU1.BD6 ; CPU1.BE6 CPU1.BF6 CPU1.BG6 CPU1.BH6 ; CPU1.BE6 175.19,31.72 175.19,31.89 ; v2(179.2,43.31) 178.85,42.96 CPU1.AL12 179.05,42.65 179.05,42.14 CPU1.AM12 179.1,41.68 179.1,41.27 CPU1.AN12 178.85,40.85 v2(178.56,40.56) ; CPU1.A37 197.75,64.73 197.75,64.94 v2(197.45,65.24) 196.99,64.78 196.99,64.74 CPU1.A36 ; v2(131.67,105.47) 131.67,104.89 UH1.F8 ; v2(131.67,105.47) 131.99,105.79 UH1.J7 ; v2(131.67,105.47) 131.3,105.47 UH1.G9 ; UH1.D25 123.44,103.77 UH1.D24 ; UH1.D25 122.77,103.34 v2(122.87,103.25) ; UH1.D25 122.68,103.68 UH1.D27 ; v2(132.4,107.56) 132.76,107.91 UH1.N5 ; 175.19,31.89 175.2,31.88 CPU1.BD7 CPU1.BD8 ; 175.19,31.89 175.19,32.14 175.02,32.31 CPU1.BD6 ; v2(133.18,115.33) 133.4,115.11 UH1.AG4 133.4,114.23 UH1.AE4 133.32,113.71 UH1.AD4 133.4,113.59 UH1.AB4 133.12,112.62 UH1.AB5 132.94,112.27 v2(132.58,111.91) ; CPU1.Y9 CPU1.Y8 ; CPU1.Y9 CPU1.Y10 CPU1.Y11 178.2,51.27 v2(177.92,51.54) 177.29,51.54 v2(177.29,51.54) ; CPU1.Y9 176.9,51.15 v2(177.29,51.54) ; CPU1.Y8 176.65,51.49 v2(176.65,51.54) v2(177.29,51.54) ; CPU1.T14 180.15,53.71 v2(179.82,53.39) 179.5,53.71 CPU1.T13 CPU1.T12 ; v2(193.44,42.82) 193.06,43.2 CPU1.AK30 CPU1.AK29 ; CPU1.F21 186.31,61.46 v2(186.64,61.14) 186.96,60.81 CPU1.G22 187.11,60.81 v2(187.42,60.5) ; CPU1.BM5 174.21,26.5 CPU1.BN4 173.79,26.09 CPU1.BM3 ; CPU1.BM5 173.97,26.82 v2(173.76,26.82) 173.53,26.82 CPU1.BM3 ; CPU1.BM5 174.75,26.59 CPU1.BM6 ; v2(177.29,54.28) v2(177.92,54.29) ; v2(177.29,54.28) 176.9,53.89 CPU1.T9 ; CPU1.AW3 172.99,36.38 v2(172.66,36.05) ; CPU1.AW3 CPU1.AW2 CPU1.AW1 171.07,36.5 v2(170.65,36.08) ; CPU1.AW3 CPU1.AW4 CPU1.AW5 174.69,36.9 174.69,37.08 CPU1.AU6 174.97,37.36 CPU1.AU7 ; v2(177.29,57.02) 176.9,56.63 CPU1.N9 ; v2(177.29,57.02) v2(177.92,57.03) 177.93,57.02 v2(178.56,57.02) ; v2(177.29,57.02) 176.65,57.03 176.65,56.97 CPU1.N8 ; v2(193.72,63.74) 194.05,63.41 CPU1.C31 194.51,63.01 194.65,63.01 CPU1.D33 195.23,62.43 195.29,62.43 195.61,62.11 CPU1.E34 195.78,62.11 195.84,62.17 196.3,62.17 CPU1.E35 ; UH1.AD11 129.89,114.14 v2(130.04,114.29) ; CPU1.G16 182.24,60.81 v2(181.91,61.14) 181.59,61.46 CPU1.F15 181.26,61.21 181.13,61.21 CPU1.G14 180.98,60.56 180.98,60.49 181.12,60.35 181.12,59.3 180.89,59.07 180.88,59.07 v2(180.73,58.91) ; CPU1.G28 191.75,60.83 192.02,61.09 v2(192.15,61.09) 192.53,61.46 CPU1.F29 ; CPU1.BT35 196.18,23.97 v2(196.63,23.52) 196.63,23.72 CPU1.BT36 196.88,24.2 CPU1.BR36 ; CPU1.BT14 CPU1.BR14 180.89,25.01 v2(180.89,25.06) 180.89,25.11 CPU1.BP14 CPU1.BN14 ; UH1.AR42 114.81,118.87 114.96,118.71 v2(115.52,118.71) 115.63,118.61 115.63,118.21 ; UH1.P17 127.31,108.79 v2(127.53,109) 127.81,109.28 UH1.U15 ; v2(170.91,59.16) 171.65,59.16 CPU1.K1 CPU1.K2 CPU1.K3 ; CPU1.AA12 179.11,49.91 179.11,49.51 CPU1.AC12 178.85,49.08 v2(178.56,48.79) 178.2,48.43 CPU1.AD11 ; v2(178.56,40.56) 178.56,40.57 v2(177.92,40.57) ; v2(178.56,40.56) 178.85,40.28 CPU1.AP12 ; v2(18.76,43.84) 19.12,43.47 UZ21.5 ; CPU1.AC38 v2(198.64,49.12) ; UH1.AN27 122.13,118.23 v2(121.77,117.87) 122.18,117.47 UH1.AM27 ; CPU1.BP26 CPU1.BR26 CPU1.BT26 v2(189.95,23.31) ; CPU1.D28 191.5,63.01 191.36,63.01 CPU1.C27 190.9,63.41 v2(190.57,63.74) ; v2(173.05,63.47) 172.64,63.47 172.52,63.35 CPU1.C2 ; v2(173.05,63.47) 173.07,63.48 CPU1.B3 172.94,64.14 CPU1.A3 ; v2(173.05,63.47) 172.92,63.33 CPU1.D3 172.92,62.86 CPU1.E4 CPU1.F4 ; CPU1.AU9 176.9,37.43 v2(177.29,37.82) ; v2(177.88,59.68) 177.58,59.98 CPU1.J10 ; v2(177.88,59.68) 177.55,59.34 CPU1.K10 177.45,59.33 176.99,59.33 CPU1.K9 176.8,59.33 176.34,59.33 CPU1.K8 175.84,59.64 v2(175.84,59.67) ; v2(177.88,59.68) 178.2,59.36 CPU1.K11 ; UH1.AR5 132.14,119.28 UH1.AR7 v2(131.46,119.59) 131.94,120.07 UH1.AU7 ; CPU1.K4 CPU1.K3 ; CPU1.K4 CPU1.J4 173.64,60.08 v2(173.35,60.37) 173.35,60.48 CPU1.G4 ; UH1.AH45 112.98,115.37 v2(112.75,115.59) ; v2(257.47,26.69) 257.47,26.44 257.22,26.19 PU1600.26 ; CPU1.AM5 174.29,41.46 v2(173.96,41.13) ; CPU1.BM35 196.26,26.69 v2(196.6,27.03) 196.36,27.27 CPU1.BL35 ; CPU1.BH2 CPU1.BH3 CPU1.BH4 CPU1.BH5 CPU1.BH6 ; CPU1.BH2 172.34,28.89 172.66,28.57 v2(172.66,28.51) ; v2(191.88,54.52) CPU1.R29 CPU1.R30 v2(193.44,55.42) ; v2(127.39,121.91) 127.39,122.32 UH1.BB16 ; v2(198.91,59.05) 198.83,58.96 CPU1.K38 ; CPU1.Y38 v2(197.99,51.48) CPU1.Y37 ; UH1.AM15 128.1,117.01 v2(127.73,116.64) ; v2(186.85,29.2) 186.8,29.14 CPU1.BJ22 CPU1.BK22 ; CPU1.K3 172.99,59.01 v2(172.66,58.69) ; CPU1.AD30 193.06,47.92 v2(193.44,47.54) ; v2(178.56,57.02) 178.85,57.31 CPU1.M12 CPU1.M13 CPU1.M14 180.45,57.09 v2(180.49,57.05) ; v2(178.56,57.02) 178.85,56.74 CPU1.N12 ; v2(178.56,57.02) 178.2,56.66 CPU1.N11 ; CPU1.BE3 172.99,31.35 v2(172.66,31.02) ; CPU1.BE3 CPU1.BE2 CPU1.BE1 171.17,31.47 v2(170.72,31.02) ; CPU1.BM23 187.65,26.69 v2(187.98,26.36) 188.3,26.04 CPU1.BN24 188.45,25.96 188.45,25.46 CPU1.BP24 188.45,25.31 188.45,24.81 CPU1.BR24 188.32,24.68 188.32,24.14 CPU1.BT24 ; CPU1.D6 CPU1.C8 176.33,63.74 v2(176.4,63.74) ; UH1.C10 130.66,103.37 UH1.D10 130.26,103.78 UH1.D12 129.52,103.78 129.16,104.14 UH1.E13 128.83,104.65 v2(128.6,104.65) 128.51,104.65 128.12,104.26 UH1.E15 128.07,103.7 UH1.D15 127.4,103.7 UH1.D16 126.88,103.78 UH1.D17 126.53,103.68 126.42,103.79 126.08,103.79 125.99,103.7 UH1.D19 125.71,103.78 UH1.D21 ; CPU1.BH11 178.2,29.23 v2(178.56,29.59) 178.85,29.88 CPU1.BG12 CPU1.BG13 179.11,30.44 179.11,30.7 CPU1.BF12 179.17,31.29 v2(179.17,31.42) 178.85,31.75 CPU1.BD12 CPU1.BD11 ; CPU1.BH11 CPU1.BH10 ; CPU1.BH11 CPU1.BH12 ; CPU1.BH11 178.2,29 v2(178.52,28.68) 178.89,28.31 CPU1.BJ12 ; CPU1.T12 179.11,53.56 179.11,53.31 178.85,53.04 CPU1.V12 179.11,52.65 179.11,52.26 CPU1.W12 ; CPU1.T12 CPU1.T11 ; CPU1.L33 195.06,58.25 v2(195.38,58.57) 195.71,58.24 CPU1.L34 ; CPU1.T3 CPU1.T2 CPU1.T1 171.17,54.1 v2(170.72,53.65) ; CPU1.T3 172.68,53.79 v2(172.68,53.66) ; CPU1.T3 CPU1.T4 CPU1.T5 ; CPU1.N8 CPU1.N7 175.34,56.57 175.29,56.61 CPU1.N6 ; CPU1.N8 CPU1.N9 ; UH1.N35 117.96,108.36 v2(117.96,108.54) ; CPU1.A3 CPU1.A4 ; CPU1.A3 172.94,65.09 173.13,65.29 v2(173.4,65.29) ; CPU1.T9 CPU1.T10 ; v2(198.7,62.99) 198.69,62.99 CPU1.D38 ; v2(176.65,32.34) 176.65,32.28 CPU1.BD8 ; CPU1.T10 177.55,53.91 v2(177.92,54.29) ; CPU1.T10 CPU1.T11 ; v2(191.78,65.19) 191.78,64.75 CPU1.A28 ; CPU1.BH6 175.12,29.13 CPU1.BH7 CPU1.BH8 ; CPU1.BH6 174.94,28.86 v2(174.61,28.53) 174.61,28.44 CPU1.BK6 175.11,27.94 175.11,27.45 CPU1.BL6 174.94,26.57 CPU1.BM6 ; v2(129.44,106.19) 129.61,106.02 UH1.J11 130.08,106.49 v2(130.02,106.55) 129.55,107.02 UH1.L12 129.62,107.06 v2(130.11,107.56) 130.47,107.91 UH1.N10 ; UH1.U10 130.65,109.8 v2(130.3,109.45) 129.89,109.86 UH1.U11 ; v2(173.76,23.41) 173.76,24.03 CPU1.BT4 ; UH1.A42 114.64,102.39 114.64,103.17 UH1.C42 114.88,103.24 114.94,103.18 v2(115.18,103.18) 115.18,102.87 UH1.B40 ; v2(193.44,50.69) CPU1.AA30 CPU1.AA29 ; CPU1.AB34 v2(195.38,49.91) CPU1.AB33 ; CPU1.BD9 CPU1.BD8 ; CPU1.BD9 176.9,31.94 v2(177.29,32.34) ; CPU1.BD9 CPU1.BD10 ; CPU1.Y13 179.5,51.18 v2(179.82,51.51) 180.15,51.18 CPU1.Y14 ; CPU1.BH10 177.55,29.22 v2(177.92,29.6) ; CPU1.BH10 CPU1.BH9 ; v2(183.88,58.93) CPU1.J18 CPU1.H18 CPU1.G18 183.81,60.81 v2(183.49,61.14) 183.16,61.46 CPU1.F17 183.02,61.46 v2(182.7,61.79) ; UH1.AJ31 120.04,115.9 v2(120.04,115.4) 120.04,115.02 UH1.AG31 ; CPU1.BR21 CPU1.BT21 v2(186.01,23.31) ; v2(173.96,41.13) 173.64,41.46 CPU1.AM4 173.55,41.61 173.07,41.61 CPU1.AM3 CPU1.AM2 CPU1.AM1 v2(171.14,41.53) ; CPU1.BH14 CPU1.BG14 180.46,30.36 v2(180.46,30.51) ; UH1.H22 124.83,105.69 v2(125.19,106.04) ; v2(131.23,120.31) 130.94,120 UH1.AT9 ; 175.96,60.77 CPU1.G8 CPU1.F8 176.07,61.46 v2(176.4,61.79) ; 175.96,60.77 175.58,60.39 CPU1.J7 175.58,59.81 175.73,59.67 v2(175.84,59.67) ; 175.96,60.77 CPU1.G6 174.8,60.77 174.78,60.79 174.43,60.79 174.41,60.77 CPU1.G5 ; CPU1.BT9 177.35,23.65 v2(177.47,23.52) ; v2(198.64,39.67) 198.31,39.35 CPU1.AR38 ; CPU1.AV37 197.66,36.99 v2(197.99,37.31) 198.31,36.98 CPU1.AV38 ; UH1.AN22 124.82,118.23 v2(125.19,117.86) 124.8,117.47 UH1.AM22 ; CPU1.N9 CPU1.N10 CPU1.N11 ; CPU1.AH12 178.85,44.82 178.98,44.95 178.98,44.96 v2(179.16,45.14) ; CPU1.T33 v2(195.38,54.63) CPU1.T34 ; CPU1.AR37 197.66,39.34 v2(197.33,39.67) ; v2(179.82,42.39) 180.15,42.72 CPU1.AL14 180.15,42.96 v2(180.5,43.31) ; UH1.BE40 115.54,124.79 v2(115.45,124.88) ; v2(176.4,61.79) 176.72,62.11 CPU1.E9 ; RC171.1 165.75,23.94 v2(166.91,25.1) ; UH1.AG32 119.63,114.92 v2(119.23,115.33) 118.87,114.97 UH1.AG33 ; v2(178.53,26.36) 178.2,26.69 CPU1.BM11 178.07,26.69 v2(177.74,26.36) ; UH1.K43 114.6,106.7 UH1.K42 114.96,106.76 UH1.L41 115.42,106.92 v2(115.7,106.64) 116.06,106.28 UH1.J39 ; CPU1.N12 CPU1.N11 ; CPU1.BM26 189.88,26.69 v2(189.55,27.01) ; v2(171.14,44.04) CPU1.AJ1 CPU1.AJ2 CPU1.AJ3 CPU1.AJ4 CPU1.AJ5 CPU1.AJ6 ; v2(193.44,36.52) 193.06,36.14 CPU1.AW30 CPU1.AW29 191.82,35.54 v2(191.82,35.22) ; CPU1.N2 172.34,56.47 172.58,56.22 v2(172.58,56.17) ; CPU1.N2 CPU1.N1 v2(170.91,56.61) ; CPU1.N2 CPU1.N3 CPU1.N4 CPU1.N5 CPU1.N6 ; CPU1.AU7 175.35,37.62 175.35,37.76 CPU1.AT6 ; v2(193.48,65.19) 193.48,64.76 CPU1.A30 ; v2(182.7,63.74) 182.85,63.58 182.92,63.58 CPU1.C17 183.49,63.01 183.63,63.01 CPU1.D18 ; v2(128.77,114.29) 128.37,113.88 UH1.AD14 ; v2(178.76,60.49) 179.09,60.16 CPU1.H12 ; v2(178.76,60.49) 178.44,60.16 CPU1.H11 ; v2(178.76,60.49) 179.09,60.81 CPU1.G12 ; CPU1.G5 CPU1.G4 ; UH1.N24 123.42,107.97 v2(123.8,107.59) ; CPU1.AU34 195.71,37.77 v2(196.03,38.09) ; UH1.U32 v2(119.87,110.85) UH1.U31 ; v2(112.69,103.93) 112.9,103.93 UH1.D45 ; UH1.AW13 v2(129.54,120.74) ; CPU1.F13 179.84,61.46 v2(179.54,61.76) ; v2(176.4,63.74) 176.72,64.06 CPU1.B9 CPU1.A9 ; CPU1.AD12 CPU1.AD11 ; CPU1.AD11 CPU1.AD10 ; CPU1.AR14 180.15,39.33 v2(179.82,39.65) 179.5,39.33 CPU1.AR13 ; v2(191.88,45.57) CPU1.AG29 CPU1.AG30 v2(193.44,45.97) ; v2(181.12,63.74) 181.45,63.41 CPU1.C15 181.91,63.01 182.05,63.01 CPU1.D16 ; CPU1.AD8 176.25,48.39 v2(176.65,48.79) ; CPU1.AD8 CPU1.AD9 ; CPU1.BM3 173.22,26.66 CPU1.BM2 172.27,26.66 v2(172.16,26.55) 172.16,26.24 CPU1.BN2 ; v2(177.92,48.8) 177.55,48.42 CPU1.AD10 ; CPU1.AK4 173.64,43.09 v2(173.32,42.77) 173.64,42.45 CPU1.AL4 ; v2(187.42,60.5) CPU1.H22 CPU1.J22 187.03,58.6 v2(187.01,58.58) ; CPU1.AF2 CPU1.AF1 v2(171.14,46.55) ; CPU1.AF2 172.34,46.44 v2(172.63,46.14) ; CPU1.AT30 CPU1.AT29 192.29,38.49 v2(191.85,38.04) ; v2(177.97,61.79) 178.3,61.46 CPU1.F11 ; CPU1.L30 CPU1.L29 192.07,58.17 v2(191.87,57.98) ; v2(177.92,32.34) 177.55,31.97 CPU1.BD10 ; UH1.AN11 129.75,118.07 v2(130.11,117.72) 130.55,117.27 UH1.AL10 ; v2(177.29,48.79) 176.9,48.4 CPU1.AD9 ; v2(176.65,29.59) 176.25,29.19 CPU1.BH8 ; v2(131.82,111.91) 132.18,112.27 UH1.AB7 ; v2(185.85,63.74) 186.17,63.41 CPU1.C21 186.64,63.01 186.78,63.01 CPU1.D22 ; 177.29,43.31 v2(177.29,43.31) ; CPU1.G20 185.39,60.81 v2(185.06,61.14) 184.74,61.46 CPU1.F19 184.6,61.46 v2(184.27,61.79) ; CPU1.BT32 v2(194.61,23.31) ; CPU1.G4 CPU1.F4 ; v2(172.79,23.48) 172.79,23.67 172.98,23.86 CPU1.BT3 ; CPU1.V30 CPU1.V29 v2(191.88,52.66) ; UH1.AK4 133.76,116.42 133.86,116.52 133.4,116.97 UH1.AL4 ; v2(177.92,46.06) 177.92,45.97 CPU1.AG10 ; v2(197.33,49.12) CPU1.AC37 ; CPU1.K7 175.6,59.42 v2(175.84,59.67) ; v2(275.76,30.88) 275.76,31.14 275.44,31.46 PU700.22 ; UH1.M42 114.78,107.51 UH1.N41 115.21,108.46 v2(115.36,108.61) ; UH1.AM17 126.7,117.47 v2(126.3,117.06) ; UH1.AW9 131.73,121.09 v2(131.78,121.14) 132.17,120.75 UH1.AV6 ; CPU1.AD9 CPU1.AD10 ; CPU1.BG37 197.66,29.89 v2(197.33,30.22) ; v2(130.18,116.48) 130.18,116.36 130.49,116.05 UH1.AJ10 ; v2(126.3,117.06) 125.89,117.47 UH1.AM19 ; v2(126.3,117.06) 126.14,116.91 UH1.AL19 ; v2(126.3,117.06) 126.45,116.91 UH1.AL17 ; CPU1.BA10 CPU1.BA11 ; CPU1.A12 v2(179.15,65.35) ; CPU1.N33 v2(195.38,56.2) CPU1.N34 ; CPU1.D14 180.48,63.01 180.34,63.01 CPU1.C13 179.87,63.41 v2(179.55,63.74) ; CPU1.AM38 198.31,41.7 v2(197.99,42.03) 197.66,41.71 CPU1.AM37 ; CPU1.BF33 195.06,30.69 v2(195.38,31.01) 195.71,30.68 CPU1.BF34 ; CPU1.A10 177.58,65.58 v2(177.53,65.63) ; v2(177.92,40.57) 178.2,40.3 CPU1.AP11 ; UH1.AD8 131.41,114.06 v2(131.23,114.25) ; CPU1.A22 v2(187.03,65.35) ; CPU1.N6 CPU1.M6 ; CPU1.N6 CPU1.P6 ; v2(177.29,29.59) 176.9,29.2 CPU1.BH9 ; UH1.H19 125.87,105.69 v2(126.23,106.04) ; CPU1.BD11 CPU1.BD10 ; CPU1.A16 v2(182.3,65.35) ; v2(130.24,108.6) UH1.R10 ; v2(189.76,58.73) 189.76,59.1 189.4,59.46 CPU1.J25 189.53,59.6 189.53,59.97 CPU1.H25 ; v2(221.7,122.17) 221.87,122.17 221.91,122.13 UZ25.11 ; CPU1.BH8 CPU1.BH9 ; v2(117.66,124.11) 117.35,124.11 UH1.BE37 ; CPU1.BL38 198.35,27.54 v2(198.69,27.2) 198.32,26.83 CPU1.BM38 ; CPU1.BN34 195.39,26.04 v2(195.07,25.71) 195.13,25.71 CPU1.BP34 CPU1.BR34 ; UH1.W38 116.59,111.23 v2(116.94,110.87) ; CPU1.C37 CPU1.B37 ; UH1.U14 128.37,109.86 v2(128.77,109.45) 128.34,109.02 UH1.R14 ; v2(194.73,47.54) CPU1.AE33 CPU1.AE34 ; UH1.AB11 129.89,112.3 v2(130.31,111.89) ; v2(179.84,35.03) 179.84,35.23 CPU1.AY14 ; v2(196.03,33.37) 195.71,33.05 CPU1.BC34 ; UH1.K10 130.91,107.03 UH1.L8 131.4,106.5 v2(131.34,106.44) 131.06,106.16 UH1.J10 ; v2(191.79,40.85) CPU1.AN29 CPU1.AN30 193.06,40.84 v2(193.44,40.46) ; v2(190.18,65.35) CPU1.A26 ; 257.22,29.64 257.22,29.65 PU1600.5 ; v2(193.44,31.79) 193.06,31.42 CPU1.BE30 CPU1.BE29 192.22,31.4 v2(191.91,31.09) ; CPU1.U37 v2(197.99,53.84) CPU1.U38 ; PU1400.26 234.51,13.63 v2(234.4,13.74) ; CPU1.A18 v2(183.88,65.35) ; UH1.AR33 118.97,118.56 v2(118.74,118.33) 118.45,118.61 UH1.AR34 ; CPU1.J36 196.76,60 196.76,60.14 CPU1.H35 196.36,60.61 v2(196.68,60.93) 196.68,60.99 CPU1.F36 197.01,61.39 v2(197.33,61.72) 198.21,61.72 CPU1.E38 ; CPU1.BM18 v2(183.25,26.36) 183.58,26.04 CPU1.BN18 CPU1.BP18 CPU1.BR18 CPU1.BT18 v2(183.65,23.29) ; UH1.K4 133.86,107.22 v2(133.86,107.35) ; UH1.AU39 v2(116.17,120.78) ; CPU1.AY34 195.71,35.4 v2(195.38,35.73) 195.06,35.41 CPU1.AY33 ; R561.2 251.07,103.83 ; v2(198.64,30.22) 198.31,29.9 CPU1.BG38 ; v2(177.97,63.74) 178.3,63.41 CPU1.C11 178.65,63.13 178.79,63.13 CPU1.D12 ; CPU1.A14 v2(180.73,65.35) ; UH1.W8 v2(131.01,110.92)
  TOP w0.254: v2(120.94,21.17) 120.44,21.68 JDIMM3.27 ; UH1.U33 118.98,110.16 v2(119.23,110.87) ; UZ28.5 151.06,122.82 v2(151.62,122.26) ; U88.7 1.91,44.18 v2(1.63,43.9) 2.2,43.33 v3(3.14,43.33) 4.68,43.33 5.06,43.71 U88.8 ; JDIMM3.73 119.78,33.17 120.78,32.17 ; CPU1.BM25 v2(189.55,27.01) ; PU1001.14 v2(333.7,53.69) PU1001.32 ; v2(120.04,111.91) UH1.W31 ; v2(120.04,111.91) UH1.AB32 ; v2(120.04,111.91) UH1.AB31 ; v2(120.74,33.49) 120.05,34.17 JDIMM3.77 ; v2(117.7,107.05) UH1.M35 UH1.N36 ; UH1.AU1 135.22,119.55 136.08,119.55 136.4,119.86 v2(136.4,120.23) ; UH1.W32 v2(119.23,110.87) ; v2(119.23,110.87) UH1.W33 ; JDIMM1.69 133.56,32.17 133.65,32.08 133.69,32.08 133.93,31.84 133.93,31.8 134.23,31.51 134.68,31.51 135.06,31.88 v2(135.06,31.97) ; C539.2 242.75,78.4 242.87,78.4 v2(243.1,78.63) 242.77,78.96 UZ22.5 ; UN8.7 v2(24.66,30.9) ; UH1.H3 133.89,106.02 UH1.J3 133.55,106.01 UH1.J5 132.82,105.79 v2(132.82,105.51) ; v2(34.7,30.04) 35.11,30.45 UN9.7 ; UH1.W4 133.33,111.43 UH1.AA4 133.42,111.97 v2(133.86,111.97) ; v2(174.22,86.57) 174.22,86.77 174.5,87.04 JMXM1.187 ; v2(126.25,108.15) 126.15,108.05 125.85,108.05 UH1.N19 UH1.P19 ; UH1.AP4 133.42,118.79 v2(133.86,118.79) ; JEDP1.31 112.44,143.15 v2(112.44,142.77) 112.95,143.21 JEDP1.30 ; 309.86,41.99 309.08,42.77 309.08,43.27 309.61,43.8 JIO1.20 ; 309.86,41.99 309.92,42.06 310.57,42.06 310.81,42.3 JIO1.26 ; 309.86,41.99 v2(309.86,41.55) ; UZ27.5 151.31,125.23 v2(151.62,124.92) ; v2(327.38,41.18) 327.76,40.8 UZ29.20 ; PU500.11 73.97,10.86 73.75,11.08 73.54,11.08 73.3,11.32 v2(72.24,11.32) 72.22,11.35 PR508.2 ; UH1.D30 120.55,103.73 v2(120.55,103.25) ; v2(327.28,39.57) 327.6,39.25 UZ29.2 ; UH1.C1 UH1.D1 135.18,103.64 v2(135.42,103.4) ; UH1.AM24 v2(122.81,117.06) UH1.AL24 ; JIO1.14 309.6,45.3 v2(309.49,45.41) ; RD29.2 128.39,7.4 ; Q367.4 170.17,96.85 169.68,96.35 169.21,96.35 168.87,96.02 Q367.1 ; UZ23.5 182.29,100.64 v2(182.14,100.79) ; 140.19,97.46 140.19,97.68 140.82,98.31 143.3,98.31 143.79,98.8 143.79,101.96 143.17,102.59 v2(140.55,102.59) 140.08,102.13 139.55,102.13 139.4,101.98 139.4,101.77 CH14.2 138.5,101.8 137.63,101.8 136.88,101.05 134.28,101.05 134.03,101.3 ; UH1.AE42 114.57,114.22 v2(114.18,114.22) ; v2(133.86,107.35) 133.86,107.41 133.4,107.87 UH1.N4 ; CH13.2 138.98,98.48 138.65,98.15 137.59,98.15 136.71,99.04 136.71,99.38 136.16,99.93 134.26,99.93 133.27,100.91 v2(132.78,100.91) ; JEDP1.40 108.31,145.82 v2(107.48,146.58) ; v2(191.94,98) 191.83,98.11 UZ18.5 ; v2(122.81,120.84) 122.96,120.7 123.15,120.7 UH1.AV24 ; v2(120.58,122.97) 120.59,122.97 120.58,122.97 120.58,122.52 UH1.BB30 ; v2(330.08,38.37) 330.2,38.49 UZ29.5 ; v2(114.17,109.63) 114.53,109.63 UH1.T42 ; UZ20.11 v2(304.44,30.27) ; v2(309.91,49.62) 309.91,48.55 310.17,48.3 JIO1.2 ; CPU1.BR38 198.36,24.68 v2(198.74,25.06) ; 134.96,39.54 v2(134.97,39.53) ; 134.96,39.54 134.96,40.02 134.3,40.68 JDIMM1.103 ; 134.96,39.54 134.82,39.68 JDIMM1.99 ; UZ29.11 333.35,40.8 333.48,40.94 ; v2(118.46,106.99) 118.46,106.98 UH1.K33 ; JMXM1.209 169,87.09 169.25,86.83 v2(170.37,86.83) ; JEDP1.12 122.05,142.97 122.05,143.97 v2(122.28,144.19) ; v2(114.18,116.5) 114.57,116.5 UH1.AK42 ; v2(114.17,111.95) 114.57,111.95 UH1.AA42 ; UH1.BB25 122.8,122.57 v2(122.8,122.98) ; 311.66,37.8 312.82,37.8 v2(313.08,38.06) ; JEDP1.14 v2(120.82,141.75) ; PU1001.5 333.7,49.82 v2(333.72,49.8) ; UH1.BB34 118.41,122.74 v2(118.23,122.91) ; JIO2.81 v2(54.74,42.35) ; U88.5 v3(2.96,45.23) 1.88,45.23 v2(1.63,44.98) 1.88,44.73 U88.6 ; JMXM1.215 167.5,87.27 166.82,86.6 166.73,86.6 v2(166.53,86.39) ; v2(333.78,57.81) 333.7,57.72 PU1001.23 ; UH1.V3 133.73,110.67 UH1.U4 133.4,110.15 v2(133.86,109.7) 133.76,109.6 UH1.T4 ; PU1800.11 56.85,10.84 v2(56.68,11.01) 56.49,11.2 55.99,11.2 PC1807.2 ; 200.08,86.77 200.97,85.88 201.82,85.88 202.24,86.3 202.24,86.94 202,87.18 JMXM1.83 ; v2(112.63,121.75) 112.82,121.56 UH1.AY45 ; v2(132.59,108.63) 132.89,108.93 UH1.R5 ; CPU1.BK25 CPU1.BJ25 ; UH1.BB11 129.68,122.52 v2(129.68,122.92)
  TOP w0.279: v2(144.36,8.82) JXDP1.2 ; JXDP1.7 145.86,6.48 145.39,6.95 v2(145.33,6.95) ; v2(153.36,6.44) JXDP1.37 ; v2(148.36,8.24) 148.58,8.24 148.86,8.52 JXDP1.20 ; v2(150.52,6.37) 150.36,6.21 JXDP1.25 ; JXDP1.38 153.36,11.4 152.59,12.17 v2(152.44,12.17) ; v2(145.36,8.24) 145.5,8.24 145.86,8.6 JXDP1.8 ; v2(156.36,8.81) JXDP1.50 ; v2(147.36,8.82) JXDP1.14 ; v2(151.45,6.97) 151.64,6.97 151.89,6.71 151.89,4.62 JXDP1.31 ; v2(151.38,8.24) 151.56,8.24 151.86,8.55 JXDP1.32 ; v2(147.36,6.36) JXDP1.13 ; v2(148.36,6.95) 148.48,6.95 148.86,6.57 JXDP1.19 ; v2(150.36,8.83) JXDP1.26 ; v2(156.36,6.43) JXDP1.49 ; JXDP1.59 158.9,4.62 158.9,6.29 v2(159.05,6.43)
  TOP w0.305: JDIMM3.181 120.11,62.17 v2(120.27,62.33) ; JDIMM1.26 123.38,21.42 v2(123.13,21.17) ; JDIMM1.65 133.63,31.17 134.17,30.64 v2(134.17,30.34) 134.01,30.17 JDIMM1.61 ; JIO1.74 310.8,30.3 310.3,29.8 ; JDIMM1.248 123.77,78.92 123.5,79.19 v2(123.36,79.19) 123.36,79.73 123.55,79.92 JDIMM1.252 ; v2(107.98,21.5) 109.06,20.42 JDIMM3.22 ; JDIMM3.197 120.91,66.17 v2(121.03,66.05) 121.03,65.76 120.45,65.17 JDIMM3.193 ; JMXM1.278 151.25,79.04 150.89,78.69 v2(150.89,78.26) 152.46,78.26 152.75,78.55 JMXM1.272 ; v2(180.71,86.78) 180.5,87 JMXM1.163 ; v2(108.82,25.69) 109.05,25.93 JDIMM3.44 ; JIO2.130 51.44,54.35 51.03,54.76 v2(51.03,55.14) ; JDIMM3.205 121.38,68.17 v2(121.83,67.73) 121.28,67.17 JDIMM3.201 ; JIO1.57 316.51,34.3 v2(316.59,34.22) ; JDIMM3.57 120.41,29.17 v2(121.07,29.83) 120.72,30.17 JDIMM3.61 ; v2(134.97,16.25) 134.89,16.17 JDIMM1.5 ; JMXM1.203 170.5,86.96 v2(170.37,86.83) ; JIO2.106 53.45,48.35 v2(53.46,48.37) ; JDIMM3.98 109.41,39.42 v2(109.21,39.63) 109.21,39.87 109.76,40.42 JDIMM3.102 ; JDIMM1.52 123.4,27.93 v2(123.2,27.73) ; JDIMM1.82 123.46,35.42 v2(123,34.97) ; v2(182.74,86.77) 182.5,87.01 JMXM1.161 ; JDIMM1.102 123.2,40.42 122.49,41.13 v2(122.49,41.62) ; v2(108.82,15.23) 109.02,15.42 JDIMM3.2 ; JDIMM1.44 123.21,25.93 v2(123.2,25.92) 123.2,25.2 123.48,24.93 JDIMM1.40 ; JDIMM3.15 120.32,18.68 v2(121.14,19.49) 120.96,19.68 JDIMM3.19 ; JMXM1.100 197.75,78.64 v2(197.74,78.63) ; v2(109.21,72.97) 109.21,72.94 109.73,72.43 JDIMM3.222 ; JDIMM3.23 120.45,20.68 v2(120.94,21.17) ; JDIMM3.72 109.7,32.93 108.69,33.93 v2(108.69,34.22) ; 312.83,39.3 312.83,40.55 312.58,40.8 JIO1.32 ; 312.83,39.3 JIO1.38 ; 312.83,39.3 312.83,38.81 313.08,38.56 v2(313.08,38.06) ; JDIMM1.193 133.88,65.17 134.02,65.04 v2(134.97,65.04) 134.97,65.17 133.96,66.17 JDIMM1.197 ; JDIMM3.78 109.51,34.42 v2(109.29,34.2) ; v2(122.25,62.33) 122.25,62.3 122.81,61.74 ; JDIMM3.188 109.4,63.92 v2(109.34,63.86) ; JMXM1.293 148,89.05 v2(147.99,89.05) ; v2(177.44,78.57) 177.25,78.76 JMXM1.174 ; JDIMM1.243 133.69,77.67 134.02,78 v2(134.96,78) ; JDIMM3.31 120.6,22.68 121.58,21.7 v2(121.58,21.17) ; v2(134.97,41.62) 134.91,41.68 JDIMM1.107 ; JIO2.112 53.37,49.85 v2(53.46,49.94) ; v2(108.62,29.92) 109.61,28.93 JDIMM3.56 ; 122.81,61.74 123.47,61.74 123.66,61.92 JDIMM1.180 ; 122.81,61.74 123.63,60.92 JDIMM1.176 ; v2(185.74,78.63) 185.75,78.64 JMXM1.148 ; JDIMM1.39 134.69,24.68 v2(135.28,25.27) ; JDIMM1.247 134.28,78.67 v2(134.85,79.24) 134.41,79.67 JDIMM1.251 ; JDIMM3.230 109.67,74.43 v2(109.35,74.75) ; v2(57.13,48.35) JIO2.105 ; v2(316.41,45.36) 316.35,45.3 JIO1.13 ; JIO2.148 v2(51.13,58.85) ; JMXM1.169 179,86.9 v2(178.94,86.85) 178.87,86.92 177.76,86.92 177.5,87.18 ; JDIMM1.202 123.49,67.43 v2(123.19,67.73) 123.19,68.06 123.55,68.43 JDIMM1.206 ; v2(135.25,37.45) 135.25,37.48 134.94,37.17 JDIMM1.89 ; JIO2.93 57.18,45.35 v2(57.19,45.36) ; v2(109.26,38.17) 109.51,38.42 JDIMM3.94 ; v2(150.91,89.3) 151,89.21 JMXM1.281 150.98,87.94 150.98,87.14 150.6,86.76 149.84,86.76 149.5,87.1 JMXM1.287 ; JDIMM1.98 123.18,39.42 v2(123.07,39.54) ; JMXM1.239 161.5,87.24 161.94,86.8 162.92,86.8 162.93,86.8 v2(163.24,86.8) 163,87.04 JMXM1.233 ; v2(184.03,86.85) 184,86.88 JMXM1.155 ; JDIMM3.64 109.1,30.93 v2(108.14,31.89) ; v2(195.99,78.7) 195.98,78.7 195.98,78.73 196.25,79 JMXM1.106 ; JIO1.23 314.28,42.8 314.05,42.57 314.05,41.74 v2(313.99,41.68) 314.36,41.3 JIO1.29 ; JDIMM3.90 109.24,37.42 v2(108.54,38.12) ; v2(108.45,66.42) 108.46,66.43 108.46,66.8 109.09,67.43 JDIMM3.202 ; 55.9,58.85 JIO2.147 v2(57.08,58.85) ; v2(108.14,27.67) 108.14,27.66 108.87,26.93 JDIMM3.48 ; UZ19.5 199.39,101.02 198.62,101.8 v2(198.62,102.04) ; JDIMM1.227 133.73,73.67 v2(134.27,73.14) 133.81,72.67 JDIMM1.223 ; JIO1.63 316.24,32.8 v2(316.38,32.94) ; JDIMM3.175 120.45,60.68 v2(120.76,60.37) ; v2(204.25,78.28) 204.75,78.77 JMXM1.72 204.75,80.81 204.54,81.02 202.57,81.02 202.25,80.7 JMXM1.82 ; JDIMM1.57 134.51,29.17 134.97,28.71 v2(134.97,28.69) ; v2(51.14,60.35) 52.3,60.35 ; JMXM1.226 v2(164.25,81.17) 163.24,81.17 162.75,80.68 JMXM1.232 ; JMXM1.143 187,87.1 186.85,86.95 v2(186.85,86.63) ; JDIMM3.69 120.78,32.17 v2(120.82,32.14) ; JDIMM3.65 120.71,31.17 v2(121.53,31.99) ; JDIMM3.213 121.09,70.17 v2(121.83,69.43) 121.58,69.17 JDIMM3.209 ; v2(122.85,31.97) 122.9,31.93 JDIMM1.68 ; JDIMM3.235 119.85,75.67 120.29,75.24 v2(121.43,75.24) 121.43,76.05 120.81,76.67 JDIMM3.239 ; v2(134.9,17.86) 134.22,17.17 JDIMM1.9 ; 310.3,29.8 v2(310.18,29.67) ; 310.3,29.8 JIO1.76 ; v2(122.19,31.99) 122.19,32.52 122.59,32.93 JDIMM1.72 ; JDIMM3.168 109.09,58.92 v2(108.85,59.17) ; JDIMM1.184 123.52,62.92 123.09,62.49 v2(123.09,62.35) ; JDIMM1.14 123.23,18.42 122.8,18.85 v2(122.8,19.47) 122.85,19.42 JDIMM1.18 ; JMXM1.227 164.5,87.22 164.54,87.17 164.56,87.17 164.85,86.87 164.85,86.86 164.94,86.77 v2(165.05,86.77) 165.08,86.8 165.76,86.8 166,87.04 JMXM1.221 ; JDIMM3.214 109.54,70.43 v2(109.34,70.23) ; JIO2.99 57,46.85 v2(57.07,46.92) ; 311.66,34.3 JIO1.58 310.81,34.3 309.78,35.33 ; JDIMM1.189 134.87,64.17 v2(135.73,65.04) ; JMXM1.220 165.75,80.68 166.01,80.94 v2(167.4,80.94) 167.25,80.79 JMXM1.214 ; 55.9,61.85 JIO2.159 57.08,61.85 v2(57.19,61.74) ; JMXM1.131 190,87.06 v2(190.22,86.83) 191.12,86.83 191.5,87.21 JMXM1.125 ; JMXM1.95 199,87.21 198.54,86.76 v2(198.33,86.76) ; JDIMM3.252 109.75,79.92 v2(109.11,79.28) 109.47,78.92 JDIMM3.248 ; v2(108.75,17.21) 108.96,17.42 JDIMM3.10 ; JDIMM1.43 134.12,25.68 v2(134.52,25.27) ; JMXM1.168 178.75,78.65 v2(178.73,78.63) ; R775.1 176.66,104.27 177.55,103.39 179.01,103.39 179.41,103.78 179.41,105.04 C717.2 ; JDIMM1.10 123.6,17.42 123.43,17.26 v2(122.75,17.26) ; v2(146.73,89.08) 146.5,88.85 JMXM1.299 ; JMXM1.73 204.5,86.45 204.28,86.24 v2(203.36,86.24) ; v2(134.97,26.99) 134.66,26.68 JDIMM1.47 ; JDIMM1.185 134.25,63.17 v2(134.65,63.58) ; v2(182.74,78.63) 182.75,78.64 JMXM1.160 ; JDIMM1.192 123.08,64.92 122.42,65.59 v2(122.42,66.08) ; JMXM1.251 158.49,86.9 v2(158.63,86.76) 159.56,86.76 160,87.2 JMXM1.245 ; JDIMM1.235 134.11,75.67 134.4,75.39 v2(134.4,74.89) 134.18,74.67 JDIMM1.231 ; v2(108.74,63.88) 108.74,64.08 109.59,64.92 JDIMM3.192 ; v2(134.89,66.7) 134.89,66.76 134.48,67.17 JDIMM1.201 ; JIO2.87 55.02,43.85 v2(54.72,44.15) ; JDIMM3.234 109.24,75.43 108.75,74.93 v2(108.75,74.76) ; v2(199,78.38) 199,78.46 199.25,78.71 JMXM1.94 ; JDIMM1.23 134.15,20.68 v2(134.59,21.11) ; JDIMM3.223 121.34,72.67 v2(121.89,73.22) 121.89,73.31 121.52,73.67 JDIMM3.227 ; v2(107.96,17.26) 107.96,17.24 108.78,16.42 JDIMM3.6 ; JDIMM3.9 119.92,17.17 120.25,16.85 121.14,16.85 121.5,17.21 v2(121.5,17.35) ; JDIMM1.94 123.29,38.42 122.31,37.45 v2(122.31,37.43) ; v2(122.33,71.48) 122.33,71.18 121.98,70.82 121.23,70.82 120.88,71.17 JDIMM3.217 ; JDIMM1.244 123.55,77.92 123.37,78.1 v2(123.37,78.59) ; v2(180.41,78.63) 180.25,78.79 JMXM1.162 ; JDIMM3.14 109.05,18.42 v2(107.98,19.49) ; JDIMM1.93 135.62,38.17 135.86,37.94 v2(135.86,37.45) ; JDIMM1.35 133.73,23.68 134.26,24.21 135.03,24.21 v2(136.04,25.23) ; v2(135.73,35.75) 135.15,35.17 JDIMM1.81 ; v2(191.5,78.59) 191.5,78.59 191.75,78.84 JMXM1.124 ; JDIMM3.218 109.67,71.43 108.72,70.47 v2(108.72,70.23) ; JDIMM1.22 122.92,20.42 v2(121.98,19.49) ; JDIMM3.52 109.02,27.93 v2(108.82,27.73) ; JDIMM3.251 120.37,79.67 120.58,79.47 ; JDIMM3.244 109.48,77.92 v2(109.34,77.78) ; JDIMM3.43 120.77,25.68 v2(121.02,25.93) ; v2(122.98,76.6) 123.17,76.6 123.34,76.43 JDIMM1.238 ; JDIMM3.18 108.85,19.42 v2(108.8,19.47) ; v2(109.36,62.22) 109.66,61.92 JDIMM3.180 ; JDIMM3.85 119.84,36.17 120.16,36.5 v2(120.16,36.69) 120.16,37.02 120.01,37.17 JDIMM3.89 ; v2(187,78.52) 187,78.62 187.24,78.86 JMXM1.142 ; v2(108.85,31.97) 108.9,31.93 JDIMM3.68 ; JDIMM3.5 121.87,16.17 v2(122.03,16.01) ; JDIMM1.15 134.17,18.68 134.96,19.47 v2(134.96,19.47) 134.96,19.48 134.77,19.68 JDIMM1.19 ; JDIMM3.247 120.41,78.67 120.46,78.73 121.34,78.73 v2(121.4,78.67) 120.41,77.67 JDIMM3.243 ; JIO1.93 314.04,25.3 v2(313.86,25.48) 314.18,25.8 JIO1.91 ; v2(108.72,62.25) 108.72,62.46 109.19,62.92 JDIMM3.184 ; 177.5,87.18 177.2,86.89 176.32,86.89 176,87.21 JMXM1.181 ; 177.5,87.18 JMXM1.175 ; v2(184.01,78.59) 184.24,78.83 JMXM1.154 ; 120.95,23.68 119.95,24.68 JDIMM3.39 ; 120.95,23.68 v2(120.97,23.66) ; 120.95,23.68 JDIMM3.35 ; JIO2.136 v2(51.05,55.85) ; JDIMM1.64 123.2,30.93 122.49,30.22 v2(122.49,29.86) ; 134.31,70.17 v2(134.97,69.52) 134.62,69.17 JDIMM1.209 ; 134.31,70.17 134.57,70.43 134.57,71.17 JDIMM1.217 ; 134.31,70.17 JDIMM1.213 ; JDIMM3.107 119.87,41.68 120.34,42.15 121.02,42.15 121.29,41.88 v2(121.29,41.62) ; v2(108.14,23.66) 108.14,23.59 109.3,22.42 JDIMM3.30 ; v2(121.75,25.92) 121.75,25.94 121.02,26.68 JDIMM3.47 ; JMXM1.256 156.75,78.44 v2(156.56,78.25) ; v2(134.97,61.13) 134.51,60.68 JDIMM1.175 ; v2(135.01,76.89) 134.8,76.67 JDIMM1.239 ; JDIMM1.222 123.33,72.43 123.01,72.74 v2(123.01,73.26) 123.17,73.43 JDIMM1.226 ; JMXM1.238 161.25,80.5 v2(160.57,81.17) ; v2(57.07,57.53) 57.07,57.49 56.93,57.35 JIO2.141 ; v2(120.8,36.68) 120.8,36.06 119.91,35.17 JDIMM3.81 ; v2(108.01,68.26) 109.17,69.43 JDIMM3.210 ; JDIMM3.189 119.73,64.17 v2(120.16,63.75) 120.16,63.43 119.91,63.17 JDIMM3.185 ; v2(89.01,19.07) 89.52,19.58 UZ30.5 ; JDIMM3.26 108.85,21.42 v2(108.8,21.47) ; v2(135.73,26.99) 135.04,27.68 JDIMM1.51 ; JMXM1.88 200.75,78.83 v2(200.53,78.62) ; JMXM1.290 148.25,78.65 v2(148.15,78.55) 147.11,78.55 146.75,78.92 JMXM1.296 ; v2(57.08,55.88) 57.06,55.85 JIO2.135 ; JMXM1.136 188.75,78.66 188.77,78.64 v2(188.77,78.54) ; JDIMM3.103 120.01,40.68 120.58,41.24 v2(120.58,41.62) ; v2(121.21,38.04) 121.21,38.64 120.17,39.68 JDIMM3.99 ; JDIMM1.205 135.47,68.17 CD9.2 ; JMXM1.305 v2(145,89.19) ; JDIMM1.167 134.5,58.68 v2(134.97,59.14) 134.43,59.68 JDIMM1.171 ; JIO1.8 310.35,46.8 v2(310.3,46.76) ; v2(185.16,86.8) 185.5,87.13 JMXM1.149 ; v2(122.34,21.17) 122.34,21.88 122.89,22.42 JDIMM1.30 ; v2(108.87,68.19) 109.11,68.43 JDIMM3.206 ; JDIMM1.218 123.02,71.43 v2(122.98,71.47) ; JMXM1.244 159.75,81.15 v2(159.76,81.17) 158.57,81.17 158.25,80.85 JMXM1.250 ; v2(175.72,78.52) 175.75,78.54 JMXM1.180 ; JDIMM3.93 119.88,38.17 v2(120.02,38.04) ; JMXM1.137 188.5,86.88 v2(188.56,86.82) ; JIO1.35 316.76,39.8 v2(317,40.04) ; v2(108.8,23.69) 109.03,23.93 JDIMM3.36 ; v2(122.26,34.96) 123.73,36.42 JDIMM1.86 ; JDIMM1.196 123.23,65.92 v2(123.11,66.04) ; JDIMM3.196 109.54,65.92 v2(109.07,66.39) ; v2(317.16,47.33) 316.63,46.8 315.26,46.8 ; JIO2.118 53.42,51.35 v2(53.51,51.26) ; v2(108.73,77.76) 108.73,77.35 109.65,76.43 JDIMM3.238 ; v2(123.08,41.64) 123.29,41.42 JDIMM1.106 ; v2(121.08,27.76) 121,27.68 JDIMM3.51 ; JDIMM1.214 123.49,70.43 v2(122.52,69.45) 122.55,69.43 JDIMM1.210 ; v2(199.6,86.77) 200.08,86.77 200.5,87.19 JMXM1.89 ; JIO2.142 v2(51.11,57.35) ; v2(135.35,21.11) 134.79,21.68 JDIMM1.27 ; v2(168.74,78.63) 168.75,78.64 JMXM1.208 ; v2(123.15,63.97) 123.2,63.92 JDIMM1.188 ; v2(195.94,86.83) 196,86.88 JMXM1.107 ; JDIMM3.82 109.18,35.42 108.69,35.92 v2(108.69,36.2) ; v2(134.43,32) 134.43,32.02 134.44,32.03 134.44,32.29 133.96,32.78 133.96,32.85 133.63,33.17 JDIMM1.73 ; JDIMM3.60 109.35,29.93 v2(109.33,29.95) ; v2(57.07,49.85) JIO2.111 ; JDIMM1.168 123.63,58.92 123.59,58.89 v2(123.18,58.89) 123.18,59.49 123.62,59.92 JDIMM1.172 ; JDIMM1.77 133.96,34.17 v2(134.47,33.67) ; v2(109.33,36.22) 109.54,36.42 JDIMM3.86 ; v2(57.13,60.35) 57.12,60.35 JIO2.153 ; JDIMM1.85 134.58,36.17 v2(135.01,35.75) ; v2(108.08,25.69) 108.08,25.68 108.84,24.93 JDIMM3.40 ; v2(57.07,52.85) JIO2.123 ; JIO2.124 v2(51.1,52.85) ; JDIMM1.2 123.38,15.42 v2(122.81,15.99) 123.24,16.42 JDIMM1.6 ; JDIMM3.172 109.33,59.92 108.69,60.56 v2(108.69,60.68) ; JMXM1.194 172.25,78.94 171.81,78.51 170.75,78.51 170.25,79.01 JMXM1.202 170.25,81.14 v2(170.2,81.18) ; v2(108.61,73.01) 108.61,73.15 108.96,73.49 109.39,73.49 109.45,73.43 JDIMM3.226 ; v2(122.32,33.47) 122.32,33.93 122.82,34.42 JDIMM1.78 ; JDIMM3.106 109.23,41.42 v2(109.2,41.4) ; v2(121.83,29.86) 121.83,29.42 122.33,28.93 JDIMM1.56 ; JMXM1.112 194.75,78.81 v2(194.93,78.63) ; JMXM1.113 194.5,87.05 194.27,86.83 194.09,86.83 v2(194.08,86.82) 193.15,86.82 193,86.98 JMXM1.119 ; JDIMM3.231 121.68,74.67 v2(122.15,75.14) ; JDIMM1.181 134.96,62.17 v2(134.97,62.16) ; JDIMM1.48 123.07,26.93 122.49,26.35 v2(122.49,25.92) ; v2(149.27,78.55) 149.75,79.03 JMXM1.284 ; v2(134.97,14.65) 134.44,15.17 JDIMM1.1 ; JDIMM1.90 123.05,37.42 v2(123.05,37.43) ; v2(109.37,60.66) 109.63,60.92 JDIMM3.176 ; v2(57.07,51.35) JIO2.117 ; JDIMM3.1 118.19,15.17 118.03,15.01 v2(118.03,14.03) ; v2(197.1,86.78) 197.08,86.78 197.08,86.78 197.5,87.19 JMXM1.101 ; v2(123.25,23.69) 123.49,23.93 JDIMM1.36 ; v2(190.05,78.52) 190.24,78.71 JMXM1.130 ; v2(57.11,54.35) JIO2.129 ; 309.35,35.33 C723.2 ; v2(123.23,29.88) 123.27,29.93 JDIMM1.60 ; JDIMM3.171 120.03,59.68 120.35,59.35 v2(120.35,58.92) 120.1,58.68 JDIMM3.167 ; JMXM1.118 193.25,78.7 v2(193.17,78.63) ; JDIMM1.31 134.49,22.68 v2(134.97,23.15) ; JDIMM1.234 123.51,75.43 v2(123.1,75.02) 123.69,74.43 JDIMM1.230
  TOP w0.33: v2(189.7,29.63) 189.7,29.14 189.23,28.67 189.22,28.64 CPU1.BJ25
  TOP w0.356: CZ31.2 289.14,35.94 289.75,36.55 290.83,36.55 291.03,36.35 JKBTP1.21 ; v2(323.38,4.66) 323.4,4.67 323.4,5.17 323.07,5.49 322.57,5.49 322.32,5.24 U9.3
  TOP w0.381: PC1303.2 208.04,57.71 v2(207.72,57.39) 207.97,57.14 PC1271.2 ; UC6.3 220.95,106.6 v2(220.56,106.99) ; v2(9.11,17.98) PU1.2 ; PC1304.2 206.77,55.74 v2(206.51,55.99) 206.83,56.31 PC1317.2 ; PC1530.2 209.31,37.7 v2(209.05,37.96) 209.37,38.28 PC1540.2 ; PC1499.2 208.04,25.64 v2(207.78,25.89) 208.1,26.21 PC1485.2 ; PC1283.2 209.43,45.83 v2(209.12,45.52) 209.37,45.26 PC1311.2 ; PC1532.2 206.89,30.08 v2(206.58,29.77) 206.83,29.51 PC1514.2 ; PC1287.2 208.04,49.64 v2(207.72,49.33) 207.97,49.07 PC1319.2 ; PC1312.2 206.77,53.07 v2(206.51,53.33) 206.83,53.64 PC1313.2 ; PC1522.2 207.91,41.96 v2(207.66,42.21) 207.97,42.53 PC1482.2 ; PC1302.2 209.18,53.07 208.93,53.33 ; PC1531.2 208.1,30.85 v2(207.85,31.1) 208.16,31.42 PC1521.2 ; PC1495.2 209.37,32.18 v2(209.12,32.43) 209.43,32.75 PC1503.2 ; PC1284.2 206.83,50.98 v2(206.51,50.66) 206.77,50.4 PC1318.2 ; v2(188.24,104.55) 188.24,103.85 188.57,103.53 UC4.3 189.22,103.18 188.83,102.79 RC318.2 ; 208.93,53.33 209.24,53.64 PC1323.2 ; 208.93,53.33 v2(208.94,53.33) ; PC1498.2 208.1,28.81 v2(207.78,28.5) 208.04,28.24 PC1513.2 ; PC1494.2 206.7,37.7 v2(206.45,37.96) 206.77,38.28 PC1541.2 ; PC1282.2 208.04,47.04 v2(207.72,46.72) 207.97,46.47 PC1326.2 ; PC1538.2 206.77,26.97 v2(206.51,27.23) 206.83,27.54 PC1512.2 ; v2(158.22,77.93) 157.15,76.87 R519.1 157.15,75.99 157.01,75.85 U25.3 ; PC1298.2 206.7,45.26 v2(206.45,45.52) 206.77,45.83 PC1285.2 ; PC1299.2 206.8,48.3 v2(206.48,47.98) 206.73,47.73 PC1321.2 ; PC1497.2 208.1,34.15 v2(207.78,33.83) 208.04,33.58 PC1537.2 ; PC1545.2 209.43,26.97 v2(209.18,27.23) 209.5,27.54 PC1544.2 ; U16.3 173.58,73.16 173.58,75.47 173.66,75.56 ; PC1500.2 209.43,29.51 v2(209.18,29.77) 209.5,30.08 PC1523.2 ; PC1316.2 209.31,56.31 v2(208.99,55.99) 209.24,55.74 PC1314.2 ; U27.3 145.18,76.36 145.37,76.55 145.37,76.78 145,77.14 R60.2 ; PC1511.2 206.89,32.75 v2(206.58,32.43) 206.83,32.18 PC1539.2 ; RH358.2 109.78,116.96 v2(109.78,117.39) ; PC1273.2 208.04,54.98 v2(207.72,54.66) 207.97,54.41 PC1324.2 ; PR767.2 30.96,36.99 PQ708.1 ; PC1516.2 209.43,35.55 v2(209.12,35.23) 209.37,34.97 PC1481.2 ; v2(136.35,69.5) 136.81,69.5 137.27,69.04 CD97.2 ; PC1286.2 208.1,44.56 v2(207.78,44.25) 208.04,43.99 PC1320.2 ; PC1519.2 208.04,39.67 v2(207.72,39.36) 207.97,39.1 PC1515.2 ; v2(225.36,114.31) U15.3 ; PC1517.2 209.37,41.07 v2(209.05,40.75) 209.31,40.5 PC1548.2 ; PC1291.2 209.4,48.31 v2(209.08,47.99) 209.33,47.74 PC1297.2 ; PC1520.2 206.77,34.91 v2(206.51,35.16) 206.83,35.48 PC1487.2 ; PC1329.2 209.18,58.6 v2(208.93,58.85) 209.24,59.17 PC1301.2 ; C92.2 216.99,74.84 v2(216.99,74.25) ; PC1528.2 208.04,36.31 v2(207.78,36.56) 208.1,36.88 PC1542.2 ; UC3.3 142.89,126.28 142.77,126.41 RH70.2 ; PC1486.2 206.64,40.5 v2(206.39,40.75) 206.7,41.07 PC1505.2 ; UC7.3 v2(88,19.47) ; U58.3 305.51,12.24 305.31,12.44 v2(304.91,12.44) ; U14.3 149.24,76.36 149.06,76.54 149.06,76.99 149.27,77.2 v2(149.27,77.94) ; PC1325.2 209.31,50.98 v2(208.99,50.66) 209.24,50.4 PC1289.2 ; PC1270.2 207.97,51.74 v2(207.72,51.99) 208.04,52.31 PC1331.2 ; v2(44.67,10.86) UD1.3
  TOP w0.406: v2(168.38,94.64) 168.87,95.13 Q367.1 ; U639.2 8.01,35.16 8.36,34.81 11.55,34.81 v2(11.65,34.91) ; v2(10.58,41.74) Q29.4 ; v2(10.04,43.04) Q29.1 ; v2(11.19,52.06) U6.3
  TOP w0.432: v2(335.64,44.7) 335.64,44.7 335.7,44.76 PQ1074.4 ; PQ1074.1 v2(338.32,42.89) ; PQ1073.4 v2(26.98,38.4) ; PU105.3 v2(338.26,39.2)
  TOP w0.457: R51.2 176.38,74.55 176.68,74.24 v2(177.33,74.24) ; v2(255.69,89.56) 255.55,89.41 U8.1 ; C330.2 281.74,43.52 C370.2 282.26,43.23 283.52,43.23 v2(283.67,43.38) ; v2(162.28,15.45) 162.16,15.58 162.16,15.61 161.84,15.93 CC35.2 ; CZ82.2 200.11,97.67 199.75,97.31 v2(199.75,96.86) ; U8.10 252.78,96.61 252.58,96.41 v2(252.58,96.22) ; v2(129.33,137.31) 129.33,139.2 JEDP1.41 ; v2(246.21,88.86) U8.36 ; v2(24.11,26.82) 23.91,26.82 23.68,26.59 CN67.2 ; JKBTP1.1 v2(290.71,35.35)
  TOP w0.508: v2(135.72,81.68) 135.72,81.59 135.93,81.39 CD2.2 CD21.2 ; v2(239.2,88.72) 239.5,88.41 C35.2 ; v2(254.64,35.05) 254.9,34.78 PC1642.2 ; RH324.1 39.6,21.61 v2(39.79,21.8) ; CD18.2 138.02,34.88 CD20.2 137.52,34.63 136.42,35.73 v2(136.42,35.75) ; v2(105.76,21.75) CD110.2 105.26,22.99 CD107.2 ; C617.2 v2(3.47,10.47) ; CD144.2 46.29,13.23 45.46,14.05 v3(44.76,14.05) 44.49,13.78 v2(44.49,11.96) ; v2(135.54,133.79) 135.51,133.82 CH5.1 CH4.1 ; C485.1 v2(255.88,128.67) ; PC310.2 334.81,21.29 v2(335.07,21.55) ; R139.2 R141.2 R137.2 R138.2 152.96,142.81 v2(153.01,142.86) ; v2(188.56,154.66) 188.71,154.66 C701.2 ; R60.2 145.59,77.49 v2(145.62,77.52) ; RN107.2 31.55,28.49 v2(31.73,28.67) 31.73,28.39 32.03,28.09 RN58.2 ; R723.2 217.89,121.54 217.66,121.31 v2(217.66,120.99) ; v2(58.89,31.07) 59.54,31.72 C724.2 C1431.2 ; v2(131.2,5.51) RD44.2 130.34,6.18 CD139.2 130.33,5.91 129.66,5.24 RD30.2 ; C97.1 181.08,137.75 v2(181.33,137.5) 181.35,137.51 C783.2 ; v2(66.79,44.8) JUSH1.3 ; CD102.2 CD103.2 135.8,64.97 v2(135.73,65.04) ; CZ89.2 187.3,96.04 187.92,95.42 188.98,95.42 189.21,95.19 v2(189.21,94.7) ; CD8.2 135.81,88.76 135.39,88.35 v2(135.11,88.35) ; CC186.1 219.03,71.28 v2(219.46,70.84) ; C437.1 213.03,99.87 212.32,100.58 212.32,101.44 212.62,101.73 v2(212.89,101.73) ; C704.2 v2(190.65,146.74) ; v2(165.9,115.78) 165.81,115.69 RV37.2 RV38.2 ; v2(44.51,30.91) RN57.2 43.51,30.91 43.41,31.01 RN126.2 ; CZ90.2 187.82,100.55 188.03,100.76 190.48,100.76 190.78,101.06 CZ63.2 190.38,101.37 v2(190.16,101.58) ; v2(308.17,11.37) 308,11.2 C778.2 ; C536.2 217.61,125.88 217.02,125.29 v2(217.02,124.29) ; v2(69.7,36.02) 69.48,35.8 JUSH1.21 ; v2(198.23,11.74) PC1625.2 PC1624.2 ; v2(71.49,3.96) PR514.2 ; C784.2 154.19,143.68 154.41,143.47 v2(154.41,142.9) ; v2(278.24,39.39) 278.24,39.84 278.65,40.25 ; v2(253.22,10.18) 253.47,9.92 PD2.1 ; v2(256.4,103.91) C1177.2 256.28,104.59 C469.2 ; v2(110.74,113.43) 110.37,113.06 RH326.1 ; v2(264.52,48.43) PC1108.1 PR1118.1 ; C554.2 151.42,137.53 151.26,137.37 v2(151.3,137.37) ; CZ30.2 289.14,32.24 v2(289.53,31.86) ; v2(257.53,111.27) C466.2 ; v2(135.65,78) 135.82,77.83 CD22.2 136.79,77.83 138.28,79.32 138.28,82.59 JMXM1.312 139.55,79.66 139.55,79.65 137.44,77.54 137.44,76.88 136.61,76.05 CD4.2 136.44,75.31 v2(136,74.87) ; C494.2 175.11,135.08 175.18,135.15 175.14,135.15 175.19,135.2 v2(175.24,135.2) ; JUSH1.27 68.98,46.8 v2(69.83,47.65) 70.67,46.8 JUSH1.28 ; v2(185.73,94.74) 185.75,94.76 185.75,97.26 C1424.2 ; C623.2 v2(24.11,11.35) ; RD18.1 166.22,63.46 163.17,60.41 163.17,50.76 v2(161.67,49.25) ; PR316.1 v2(332.7,25.42) ; v2(58.34,3.77) PC1806.2 ; v2(183.37,116.94) 183.37,116.92 183.79,116.5 C709.2 R804.2 ; v2(345.15,29.93) 345.53,29.55 PR105.1 ; v2(143.68,107.24) 144.17,107.24 R147.2 ; v2(103.81,65.92) 104.59,66.7 CD63.2 ; C94.2 143.29,73.69 v2(143.75,73.23) 143.74,73.23 C332.2 ; PR308.2 331.95,21.26 332.51,20.7 PC309.2 v2(331.81,20.53) ; v2(55.48,3.77) PR1814.2 ; CD137.2 CD138.2 ; CD138.2 CD140.2 ; CD138.2 v2(133.88,5.56) ; CD75.2 137.01,60.1 137.42,60.51 v2(137.9,60.51) RD10.2 ; C723.2 308.75,35.72 v2(308.19,36.28) ; v2(30.97,22.73) 30.88,22.64 C395.2 C406.2 ; RD47.2 106.5,52.26 CD41.2 CD111.2 107.75,52.17 v2(108.18,52.6) ; v2(52.62,3.77) PR1813.1 ; R1970.1 209.55,90.64 209.96,90.22 209.96,89.93 v2(209.97,89.93) 210.14,90.1 210.87,90.1 C7.2 ; CD89.2 136.42,21.04 CD12.2 136.36,17 v2(135.6,16.24) ; RN105.2 v2(28.81,23.21) ; v2(15.18,24.11) 14.95,23.88 PQ8.6 ; CD51.2 96.37,74.81 v2(96.23,74.67) 95.65,74.67 95.36,74.96 CD53.2 ; R2160.2 167.73,156.74 v2(168.25,157.26) ; C1427.2 C1426.2 59.6,21.79 59.9,22.09 v2(59.9,22.33) ; v2(296.42,7.73) 295.19,6.5 293.98,6.5 293.55,6.93 JLED1.6 ; v2(151.43,96.41) 151.3,96.41 150.92,96.03 150.92,94.99 151.25,94.66 C496.2 ; JKBTP1.23 v2(293.35,24.85) JKBTP1.24 ; v2(108.91,43.67) 108.91,43.99 108.12,44.77 CD42.2 CD116.2 ; v2(106.51,29.87) 106.21,29.87 CD106.2 ; v2(214.8,96.48) 214.42,96.1 C764.2 214.1,96.17 C542.1 ; JTS1.1 134.3,129.92 134.73,129.5 137.08,129.5 v2(137.14,129.43) ; v2(245.03,112.22) C463.2 C467.2 ; PR1802.1 60.61,6.51 v2(60.81,6.31) ; v2(103.71,53.33) 103.71,53.19 CD68.2 104.74,52.17 CD117.2 ; C1421.2 208.12,98.95 v2(208.55,98.52) ; v2(63.94,43.09) CZ10.2 ; v2(330.03,35.77) 329.68,35.77 329.37,36.09 C762.2 ; v2(202.94,43.03) 203.13,43.23 PR1620.1 ; C400.2 14.88,44.41 v2(14.01,44.41) ; v2(342.86,53.42) 342.66,53.22 PR1031.1 ; PD4.1 29.35,42.79 v2(29.19,42.63) ; C6.2 287.99,4.85 v2(287.62,5.23) ; CD27.2 138.92,26.98 v2(139.42,27.48) ; PC119.2 345.68,28.51 v2(345.15,29.04) ; v2(4.74,51.26) C401.2 ; v2(226.92,37.67) 226.37,37.67 PC1457.2 ; v2(222.74,111.21) 224.13,112.6 Q87.3 ; PR310.2 330.94,23.83 v2(330.42,23.83) ; CD36.2 131.25,90.87 v2(130.73,91.4) 129.96,90.63 CD105.2 ; C99.1 149.11,102.26 v2(149.14,102.22) 149.14,103.01 C785.2 ; RH334.2 116.63,128.16 116.25,128.54 v2(116.25,129.39) ; R558.2 255.83,119.48 255.58,119.22 v2(255.33,119.22) C1418.2 ; JFAN2.4 272.54,42.68 v2(271.7,42.68) ; v2(115.04,140.23) 115.42,140.23 116.18,139.47 JEDP1.43 ; PC1600.1 262.54,31.09 v2(262.99,30.63) ; R492.1 159.2,146.91 v2(159.37,146.74) ; CD6.2 137.96,43.82 CD94.2 CD96.2 139.67,43.26 CD13.2 141.28,43.26 v2(141.36,43.19) ; RV48.2 170.4,94.25 v2(171.11,93.55) 170.85,93.3 C507.2 ; v2(278.81,30.37) 278.49,30.06 PC714.2 ; PC5.2 246.52,13.91 v2(246.53,13.93) ; JUSH1.17 67.23,37.8 66.78,38.25 v2(66.78,38.82) ; v2(94.05,93.45) 94.4,93.1 JFAN1.5 ; PC1612.1 262.67,25.22 v2(262.76,25.3) ; v2(212.29,36.4) PC1419.2 PC1418.2 ; 333.48,40.94 333.63,41.09 CZ94.2 334.34,41.73 v2(334.24,41.83) ; PR1001.2 326.81,52.57 v2(326.81,51.95) ; PC737.2 v2(266.99,29.87) ; v2(234.32,17.98) 234.76,17.98 PH1104.2 ; PQ1011.3 v2(339.21,60.46) ; C100.1 165.33,93.43 v2(165.27,93.49) 165.24,93.47 C506.2 ; C450.2 v2(300.44,32.51) ; v2(145.08,137.31) 144.45,137.93 C500.2 144.45,139.34 C501.2 ; CD143.2 105.99,55.9 105.77,56.12 105.77,56.81 v2(105.81,56.85) 106.39,56.85 CD79.2 ; v2(191.41,154.64) 191.48,154.58 C703.2 ; PR1116.1 PC1100.1 263.31,47.33 263.75,47.76 v2(263.89,47.76) ; JPB1.6 285,45.26 283.7,46.56 JPB1.8 283.7,47.9 284.52,48.72 292.84,48.72 v2(293.54,48.03) 293.54,47.69 292.78,46.92 JPB1.7 ; v2(6.9,10.44) C621.2 C618.2 ; v2(108.23,43.7) 108.02,43.91 CD108.2 CD59.2 ; v2(180.3,12.4) 180.3,12.63 181.07,13.41 CC190.2 v2(181.17,14.12) RC175.1 ; C36.2 253.6,83.93 254.16,83.37 254.16,81.97 LED5.1 253.84,81.87 252.82,82.89 v2(252.45,82.89) ; CD115.2 105.5,26.34 CD120.2 106.34,27.18 v2(106.34,27.64) 106.07,27.91 CD109.2 ; PR1028.2 v2(339.88,56.28) ; PD3.1 v2(251.76,10.56) ; v2(293.22,26.75) 292.82,26.35 JKBTP1.19 ; CD34.2 137.9,30.74 137.32,30.16 135.98,30.16 135.82,30.32 v2(135.82,30.34) ; RN100.2 v2(21.21,31.62) 21.21,31.16 20.53,30.47 RN53.2 ; CD80.2 108.45,58.77 v2(108.85,59.17) ; PC1807.2 55.51,11.67 PR1808.2 ; CD3.2 135.72,84.08 v2(135.66,84.15) 135.66,84.43 CD7.2 ; RN101.2 v2(21.31,34.28) ; PC1417.2 PC1416.2 v2(212.29,30.59) ; PC741.1 v2(266.93,28.09) ; v2(154.73,116.78) 155.05,117.1 RV28.1 154.28,117.48 CV27.2 ; v2(202.33,45.19) 202.16,45.36 PR1129.2 ; v2(154.97,15.77) 154.97,15.24 154.67,14.94 CC33.2 CC37.2 ; CD114.2 105.02,63.65 v2(105.01,63.66) ; v2(141.95,128.92) 141.22,128.2 JTS1.8 ; CD39.2 104.74,71.9 v2(104.47,72.17) ; JDIMM1.262 123.52,86.3 v2(124.31,87.09) ; v2(69.83,43.9) 69.83,44.98 70.15,45.3 JUSH1.2 ; R155.2 169.99,92.87 C507.2 ; v2(135.3,115.41) 136.32,115.41 136.45,115.54 RH357.2 137.38,115.54 137.95,114.97 RH193.2 ; v2(75.23,42.58) CZ11.2 ; v2(161.01,116.86) 161.62,117.46 CV29.2 ; CD122.2 107.51,39.06 v2(108.03,39.58) ; CC185.2 165.45,51.59 v2(166.17,50.87) ; v2(178.19,136.31) 177.79,136.31 v3(177.08,137.02) 176.59,137.51 R115.2 176.57,138.07 C499.2 ; v2(65.24,18.19) PC212.2 ; R122.2 186.35,140.29 v2(186.41,140.36) ; CZ5.2 190.37,127.51 v2(190.42,127.46) ; C502.2 143.81,141.09 ; 143.81,141.09 R101.1 ; 143.81,141.09 143.82,141.11 R136.2 145.06,140.5 145.14,140.42 v2(145.14,140.36) ; v2(75.28,44.36) CZ57.2 ; PC800.2 100.39,130.76 PR808.2 100.37,131.29 100.46,131.38 v2(100.46,131.52) ; PR1003.2 284.22,5.02 PC1005.2 v2(284.31,5.75) ; CD100.2 CD24.2 136.28,24.99 v2(136.04,25.23) ; C1423.2 180.59,101.45 179.94,100.81 v2(179.94,100.77) ; PR764.2 v2(272.6,23.53) ; PC1008.2 338.29,50.57 337.84,50.12 v2(337.33,50.12) ; CD72.2 101.96,74.92 101.76,74.72 v2(101.76,74.44) ; CD40.2 CD119.2 105.07,62.5 v2(104.94,62.38) ; C1471.2 v2(86.03,24.61) ; R148.2 150.88,107.84 150.52,108.2 150.52,109.04 v2(151.17,109.68) ; C404.2 27.03,18.82 26.82,19.03 C403.2 27.35,20.47 v2(27.53,20.47) ; v2(60.69,36.57) 60.59,36.47 C766.2 ; v2(293.73,29.42) 294.16,29.85 JKBTP1.12 ; v2(156.55,156.99) C702.2 ; v2(128.57,9.08) 128.57,7.57 128.39,7.4 ; v2(148.56,73.26) 148.57,73.25 C8.2 ; PQ3.3 v2(12.17,28.66) ; v2(239.79,121.96) C472.2 ; v2(175.43,109.28) 174.91,109.28 C718.2 174.68,109.51 R3741.2 ; C1410.2 289.46,30.17 288.89,29.6 C1414.2 v2(288.21,29.29) ; R106.1 C507.2 ; C722.2 v2(308.43,29.66) ; v2(243.29,125.27) C480.2 ; RD21.1 RD22.1 166.34,60.41 165.62,59.69 165.62,58.76 v2(166.68,57.7) ; C763.2 v2(318.49,23.2) ; CN71.2 40.14,33.68 v2(40.77,33.68) 40.77,34.13 41.03,34.39 42.01,34.39 42.37,34.03 RN125.2 ; RC319.1 198.89,14.17 PC1619.2 PC1626.2 198.8,12.85 v2(198.1,12.85) ; v2(279.51,29.61) 278.82,28.93 PD703.2 ; R3722.2 150.98,144.67 v2(150.58,145.07) ; v2(64.73,45.66) RZ10.1 ; v2(104.98,60.46) 105,60.47 CD49.2 ; RC306.1 162.54,15.2 v2(162.28,15.45) ; v2(194.1,132.16) 193.91,132.35 193.91,132.54 193.54,132.91 CZ7.2 CZ6.2 ; PC1007.2 v2(331.88,48.34) ; CD121.2 v2(100.69,74.47) ; v2(30.56,33.98) 30.74,33.8 CN75.2 30.74,32.61 31.09,32.25 RN106.2 31.32,31.16 32.06,30.42 RN117.2 ; PC118.2 354.1,33.08 v2(353.75,33.44) ; U17.3 218.47,77.37 v2(219.09,77.99) ; v2(192.9,123.21) 192.63,123.21 192.21,122.78 RZ82.2 ; C486.2 v2(255.95,123.53) ; CH267.2 109.06,100.74 109.96,99.84 v2(109.96,99.78) ; CD95.2 138.77,53.36 139.35,53.94 139.35,54.1 RD16.2 139.81,54.38 140.87,53.31 140.87,52.74 140.89,52.73 v2(140.89,52.75) ; C1456.2 C1428.2 45.84,37.42 46.05,37.21 v2(46.21,37.21) ; v2(138.22,6.5) 137.89,6.17 RD34.2 ; RN128.2 31.5,25.57 RN51.2 31.5,24.56 30.99,24.05 30.43,24.05 v2(30.33,23.95) ; v2(103.08,46.55) 103.73,47.2 CD45.2 CD64.2 105.47,47.47 CD60.2 CD142.2 107.74,47.47 108.12,47.85 v2(108.12,47.92) ; PC506.2 72.22,12.01 PR508.2 ; R935.2 C4.2 218.51,89.84 218.23,89.56 v2(218.16,89.56) ; PR745.2 v2(266.97,28.98) ; RV35.2 158.39,115.18 v2(157.89,115.69) ; RN118.2 33.15,29.89 33.53,29.51 v2(33.96,29.51) ; JEDP1.42 v2(125.87,139) ; v2(152.25,15.4) CC36.2 ; v2(125.37,6.4) 125.64,6.66 RD28.2 ; v2(160.98,114.67) 161.24,114.92 CV28.2 ; RN103.2 v2(23.93,34.56) ; CZ93.2 326.24,42.26 326.56,41.94 v2(326.56,41.61) ; CV31.2 CV42.2 155.09,114.21 v2(154.73,114.57) ; v2(104.46,69.58) 104.5,69.62 CD70.2 ; v2(335.81,60.41) 335.62,60.22 PR1018.2 ; RC322.2 RC323.2 ; C483.2 C1167.2 v2(225.11,143.32) ; v2(327.51,19.9) 327.51,20.47 327.44,20.54 PC312.2 PR303.2 ; v2(137.56,37.36) 138.46,37.36 138.92,37.82 CD28.2 CD31.2 ; C543.1 C544.1 v2(299.81,30.5) ; PC1009.2 v2(339.88,52.92) ; v2(173.66,75.51) 173.66,75.61 173.18,76.09 R3750.2 ; JDEG3.2 263.55,60.09 v2(264.9,61.45) ; v2(73.4,3.89) PC507.2 ; v2(135.25,49.63) 135.25,50.11 136.11,50.97 CD10.2 CD90.2 ; C470.2 253.17,117.86 v2(252.99,118.04) Y3.2 ; v2(57.38,3.77) PR1809.2 ; PC151.1 v2(335.88,40.67) ; v2(229.42,112.91) 229.64,113.12 229.64,113.9 229.47,114.07 C478.2 C473.2 ; v2(153.94,126.08) 154.28,126.42 C1444.1 ; v2(244.07,115.34) R562.2 ; v2(103.1,44.81) 103.38,44.53 CD46.2 CD57.2 ; CD128.2 v2(138.79,60.5) 139.3,60.5 139.68,60.12 CD76.2 139.76,59.86 140.49,59.86 CD78.2 CD77.2 ; v2(35.89,23.57) 35.51,23.95 RN119.2 ; v2(93.13,73.36) 92.82,73.68 CD56.2 ; v2(105.01,65.81) 105.26,65.55 CD58.2 ; R411.1 v2(257.52,98.24) ; C310.2 142.16,132.67 v2(143.17,131.66) ; CD23.2 137.2,38.55 137.7,38.06 CD32.2 137.21,38.06 v2(136.61,37.45) ; C716.2 173.97,105.6 173.97,104.74 v2(173.98,104.73) ; CD30.2 132.38,90.7 132.06,91.02 v2(132.06,91.46) ; CD66.2 v2(99.33,77.49) ; JDEG3.7 266.83,60.2 266.17,60.86 v2(265.49,60.86) ; v2(295.64,4.55) 295.26,4.93 JLED1.9 ; C1411.2 296.7,26.85 v2(296.02,26.85) JKBTP1.18 ; C504.2 181.97,134.51 v2(181.33,135.15) ; v2(219.35,130.66) 219.63,130.38 C608.2 219.62,129.83 C607.1 C606.1 ; v2(265.9,41.36) 266.09,41.17 PC1101.1 ; CZ12.2 75.73,39.38 v2(75.73,39.96) ; C787.2 v2(319.14,5.79) ; C98.1 148.9,142.52 v2(149.01,142.64) ; v2(218.88,97.62) 218.61,97.62 218.29,97.94 218.29,98.79 218.85,99.35 218.85,100.48 218.37,100.96 218.05,100.96 217.38,101.63 UC5.3 ; R869.1 187.86,116.99 187.7,116.99 187.18,117.51 v2(186.76,117.51) ; CH29.2 CH46.2 135.96,98.89 CH32.2 137.24,97.78 137.8,97.23 138.23,97.23 v2(138.24,97.24) ; PR12.1 15.24,19.09 v2(15.4,18.93) ; JEDP1.45 105.48,144.32 107.48,146.32 v2(107.48,146.58) ; v2(320.57,42.18) 320.57,41.58 C610.2 C611.2 ; v2(297.56,34.62) 296.79,33.85 JKBTP1.4 ; v2(262.3,64.05) 261.58,64.77 JDEG3.8 ; RC174.1 RC176.1 RC224.1 v2(182.44,14.14) RC223.1 ; v2(135.32,63.58) 135.33,63.58 135.56,63.34 CD5.2 CD129.2 ; JDIMM1.261 115.15,10.8 114.44,10.08 v2(114.44,9.16) RD40.2 ; PC1002.2 283.96,16.66 v2(283.95,16.67) ; R150.2 149.08,107.11 v2(148.91,107.27) 148.44,107.27 148.21,107.04 R146.2 ; v2(29.95,36.66) PR767.2 ; RV45.1 158.86,117.01 v2(159.08,116.78) ; C1.2 v2(220.64,94.98) ; v2(296.27,32.53) 295.95,32.85 JKBTP1.6 ; v2(315.19,22.18) 314.64,21.62 JIO1.102 ; R96.1 174.82,137.66 v2(175.05,137.43) 174.45,136.84 C495.2 ; C605.2 C604.2 C603.2 220.07,109.6 220.07,109.44 220.39,109.11 222.13,109.11 v3(222.21,109.2) 222.76,109.75 v2(222.76,110.46) ; v2(34.7,30.04) 34.29,30.45 RN120.2 ; 251.07,103.83 251,103.76 v2(251,103.22) ; v2(74.29,3.89) PR510.2 ; JFAN2.5 269.97,47.88 269.97,44.77 v2(269.79,44.58) ; v2(212.29,33.55) PC1442.2 PC1439.2 ; C613.2 320.19,38.84 320.73,38.3 v2(322.22,38.3) ; v2(250.79,121.76) Y3.4 ; C31.2 C32.2 C33.2 C34.2 244,83.89 244.43,84.32 v2(244.57,84.32) ; C786.2 165.6,95.38 v2(165.27,95.71) ; PC805.2 v2(98.59,124.24) ; v2(165.87,114.66) 165.86,114.67 RV39.2 ; JFAN2.6 278.08,43.01 278.08,40.83 278.65,40.25 ; v2(43.72,28.49) 43.29,28.49 43.16,28.62 RN124.2 ; v2(19.22,26.17) QN5.3 ; v2(148.25,127.66) 147.64,128.26 145.51,128.26 CH65.2 CH33.2 ; v2(212.23,42.44) PC1427.2 PC1426.2 ; PR1610.2 262.79,26.12 v2(262.81,26.1) ; v2(106.65,49.63) 106.57,49.55 CD52.2 ; v2(257.53,112.23) C468.2 ; C364.2 98.26,97.12 C30.2 99.89,98.75 v2(99.89,99.14) ; v2(142.77,128.16) RH70.2 ; CD9.2 136.08,68.83 135.69,69.22 v2(135.69,69.52) ; R123.2 184.01,135.31 v2(183.61,135.71) ; CZ97.2 v2(92.43,24.61) ; PC704.2 v2(277.92,35.5) ; v2(134.97,61.13) 136.14,61.13 136.67,61.67 138.32,61.67 138.66,62.01 CD91.2 ; v2(296.27,35.38) 296.27,35.83 295.75,36.35 JKBTP1.22 ; C90.2 176.07,74.47 R51.2 ; SW1.1 v2(209,154.82) SW1.3 ; v2(10.82,53.12) R317.2 ; v2(212.29,39.45) 212.29,39.45 PC1431.2 PC1430.2 ; C713.2 184.74,107.87 C710.2 184.74,108.94 183.48,110.2 v2(183.23,110.2) ; v2(47.97,33.69) 47.97,33.48 48.23,33.23 C726.2 C1430.2 ; PC1006.2 330.6,47.71 v2(330.6,48.34) ; R121.2 186.94,138.1 v2(186.22,137.39) 185.9,137.07 R116.2 ; RN102.2 23.45,23.85 v2(23.68,23.62) ; PR770.2 v2(28.91,37.65) ; v2(93.52,102.81) 94.4,101.94 JFAN1.6 ; v2(116.25,6.37) 116.04,6.17 RD39.2 ; v2(104.45,70.33) 104.88,70.76 CD118.2 ; v2(141.85,121.5) 141.77,121.5 141.39,121.11 RH313.1 ; v2(308.49,23.87) 308.67,23.69 C721.2 ; CE8.2 CE9.2 178.52,146.85 178.6,146.77 v2(178.6,146.64) ; v2(206.57,95.7) 206.57,95.2 206.98,94.8 C357.2 ; CC273.2 201.02,102.26 v2(201.27,102) ; v2(66.89,32.3) JUSH1.30 ; RC181.2 146.68,15.63 v2(146.89,15.42) RC122.2 ; v2(106.2,36.2) CD112.2 ; CC195.1 218.14,71.69 v3(217.47,71.02) 217.02,70.57 v2(216.77,70.57) ; RN111.2 21.14,24.18 20.72,24.59 v2(20.72,24.94) ; C622.2 v2(24.03,13.99) ; C464.2 v2(253.34,114.7) ; RV36.2 165.68,117.72 v2(165.84,117.56) ; JLED1.7 v2(290.05,6.63) JLED1.8 ; CD15.2 136.52,31.06 135.55,31.06 134.83,30.34 v2(134.83,30.34) ; v2(156.58,15.78) 156.58,15.69 156.87,15.4 CC269.2 ; C481.2 225.23,142.18 v2(224.11,143.3) ; PR1100.1 v2(202.16,55.84) ; v2(151.43,102.26) 151.43,102.63 C505.2 ; v2(6.96,40.11) C391.2 ; PC702.1 277.32,38.12 v2(278.1,38.12) ; CD99.2 139.67,47.33 CD101.2 CD104.2 136.73,46.71 CD11.2 136.05,47.38 v2(136.05,47.76) ; PR1167.2 v2(248.68,48.84) ; CD35.2 v2(98.4,74.72) 98.37,74.68 97.68,74.68 97.41,74.95 CD33.2 ; v2(227.8,26.44) PC1413.2 ; 278.65,40.25 PC709.2 ; v2(4.23,50.12) C392.2 ; CZ86.2 203.49,101.7 203.49,101.76 v2(203.94,102.2) ; v2(106.4,37.99) CD50.2 ; R757.2 166.52,147.01 v2(166.88,146.65) 167.41,147.19 C695.2 ; C696.2 166.84,157.17 v2(166.75,157.26) ; v2(226.91,27.64) PC1409.2 ; RD42.2 111.04,7.32 v2(111.04,6.43) ; v2(108.67,120.77) 108.07,120.18 U638.3 ; v2(202.41,112.31) 202.54,112.18 C779.2 ; v2(189.73,105.75) 190.17,106.19 CH17.2 ; v2(140.19,97.26) 140.19,97.46 CH13.2 ; v2(18.88,46.06) 18.8,46.15 C477.1 ; PC4.2 v2(261.83,6.32) ; CZ95.2 v2(89.56,17.85) ; CH10.2 145.35,125.19 v2(145.89,125.73) ; v2(204.28,110.69) 204.28,110.4 204.8,109.89 C1465.2 ; v2(324.18,23.29) 324.01,23.46 C614.2 C612.2 ; CN73.2 33.28,25.85 v2(33.28,26.56) 33.28,27.4 RN55.2 ; v2(94.21,74.26) CD55.2 ; CC174.2 CC173.2 CC169.2 176.89,16.14 176.76,16.27 v2(176.76,16.28) ; v2(106.51,31.01) 106.25,30.75 CD67.2 ; v2(227.8,16.23) PC1412.2 ; C717.2 179.01,105.43 C714.2 179.01,107.12 178.98,107.16 v2(178.98,107.23) ; v2(98.59,131.72) 98.47,131.59 PR806.2 ; v2(230.31,123.01) C474.2 ; R758.2 148.56,77.67 148.82,77.94 v2(149.27,77.94) ; R128.2 148.56,96.84 C503.2 R97.1 148.91,95.57 C497.2 150.12,96.38 v2(150.16,96.41) ; PC719.2 v2(265.07,19.51) ; v2(177.83,116.99) 177.83,116.5 C708.2 ; PC300.2 334.37,13.29 334.69,13.61 334.69,14.21 v2(334.66,14.24) ; CD17.2 104.5,74.48 v2(104.47,74.45) ; v2(262.56,30.13) 261.86,30.13 PR1600.1 ; CD93.2 135.58,34.26 135.56,34.28 135.03,34.28 135,34.26 134.71,34.26 134.55,34.09 134.55,33.74 v2(134.47,33.67) ; RN60.2 21.44,26.59 20.91,26.06 v2(20.91,25.67) ; v2(224.26,104.88) 224.26,104.96 224.17,105.05 C774.2 ; C471.2 v2(250.47,117.93) ; v2(69.59,3.96) PR513.1 ; C1425.2 59.34,29.69 v2(58.86,29.2) ; R158.2 R160.2 R156.2 R157.2 161.06,91.52 159.22,91.52 v2(159.06,91.69) ; RC227.1 RC229.1 RC228.1 v2(195.27,12.91) ; v2(226.91,17.43) PC1411.2 ; CD123.2 105.94,41.93 105.62,41.62 v2(105.62,40.93) CD92.2 ; CD98.2 v2(103.23,74.45) ; CD26.2 CD29.2 122.48,90.09 122.48,91.01 v2(122.66,91.18) ; CD44.2 CD47.2 119.1,6.24 v2(118.98,6.37) ; RH74.2 v2(142.98,116.78) ; v2(295.41,7.93) JLED1.10 ; CZ96.2 v2(90.28,25.67) ; JEDP1.44 109.22,141.02 v2(109.96,141.75) ; v2(345.15,32.98) 345.85,32.98 PC100.1 346.61,32.79 347.01,33.18 PR106.1 ; v2(227.83,36.6) PC1458.2 ; PC801.2 v3(98.78,112.96) ; C484.2 v2(255.88,122.26) ; C479.2 239.39,123.85 v2(238.61,123.85) ; C462.2 v2(243.95,112.8) ; v2(72.35,32.3) JUSH1.29 ; v2(293.1,36.35) JKBTP1.21 ; v2(148.28,124.71) 148.16,124.71 C1445.2 147.3,123.85 C547.1 147.3,122.63 147.68,122.24 C513.2 ; PD6.1 10.35,13.33 v2(9.88,13.8) ; C514.2 v2(300.82,28.28) ; v2(104.72,59.33) 105.26,58.78 CD81.2 CD82.2 ; CD124.2 103.52,41.93 103.32,41.73 v2(103.32,40.99) CD16.2 ; PC1004.2 v2(253.77,13.93) ; RH322.1 107.85,110.91 107.99,110.77 107.99,110.75 108.07,110.68 v2(108.07,109.77) 108.07,109.16 108.37,108.86 RH214.2 ; C725.2 v2(49.03,37.2) ; v2(78.06,6.9) PR502.1 ; v2(34.14,22.75) C5.2 ; v2(257.79,117.5) R557.2
  GND1 w0.254: 247.71,1.56 PBATT1.1 ; PBATT1.1 249.43,2.3 ; PBATT1.1 249.19,1.56 ; PBATT1.1 249.19,3.04 ; PBATT1.1 248.45,1.32 ; PBATT1.1 247.71,3.04 ; PBATT1.1 247.47,2.3 ; PBATT1.1 248.45,3.28 ; JDOCK1.160 171.33,156.68 ; JDOCK1.160 170.5,156.68 ; JDOCK1.160 170.5,155.18 ; JDOCK1.160 169.67,156.68 ; JDOCK1.160 169.67,155.93 ; JDOCK1.160 169.67,155.18 ; JDOCK1.160 171.33,155.93 ; JDOCK1.160 171.33,155.18 ; PBATT1.11 268.55,0.39 ; PBATT1.11 268.55,4.21 ; PBATT1.11 266.6,0.39 ; PBATT1.11 268.55,2.3 ; PBATT1.11 267.57,4.21 ; PBATT1.11 266.6,2.3 ; PBATT1.11 266.6,4.21 ; PBATT1.11 267.57,0.39 ; 150.64,150.37 JDOCK1.145 ; JDOCK1.145 152.01,152 ; JDOCK1.145 152.01,150.37 ; JDOCK1.145 150.64,152 ; JDOCK1.145 150.64,153.63 ; JDOCK1.145 151.32,153.63 ; JDOCK1.145 152.01,153.63 ; JDOCK1.145 151.32,150.37 ; H12.1 147.52,150.27 ; H12.1 148.08,148.75 ; H12.1 147.52,147.22 ; H12.1 144.47,150.27 ; H12.1 145.99,146.67 ; H12.1 144.47,147.22 ; H12.1 143.91,148.75 ; H12.1 145.99,150.83 ; H22.1 255.33,63.6 ; H22.1 254.84,62.26 ; H22.1 254.84,64.94 ; H22.1 252.16,64.94 ; H22.1 253.5,61.77 ; H22.1 253.5,65.43 ; H22.1 252.16,62.26 ; H22.1 251.67,63.6 ; JDOCK1.154 202.83,148.79 ; JDOCK1.154 202.83,147.36 ; JDOCK1.154 202.83,148.08 ; JDOCK1.154 201,148.79 ; JDOCK1.154 201,147.36 ; JDOCK1.154 199.17,147.36 ; JDOCK1.154 199.17,148.08 ; JLOM1.14 247.64,153.12 ; JLOM1.14 247.64,156.63 ; JLOM1.14 246.73,153.12 ; JLOM1.14 247.64,154.87 ; JLOM1.14 246.73,156.63 ; JDOCK1.159 195.13,151.37 ; JDOCK1.159 194.5,152.83 ; JDOCK1.159 193.86,152.64 ; JDOCK1.159 194.5,151.17 ; JDOCK1.159 195.13,152.64 ; JDOCK1.159 195.33,152 ; JDOCK1.159 193.86,151.37 ; JDOCK1.159 193.67,152 ; 200.99,152 JDOCK1.148 ; JDOCK1.148 201.67,150.37 ; JDOCK1.148 200.99,153.63 ; JDOCK1.148 202.36,150.37 ; JDOCK1.148 202.36,152 ; JDOCK1.148 200.99,150.37 ; JDOCK1.148 202.36,153.63 ; JDOCK1.148 201.67,153.63 ; H13.1 237.63,98.6 ; H13.1 237.15,97.25 ; H13.1 237.15,99.94 ; H13.1 234.46,97.25 ; H13.1 234.46,99.94 ; H13.1 233.97,98.6 ; H13.1 235.8,96.77 ; H13.1 235.8,100.43 ; 190,11.87 H5.1 ; H5.1 190,15.53 ; H5.1 188.66,15.04 ; H5.1 191.34,15.04 ; H5.1 188.66,12.36 ; H5.1 188.17,13.7 ; H5.1 191.83,13.7 ; H5.1 191.34,12.36 ; H29.1 256.99,147.47 ; H29.1 254.01,147.47 ; H29.1 255.5,150.93 ; H29.1 256.99,150.93 ; H29.1 255.5,147.47 ; H29.1 256.99,149.2 ; H29.1 254.01,150.93 ; H29.1 254.01,149.2 ; 181.67,155.18 JDOCK1.161 ; JDOCK1.161 181.67,155.93 ; JDOCK1.161 183.33,155.18 ; JDOCK1.161 182.5,155.18 ; JDOCK1.161 181.67,156.68 ; JDOCK1.161 183.33,155.93 ; JDOCK1.161 182.5,156.68 ; JDOCK1.161 183.33,156.68 ; H20.1 332.84,5.46 ; H20.1 330.16,5.46 ; H20.1 332.84,8.14 ; H20.1 333.33,6.8 ; H20.1 329.67,6.8 ; H20.1 331.5,4.97 ; H20.1 331.5,8.63 ; H20.1 330.16,8.14 ; 229.76,156.63 JLOM1.15 ; JLOM1.15 230.68,156.63 ; JLOM1.15 230.68,153.12 ; JLOM1.15 229.76,154.87 ; JLOM1.15 229.76,153.12 ; 44.16,3.76 H18.1 ; H18.1 46.84,6.44 ; H18.1 45.5,3.27 ; H18.1 43.67,5.1 ; H18.1 46.84,3.76 ; H18.1 47.33,5.1 ; H18.1 45.5,6.93 ; H18.1 44.16,6.44 ; JDOCK1.155 153.83,156.64 ; JDOCK1.155 150.17,156.64 ; JDOCK1.155 150.17,155.93 ; JDOCK1.155 152,155.21 ; JDOCK1.155 150.17,155.21 ; JDOCK1.155 153.83,155.93 ; JDOCK1.155 152,156.64 ; 42.8,25.3 H14.1 ; H14.1 42.8,21.9 ; H14.1 44.5,25.94 ; H14.1 42.17,23.6 ; H14.1 46.21,21.9 ; H14.1 46.84,23.6 ; H14.1 44.5,21.26 ; H14.1 46.21,25.3 ; 26.07,49.6 H9.1 ; H9.1 29.24,48.26 ; H9.1 29.24,50.94 ; H9.1 26.56,50.94 ; H9.1 27.9,51.43 ; H9.1 27.9,47.77 ; H9.1 29.73,49.6 ; H9.1 26.56,48.26 ; JDOCK1.158 183.33,152 ; JDOCK1.158 183.13,151.37 ; JDOCK1.158 181.67,152 ; JDOCK1.158 182.5,151.17 ; JDOCK1.158 183.13,152.64 ; JDOCK1.158 182.5,152.83 ; JDOCK1.158 181.86,152.64 ; JDOCK1.158 181.86,151.37 ; 117.57,154.1 H6.1 ; H6.1 118.06,152.76 ; H6.1 119.4,152.27 ; H6.1 120.74,155.44 ; H6.1 118.06,155.44 ; H6.1 121.23,154.1 ; H6.1 119.4,155.93 ; H6.1 120.74,152.76 ; JDOCK1.152 171.33,148.82 ; JDOCK1.152 169.67,147.33 ; JDOCK1.152 171.33,148.08 ; JDOCK1.152 170.5,148.82 ; JDOCK1.152 170.5,147.33 ; JDOCK1.152 169.67,148.82 ; JDOCK1.152 171.33,147.33 ; JDOCK1.152 169.67,148.08 ; 136.79,137.34 H27.1 ; H27.1 136.23,138.86 ; H27.1 139.83,140.38 ; H27.1 138.31,136.78 ; H27.1 138.31,140.94 ; H27.1 140.39,138.86 ; H27.1 139.83,137.34 ; H27.1 136.79,140.38 ; H17.1 257.33,144.7 ; H17.1 255.5,146.53 ; H17.1 256.84,146.04 ; H17.1 254.16,143.36 ; H17.1 253.67,144.7 ; H17.1 255.5,142.87 ; H17.1 256.84,143.36 ; H17.1 254.16,146.04 ; H19.1 274.24,6.16 ; H19.1 271.56,6.16 ; H19.1 274.73,7.5 ; H19.1 272.9,5.67 ; H19.1 274.24,8.84 ; H19.1 271.56,8.84 ; H19.1 272.9,9.33 ; H19.1 271.07,7.5 ; JDOCK1.162 202.83,156.64 ; JDOCK1.162 202.83,155.93 ; JDOCK1.162 199.17,155.93 ; JDOCK1.162 202.83,155.21 ; JDOCK1.162 201,156.64 ; JDOCK1.162 201,155.21 ; JDOCK1.162 199.17,156.64 ; 150.17,148.79 JDOCK1.151 ; JDOCK1.151 152,147.36 ; JDOCK1.151 153.83,147.36 ; JDOCK1.151 150.17,147.36 ; JDOCK1.151 150.17,148.08 ; JDOCK1.151 152,148.79 ; PBATT1.10 245.32,4.21 ; PBATT1.10 246.3,0.39 ; PBATT1.10 244.35,0.39 ; PBATT1.10 244.35,2.3 ; PBATT1.10 245.32,0.39 ; PBATT1.10 246.3,2.3 ; PBATT1.10 246.3,4.21 ; PBATT1.10 244.35,4.21 ; JDOCK1.157 171.13,152.64 ; JDOCK1.157 169.86,152.64 ; JDOCK1.157 170.5,152.83 ; JDOCK1.157 169.67,152 ; JDOCK1.157 171.13,151.37 ; JDOCK1.157 171.33,152 ; JDOCK1.157 169.86,151.37 ; 157.86,152.64 JDOCK1.156 ; JDOCK1.156 159.13,151.37 ; JDOCK1.156 157.67,152 ; JDOCK1.156 158.5,151.17 ; JDOCK1.156 159.33,152 ; JDOCK1.156 157.86,151.37 ; H1.1 171.24,15.5 ; H1.1 168.9,13.16 ; H1.1 167.2,13.8 ; H1.1 168.9,17.84 ; H1.1 170.6,17.2 ; H1.1 167.2,17.2 ; H1.1 166.56,15.5 ; H1.1 170.6,13.8 ; 196.96,136.45 SW2.5 ; SW2.5 197.72,138.21 ; SW2.5 196.72,137.21 ; SW2.5 198.48,136.45 ; SW2.5 197.72,136.21 ; SW2.5 198.72,137.21 ; SW2.5 198.48,137.97 ; SW2.5 196.96,137.97 ; 303.16,20 H23.1 ; H23.1 305.5,17.66 ; H23.1 307.2,18.3 ; H23.1 307.2,21.7 ; H23.1 307.84,20 ; H23.1 305.5,22.34 ; H23.1 303.8,21.7 ; H23.1 303.8,18.3 ; H30.1 347,63.93 ; H30.1 348.34,60.76 ; H30.1 348.83,62.1 ; H30.1 345.66,60.76 ; H30.1 348.34,63.44 ; H30.1 345.17,62.1 ; H30.1 347,60.27 ; H30.1 345.66,63.44 ; 201.66,71.7 H3.1 ; H3.1 204,69.36 ; H3.1 205.7,70 ; H3.1 205.7,73.4 ; H3.1 202.3,73.4 ; H3.1 206.34,71.7 ; H3.1 204,74.04 ; H3.1 202.3,70 ; 250.45,1.32 PBATT1.2 ; PBATT1.2 250.45,3.28 ; PBATT1.2 249.71,1.56 ; PBATT1.2 251.19,3.04 ; PBATT1.2 251.19,1.56 ; PBATT1.2 249.47,2.3 ; PBATT1.2 249.71,3.04 ; 181.67,148.08 JDOCK1.153 ; JDOCK1.153 182.5,147.33 ; JDOCK1.153 182.5,148.82 ; JDOCK1.153 181.67,147.33 ; JDOCK1.153 183.33,148.08 ; JDOCK1.153 181.67,148.82 ; JDOCK1.153 183.33,148.82 ; JDOCK1.153 183.33,147.33 ; 167.2,70.9 H4.1 ; H4.1 166.56,72.6 ; H4.1 167.2,74.3 ; H4.1 171.24,72.6 ; H4.1 170.6,70.9 ; H4.1 168.9,74.94 ; H4.1 170.6,74.3 ; H4.1 168.9,70.26 ; PBATT1.4 254.45,3.28 ; PBATT1.4 255.19,3.04 ; PBATT1.4 253.71,3.04 ; PBATT1.4 253.71,1.56 ; PBATT1.4 254.45,1.32 ; PBATT1.4 255.19,1.56 ; 203.26,137.97 SW2.4 ; SW2.4 204.02,138.21 ; SW2.4 203.26,136.45 ; SW2.4 204.02,136.21 ; SW2.4 203.02,137.21 ; SW2.4 205.02,137.21 ; SW2.4 204.78,137.97 ; SW2.4 204.78,136.45 ; 201.66,17.3 H2.1 ; H2.1 205.7,15.6 ; H2.1 204,14.96 ; H2.1 205.7,19 ; H2.1 202.3,19 ; H2.1 206.34,17.3 ; H2.1 204,19.64 ; H2.1 202.3,15.6 ; 91.96,110.26 H7.1 ; H7.1 95.13,111.6 ; H7.1 91.96,112.94 ; H7.1 93.3,109.77 ; H7.1 93.3,113.43 ; H7.1 94.64,112.94 ; H7.1 94.64,110.26 ; H7.1 91.47,111.6 ; 231.66,140.26 H10.1 ; H10.1 231.66,142.94 ; H10.1 231.17,141.6
  VCC w0.203: 255.5,142.87 H17.1 ; H17.1 253.67,144.7 ; H17.1 254.16,146.04 ; H17.1 254.16,143.36 ; H17.1 255.5,146.53 ; JLOM1.14 247.64,154.87 ; JLOM1.14 247.64,153.12 ; JLOM1.14 247.64,156.63 ; 254.01,149.2 H29.1 ; H29.1 254.01,147.47 ; H29.1 255.5,147.47
  VCC w0.254: 250.45,1.32 PBATT1.2 ; PBATT1.2 251.19,1.56 ; PBATT1.2 249.71,1.56 ; PBATT1.2 250.45,3.28 ; PBATT1.2 249.71,3.04 ; PBATT1.2 249.47,2.3 ; PBATT1.2 251.19,3.04 ; PBATT1.1 249.19,1.56 ; PBATT1.1 247.71,3.04 ; PBATT1.1 247.47,2.3 ; PBATT1.1 248.45,3.28 ; PBATT1.1 248.45,1.32 ; PBATT1.1 247.71,1.56 ; PBATT1.1 249.19,3.04 ; PBATT1.1 249.43,2.3 ; PBATT1.4 255.19,1.56 ; PBATT1.4 254.45,3.28 ; PBATT1.4 253.71,3.04 ; PBATT1.4 255.19,3.04 ; PBATT1.4 253.71,1.56 ; PBATT1.4 254.45,1.32 ; 266.6,4.21 PBATT1.11 ; PBATT1.11 268.55,2.3 ; PBATT1.11 266.6,2.3 ; PBATT1.11 267.57,4.21 ; PBATT1.11 268.55,4.21 ; PBATT1.10 246.3,2.3 ; PBATT1.10 244.35,4.21 ; PBATT1.10 245.32,4.21 ; PBATT1.10 246.3,4.21 ; PBATT1.10 244.35,2.3
  VCC w0.508: H1.1 170.6,13.8 ; H1.1 167.2,17.2 ; H1.1 168.9,13.16 ; H1.1 171.24,15.5 ; H1.1 168.9,17.84 ; H1.1 166.56,15.5 ; H1.1 167.2,13.8 ; H1.1 170.6,17.2
  IN3 w0.254: v2(213.5,131.11) 213.5,129.79 213.83,129.47 213.83,126.45 214.18,126.1 214.18,125.09 214.19,125.07 214.19,121.92 214.71,121.4 214.71,119.48 214.49,119.26 214.49,115.74 214.44,115.69 v2(214.44,115.5)
  GND2 w0.254: 247.47,2.3 PBATT1.1 ; PBATT1.1 249.19,3.04 ; PBATT1.1 249.19,1.56 ; PBATT1.1 247.71,3.04 ; PBATT1.1 248.45,3.28 ; PBATT1.1 248.45,1.32 ; PBATT1.1 249.43,2.3 ; PBATT1.1 247.71,1.56 ; 347,60.27 H30.1 ; H30.1 348.34,63.44 ; H30.1 348.34,60.76 ; H30.1 345.66,60.76 ; H30.1 345.17,62.1 ; H30.1 348.83,62.1 ; H30.1 347,63.93 ; H30.1 345.66,63.44 ; 266.6,4.21 PBATT1.11 ; PBATT1.11 268.55,4.21 ; PBATT1.11 268.55,2.3 ; PBATT1.11 267.57,0.39 ; PBATT1.11 268.55,0.39 ; PBATT1.11 267.57,4.21 ; PBATT1.11 266.6,0.39 ; PBATT1.11 266.6,2.3 ; 202.3,19 H2.1 ; H2.1 201.66,17.3 ; H2.1 206.34,17.3 ; H2.1 204,19.64 ; H2.1 202.3,15.6 ; H2.1 204,14.96 ; H2.1 205.7,15.6 ; H2.1 205.7,19 ; H7.1 94.64,112.94 ; H7.1 91.96,110.26 ; H7.1 91.47,111.6 ; H7.1 94.64,110.26 ; H7.1 95.13,111.6 ; H7.1 93.3,113.43 ; H7.1 91.96,112.94 ; H7.1 93.3,109.77 ; 202.3,73.4 H3.1 ; H3.1 205.7,73.4 ; H3.1 205.7,70 ; H3.1 202.3,70 ; H3.1 204,69.36 ; H3.1 204,74.04 ; H3.1 201.66,71.7 ; H3.1 206.34,71.7 ; PBATT1.2 251.19,3.04 ; PBATT1.2 249.71,3.04 ; PBATT1.2 249.71,1.56 ; PBATT1.2 250.45,1.32 ; PBATT1.2 249.47,2.3 ; PBATT1.2 250.45,3.28 ; PBATT1.2 251.19,1.56 ; 201,147.36 JDOCK1.154 ; JDOCK1.154 199.17,148.08 ; JDOCK1.154 199.17,147.36 ; JDOCK1.154 202.83,147.36 ; JDOCK1.154 201,148.79 ; JDOCK1.154 202.83,148.79 ; JDOCK1.154 202.83,148.08 ; H18.1 46.84,3.76 ; H18.1 45.5,3.27 ; H18.1 44.16,3.76 ; H18.1 44.16,6.44 ; H18.1 45.5,6.93 ; H18.1 47.33,5.1 ; H18.1 46.84,6.44 ; H18.1 43.67,5.1 ; 150.64,152 JDOCK1.145 ; JDOCK1.145 151.32,150.37 ; JDOCK1.145 150.64,153.63 ; JDOCK1.145 152.01,150.37 ; JDOCK1.145 152.01,152 ; JDOCK1.145 150.64,150.37 ; JDOCK1.145 152.01,153.63 ; JDOCK1.145 151.32,153.63 ; 181.67,147.33 JDOCK1.153 ; JDOCK1.153 182.5,148.82 ; JDOCK1.153 183.33,148.82 ; JDOCK1.153 183.33,147.33 ; JDOCK1.153 183.33,148.08 ; JDOCK1.153 181.67,148.08 ; JDOCK1.153 181.67,148.82 ; JDOCK1.153 182.5,147.33 ; H1.1 170.6,13.8 ; H1.1 167.2,17.2 ; H1.1 170.6,17.2 ; H1.1 168.9,17.84 ; H1.1 168.9,13.16 ; H1.1 171.24,15.5 ; H1.1 167.2,13.8 ; H1.1 166.56,15.5 ; 167.2,74.3 H4.1 ; H4.1 168.9,74.94 ; H4.1 166.56,72.6 ; H4.1 170.6,70.9 ; H4.1 167.2,70.9 ; H4.1 170.6,74.3 ; H4.1 168.9,70.26 ; H4.1 171.24,72.6 ; H14.1 46.21,21.9 ; H14.1 42.17,23.6 ; H14.1 42.8,21.9 ; H14.1 46.21,25.3 ; H14.1 46.84,23.6 ; H14.1 44.5,21.26 ; H14.1 42.8,25.3 ; H14.1 44.5,25.94 ; H13.1 235.8,100.43 ; H13.1 235.8,96.77 ; H13.1 234.46,97.25 ; H13.1 237.15,99.94 ; H13.1 237.15,97.25 ; H13.1 237.63,98.6 ; H13.1 233.97,98.6 ; H13.1 234.46,99.94 ; 231.66,140.26 H10.1 ; H10.1 231.66,142.94 ; H10.1 231.17,141.6 ; 196.72,137.21 SW2.5 ; SW2.5 196.96,136.45 ; SW2.5 197.72,136.21 ; SW2.5 198.48,137.97 ; SW2.5 196.96,137.97 ; SW2.5 198.72,137.21 ; SW2.5 197.72,138.21 ; SW2.5 198.48,136.45 ; H22.1 253.5,65.43 ; H22.1 254.84,62.26 ; H22.1 253.5,61.77 ; H22.1 252.16,62.26 ; H22.1 251.67,63.6 ; H22.1 254.84,64.94 ; H22.1 252.16,64.94 ; H22.1 255.33,63.6 ; 244.35,4.21 PBATT1.10 ; PBATT1.10 244.35,2.3 ; PBATT1.10 245.32,0.39 ; PBATT1.10 246.3,0.39 ; PBATT1.10 245.32,4.21 ; PBATT1.10 246.3,2.3 ; PBATT1.10 246.3,4.21 ; PBATT1.10 244.35,0.39 ; 136.79,140.38 H27.1 ; H27.1 139.83,137.34 ; H27.1 136.79,137.34 ; H27.1 136.23,138.86 ; H27.1 139.83,140.38 ; H27.1 138.31,136.78 ; H27.1 138.31,140.94 ; H27.1 140.39,138.86 ; 204.02,136.21 SW2.4 ; SW2.4 204.78,137.97 ; SW2.4 204.78,136.45 ; SW2.4 205.02,137.21 ; SW2.4 204.02,138.21 ; SW2.4 203.02,137.21 ; SW2.4 203.26,137.97 ; SW2.4 203.26,136.45 ; 303.16,20 H23.1 ; H23.1 305.5,17.66 ; H23.1 307.84,20 ; H23.1 305.5,22.34 ; H23.1 303.8,18.3 ; H23.1 307.2,18.3 ; H23.1 307.2,21.7 ; H23.1 303.8,21.7 ; 193.86,151.37 JDOCK1.159 ; JDOCK1.159 195.13,152.64 ; JDOCK1.159 195.13,151.37 ; JDOCK1.159 193.86,152.64 ; JDOCK1.159 195.33,152 ; JDOCK1.159 193.67,152 ; JDOCK1.159 194.5,151.17 ; JDOCK1.159 194.5,152.83 ; JLOM1.14 247.64,153.12 ; JLOM1.14 247.64,154.87 ; JLOM1.14 247.64,156.63 ; JLOM1.14 246.73,156.63 ; JLOM1.14 246.73,153.12 ; 181.86,152.64 JDOCK1.158 ; JDOCK1.158 181.67,152 ; JDOCK1.158 181.86,151.37 ; JDOCK1.158 182.5,151.17 ; JDOCK1.158 183.33,152 ; JDOCK1.158 182.5,152.83 ; JDOCK1.158 183.13,152.64 ; JDOCK1.158 183.13,151.37 ; H29.1 256.99,149.2 ; H29.1 254.01,150.93 ; H29.1 254.01,147.47 ; H29.1 254.01,149.2 ; H29.1 256.99,147.47 ; H29.1 256.99,150.93 ; H29.1 255.5,150.93 ; H29.1 255.5,147.47 ; H9.1 27.9,51.43 ; H9.1 26.56,50.94 ; H9.1 29.24,48.26 ; H9.1 26.56,48.26 ; H9.1 29.24,50.94 ; H9.1 26.07,49.6 ; H9.1 27.9,47.77 ; H9.1 29.73,49.6 ; 170.5,147.33 JDOCK1.152 ; JDOCK1.152 170.5,148.82 ; JDOCK1.152 171.33,148.82 ; JDOCK1.152 169.67,148.82 ; JDOCK1.152 169.67,147.33 ; JDOCK1.152 169.67,148.08 ; JDOCK1.152 171.33,147.33 ; JDOCK1.152 171.33,148.08 ; 254.16,143.36 H17.1 ; H17.1 253.67,144.7 ; H17.1 255.5,142.87 ; H17.1 254.16,146.04 ; H17.1 255.5,146.53 ; H17.1 256.84,143.36 ; H17.1 257.33,144.7 ; H17.1 256.84,146.04 ; JDOCK1.162 201,156.64 ; JDOCK1.162 202.83,155.93 ; JDOCK1.162 199.17,156.64 ; JDOCK1.162 201,155.21 ; JDOCK1.162 202.83,156.64 ; JDOCK1.162 202.83,155.21 ; JDOCK1.162 199.17,155.93 ; H20.1 332.84,8.14 ; H20.1 332.84,5.46 ; H20.1 330.16,8.14 ; H20.1 329.67,6.8 ; H20.1 330.16,5.46 ; H20.1 333.33,6.8 ; H20.1 331.5,8.63 ; H20.1 331.5,4.97 ; 157.67,152 JDOCK1.156 ; JDOCK1.156 157.86,152.64 ; JDOCK1.156 158.5,151.17 ; JDOCK1.156 159.33,152 ; JDOCK1.156 157.86,151.37 ; JDOCK1.156 159.13,151.37 ; JDOCK1.148 202.36,150.37 ; JDOCK1.148 200.99,153.63 ; JDOCK1.148 201.67,153.63 ; JDOCK1.148 202.36,153.63 ; JDOCK1.148 200.99,152 ; JDOCK1.148 201.67,150.37 ; JDOCK1.148 200.99,150.37 ; JDOCK1.148 202.36,152 ; H5.1 191.34,15.04 ; H5.1 190,15.53 ; H5.1 191.34,12.36 ; H5.1 191.83,13.7 ; H5.1 188.17,13.7 ; H5.1 190,11.87 ; H5.1 188.66,12.36 ; H5.1 188.66,15.04 ; H6.1 120.74,155.44 ; H6.1 118.06,152.76 ; H6.1 120.74,152.76 ; H6.1 121.23,154.1 ; H6.1 119.4,155.93 ; H6.1 117.57,154.1 ; H6.1 118.06,155.44 ; H6.1 119.4,152.27 ; JDOCK1.161 183.33,155.93 ; JDOCK1.161 181.67,155.93 ; JDOCK1.161 182.5,156.68 ; JDOCK1.161 181.67,155.18 ; JDOCK1.161 183.33,155.18 ; JDOCK1.161 183.33,156.68 ; JDOCK1.161 182.5,155.18 ; JDOCK1.161 181.67,156.68 ; 229.76,154.87 JLOM1.15 ; JLOM1.15 229.76,156.63 ; JLOM1.15 229.76,153.12 ; JLOM1.15 230.68,153.12 ; JLOM1.15 230.68,156.63 ; 253.71,1.56 PBATT1.4 ; PBATT1.4 255.19,3.04 ; PBATT1.4 254.45,1.32 ; PBATT1.4 254.45,3.28 ; PBATT1.4 253.71,3.04 ; PBATT1.4 255.19,1.56 ; H19.1 274.73,7.5 ; H19.1 271.56,6.16 ; H19.1 271.07,7.5 ; H19.1 272.9,5.67 ; H19.1 271.56,8.84 ; H19.1 274.24,6.16 ; H19.1 272.9,9.33 ; H19.1 274.24,8.84 ; 150.17,156.64 JDOCK1.155 ; JDOCK1.155 150.17,155.21 ; JDOCK1.155 152,156.64 ; JDOCK1.155 152,155.21 ; JDOCK1.155 153.83,155.93 ; JDOCK1.155 153.83,156.64 ; JDOCK1.155 150.17,155.93 ; H12.1 147.52,147.22 ; H12.1 144.47,150.27 ; H12.1 143.91,148.75 ; H12.1 147.52,150.27 ; H12.1 145.99,146.67 ; H12.1 145.99,150.83 ; H12.1 144.47,147.22 ; H12.1 148.08,148.75 ; 152,147.36 JDOCK1.151 ; JDOCK1.151 150.17,148.08 ; JDOCK1.151 153.83,147.36 ; JDOCK1.151 150.17,148.79 ; JDOCK1.151 152,148.79 ; JDOCK1.151 150.17,147.36 ; 169.67,155.93 JDOCK1.160 ; JDOCK1.160 169.67,156.68 ; JDOCK1.160 170.5,156.68 ; JDOCK1.160 169.67,155.18 ; JDOCK1.160 171.33,156.68 ; JDOCK1.160 171.33,155.18 ; JDOCK1.160 171.33,155.93 ; JDOCK1.160 170.5,155.18 ; 169.86,152.64 JDOCK1.157 ; JDOCK1.157 171.13,151.37 ; JDOCK1.157 170.5,152.83 ; JDOCK1.157 171.13,152.64 ; JDOCK1.157 169.86,151.37 ; JDOCK1.157 169.67,152 ; JDOCK1.157 171.33,152
  GND3 w0.254: 231.17,141.6 H10.1 ; H10.1 231.66,140.26 ; H10.1 231.66,142.94 ; H19.1 274.24,6.16 ; H19.1 272.9,9.33 ; H19.1 271.56,6.16 ; H19.1 272.9,5.67 ; H19.1 271.56,8.84 ; H19.1 274.24,8.84 ; H19.1 274.73,7.5 ; H19.1 271.07,7.5 ; 196.72,137.21 SW2.5 ; SW2.5 197.72,136.21 ; SW2.5 198.48,136.45 ; SW2.5 196.96,137.97 ; SW2.5 197.72,138.21 ; SW2.5 196.96,136.45 ; SW2.5 198.72,137.21 ; SW2.5 198.48,137.97 ; JDOCK1.153 183.33,148.08 ; JDOCK1.153 181.67,148.82 ; JDOCK1.153 183.33,147.33 ; JDOCK1.153 182.5,147.33 ; JDOCK1.153 181.67,148.08 ; JDOCK1.153 183.33,148.82 ; JDOCK1.153 181.67,147.33 ; JDOCK1.153 182.5,148.82 ; 204,69.36 H3.1 ; H3.1 202.3,70 ; H3.1 202.3,73.4 ; H3.1 206.34,71.7 ; H3.1 205.7,70 ; H3.1 205.7,73.4 ; H3.1 201.66,71.7 ; H3.1 204,74.04 ; 169.86,151.37 JDOCK1.157 ; JDOCK1.157 169.67,152 ; JDOCK1.157 171.13,152.64 ; JDOCK1.157 171.13,151.37 ; JDOCK1.157 171.33,152 ; JDOCK1.157 169.86,152.64 ; JDOCK1.157 170.5,152.83 ; 199.17,155.93 JDOCK1.162 ; JDOCK1.162 202.83,155.93 ; JDOCK1.162 202.83,155.21 ; JDOCK1.162 199.17,156.64 ; JDOCK1.162 201,155.21 ; JDOCK1.162 201,156.64 ; JDOCK1.162 202.83,156.64 ; H27.1 139.83,137.34 ; H27.1 138.31,140.94 ; H27.1 139.83,140.38 ; H27.1 136.23,138.86 ; H27.1 138.31,136.78 ; H27.1 136.79,137.34 ; H27.1 136.79,140.38 ; H27.1 140.39,138.86 ; JDOCK1.152 171.33,147.33 ; JDOCK1.152 169.67,148.82 ; JDOCK1.152 170.5,148.82 ; JDOCK1.152 169.67,147.33 ; JDOCK1.152 169.67,148.08 ; JDOCK1.152 171.33,148.82 ; JDOCK1.152 170.5,147.33 ; JDOCK1.152 171.33,148.08 ; H14.1 46.21,21.9 ; H14.1 42.8,25.3 ; H14.1 46.84,23.6 ; H14.1 42.8,21.9 ; H14.1 44.5,21.26 ; H14.1 42.17,23.6 ; H14.1 46.21,25.3 ; H14.1 44.5,25.94 ; 254.01,149.2 H29.1 ; H29.1 254.01,150.93 ; H29.1 254.01,147.47 ; H29.1 256.99,150.93 ; H29.1 255.5,150.93 ; H29.1 255.5,147.47 ; H29.1 256.99,147.47 ; H29.1 256.99,149.2 ; 303.8,21.7 H23.1 ; H23.1 307.2,18.3 ; H23.1 303.16,20 ; H23.1 307.2,21.7 ; H23.1 307.84,20 ; H23.1 305.5,17.66 ; H23.1 305.5,22.34 ; H23.1 303.8,18.3 ; JDOCK1.159 195.13,151.37 ; JDOCK1.159 194.5,151.17 ; JDOCK1.159 194.5,152.83 ; JDOCK1.159 193.86,151.37 ; JDOCK1.159 193.67,152 ; JDOCK1.159 195.13,152.64 ; JDOCK1.159 195.33,152 ; JDOCK1.159 193.86,152.64 ; H1.1 168.9,17.84 ; H1.1 166.56,15.5 ; H1.1 167.2,17.2 ; H1.1 170.6,13.8 ; H1.1 171.24,15.5 ; H1.1 170.6,17.2 ; H1.1 168.9,13.16 ; H1.1 167.2,13.8 ; JDOCK1.160 171.33,155.93 ; JDOCK1.160 170.5,155.18 ; JDOCK1.160 171.33,155.18 ; JDOCK1.160 169.67,155.93 ; JDOCK1.160 170.5,156.68 ; JDOCK1.160 169.67,155.18 ; JDOCK1.160 171.33,156.68 ; JDOCK1.160 169.67,156.68 ; H9.1 27.9,51.43 ; H9.1 29.24,48.26 ; H9.1 26.07,49.6 ; H9.1 26.56,48.26 ; H9.1 29.73,49.6 ; H9.1 27.9,47.77 ; H9.1 29.24,50.94 ; H9.1 26.56,50.94 ; JDOCK1.156 159.13,151.37 ; JDOCK1.156 157.67,152 ; JDOCK1.156 157.86,151.37 ; JDOCK1.156 157.86,152.64 ; JDOCK1.156 159.33,152 ; JDOCK1.156 158.5,151.17 ; H5.1 191.83,13.7 ; H5.1 188.66,12.36 ; H5.1 191.34,12.36 ; H5.1 190,15.53 ; H5.1 188.17,13.7 ; H5.1 190,11.87 ; H5.1 191.34,15.04 ; H5.1 188.66,15.04 ; 267.57,0.39 PBATT1.11 ; PBATT1.11 268.55,2.3 ; PBATT1.11 266.6,2.3 ; PBATT1.11 266.6,4.21 ; PBATT1.11 268.55,0.39 ; PBATT1.11 268.55,4.21 ; PBATT1.11 266.6,0.39 ; PBATT1.11 267.57,4.21 ; JDOCK1.154 201,148.79 ; JDOCK1.154 199.17,147.36 ; JDOCK1.154 202.83,147.36 ; JDOCK1.154 201,147.36 ; JDOCK1.154 202.83,148.79 ; JDOCK1.154 199.17,148.08 ; JDOCK1.154 202.83,148.08 ; H18.1 47.33,5.1 ; H18.1 45.5,3.27 ; H18.1 46.84,6.44 ; H18.1 43.67,5.1 ; H18.1 44.16,3.76 ; H18.1 46.84,3.76 ; H18.1 45.5,6.93 ; H18.1 44.16,6.44 ; JDOCK1.145 152.01,150.37 ; JDOCK1.145 150.64,153.63 ; JDOCK1.145 150.64,150.37 ; JDOCK1.145 150.64,152 ; JDOCK1.145 151.32,153.63 ; JDOCK1.145 151.32,150.37 ; JDOCK1.145 152.01,153.63 ; JDOCK1.145 152.01,152 ; H17.1 257.33,144.7 ; H17.1 255.5,142.87 ; H17.1 254.16,143.36 ; H17.1 256.84,146.04 ; H17.1 256.84,143.36 ; H17.1 255.5,146.53 ; H17.1 253.67,144.7 ; H17.1 254.16,146.04 ; 181.67,155.93 JDOCK1.161 ; JDOCK1.161 182.5,155.18 ; JDOCK1.161 183.33,155.18 ; JDOCK1.161 182.5,156.68 ; JDOCK1.161 181.67,156.68 ; JDOCK1.161 183.33,156.68 ; JDOCK1.161 183.33,155.93 ; JDOCK1.161 181.67,155.18 ; 252.16,62.26 H22.1 ; H22.1 254.84,62.26 ; H22.1 253.5,61.77 ; H22.1 251.67,63.6 ; H22.1 255.33,63.6 ; H22.1 253.5,65.43 ; H22.1 254.84,64.94 ; H22.1 252.16,64.94 ; 202.3,15.6 H2.1 ; H2.1 201.66,17.3 ; H2.1 204,19.64 ; H2.1 204,14.96 ; H2.1 206.34,17.3 ; H2.1 205.7,15.6 ; H2.1 202.3,19 ; H2.1 205.7,19 ; JLOM1.14 247.64,153.12 ; JLOM1.14 247.64,156.63 ; JLOM1.14 246.73,153.12 ; JLOM1.14 247.64,154.87 ; JLOM1.14 246.73,156.63 ; H6.1 120.74,152.76 ; H6.1 119.4,155.93 ; H6.1 118.06,152.76 ; H6.1 118.06,155.44 ; H6.1 121.23,154.1 ; H6.1 117.57,154.1 ; H6.1 120.74,155.44 ; H6.1 119.4,152.27 ; JDOCK1.151 153.83,147.36 ; JDOCK1.151 152,147.36 ; JDOCK1.151 152,148.79 ; JDOCK1.151 150.17,148.79 ; JDOCK1.151 150.17,148.08 ; JDOCK1.151 150.17,147.36 ; H7.1 95.13,111.6 ; H7.1 94.64,112.94 ; H7.1 93.3,109.77 ; H7.1 93.3,113.43 ; H7.1 91.96,110.26 ; H7.1 91.47,111.6 ; H7.1 91.96,112.94 ; H7.1 94.64,110.26 ; PBATT1.10 246.3,2.3 ; PBATT1.10 245.32,0.39 ; PBATT1.10 244.35,0.39 ; PBATT1.10 245.32,4.21 ; PBATT1.10 244.35,4.21 ; PBATT1.10 244.35,2.3 ; PBATT1.10 246.3,4.21 ; PBATT1.10 246.3,0.39 ; 331.5,4.97 H20.1 ; H20.1 330.16,5.46 ; H20.1 330.16,8.14 ; H20.1 332.84,8.14 ; H20.1 332.84,5.46 ; H20.1 329.67,6.8 ; H20.1 333.33,6.8 ; H20.1 331.5,8.63 ; 247.71,3.04 PBATT1.1 ; PBATT1.1 248.45,1.32 ; PBATT1.1 247.71,1.56 ; PBATT1.1 248.45,3.28 ; PBATT1.1 247.47,2.3 ; PBATT1.1 249.19,1.56 ; PBATT1.1 249.43,2.3 ; PBATT1.1 249.19,3.04 ; JDOCK1.148 202.36,150.37 ; JDOCK1.148 200.99,152 ; JDOCK1.148 202.36,153.63 ; JDOCK1.148 202.36,152 ; JDOCK1.148 200.99,150.37 ; JDOCK1.148 201.67,153.63 ; JDOCK1.148 200.99,153.63 ; JDOCK1.148 201.67,150.37 ; 229.76,154.87 JLOM1.15 ; JLOM1.15 229.76,156.63 ; JLOM1.15 230.68,156.63 ; JLOM1.15 230.68,153.12 ; JLOM1.15 229.76,153.12 ; 249.47,2.3 PBATT1.2 ; PBATT1.2 249.71,1.56 ; PBATT1.2 251.19,1.56 ; PBATT1.2 251.19,3.04 ; PBATT1.2 249.71,3.04 ; PBATT1.2 250.45,3.28 ; PBATT1.2 250.45,1.32 ; 234.46,97.25 H13.1 ; H13.1 235.8,96.77 ; H13.1 233.97,98.6 ; H13.1 235.8,100.43 ; H13.1 237.15,99.94 ; H13.1 234.46,99.94 ; H13.1 237.63,98.6 ; H13.1 237.15,97.25 ; 181.86,152.64 JDOCK1.158 ; JDOCK1.158 181.86,151.37 ; JDOCK1.158 183.33,152 ; JDOCK1.158 181.67,152 ; JDOCK1.158 183.13,151.37 ; JDOCK1.158 182.5,152.83 ; JDOCK1.158 182.5,151.17 ; JDOCK1.158 183.13,152.64 ; PBATT1.4 255.19,1.56 ; PBATT1.4 253.71,1.56 ; PBATT1.4 254.45,1.32 ; PBATT1.4 253.71,3.04 ; PBATT1.4 255.19,3.04 ; PBATT1.4 254.45,3.28 ; H12.1 148.08,148.75 ; H12.1 147.52,147.22 ; H12.1 145.99,146.67 ; H12.1 145.99,150.83 ; H12.1 143.91,148.75 ; H12.1 144.47,150.27 ; H12.1 144.47,147.22 ; H12.1 147.52,150.27 ; H30.1 347,63.93 ; H30.1 345.66,60.76 ; H30.1 348.34,63.44 ; H30.1 345.66,63.44 ; H30.1 348.34,60.76 ; H30.1 345.17,62.1 ; H30.1 347,60.27 ; H30.1 348.83,62.1 ; SW2.4 204.02,138.21 ; SW2.4 203.02,137.21 ; SW2.4 203.26,137.97 ; SW2.4 203.26,136.45 ; SW2.4 205.02,137.21 ; SW2.4 204.78,137.97 ; SW2.4 204.02,136.21 ; SW2.4 204.78,136.45 ; JDOCK1.155 152,156.64 ; JDOCK1.155 152,155.21 ; JDOCK1.155 150.17,155.93 ; JDOCK1.155 150.17,156.64 ; JDOCK1.155 150.17,155.21 ; JDOCK1.155 153.83,155.93 ; JDOCK1.155 153.83,156.64 ; 167.2,70.9 H4.1 ; H4.1 168.9,70.26 ; H4.1 170.6,70.9 ; H4.1 166.56,72.6 ; H4.1 168.9,74.94 ; H4.1 170.6,74.3 ; H4.1 171.24,72.6 ; H4.1 167.2,74.3
  BOTTOM w0.203: U631.41 146.97,99.5 v2(146.92,99.45) ; U630.33 145.21,137.44 v2(145.08,137.31) ; UV2.11 157.69,115.49 v2(157.89,115.69) ; v2(240.37,62.3) 240.45,62.23 PU1200.26 ; v2(161.01,116.86) 161.45,116.86 161.67,117.09 UV2.52 ; U636.57 164.79,95.24 v2(165.27,95.71) ; U631.8 151.31,100.3 v2(150.31,99.3) ; v2(127.73,116.64) 128.36,116 RH356.2 ; U629.18 175.19,132.86 v2(175.19,132.86) ; v2(240.42,52.01) 240.5,51.94 PU1201.26 ; 151.43,102.38 150.91,102.9 U631.57 ; v2(135.74,123.4) 135.74,122.83 135.3,122.39 RC328.1 ; v2(171.8,91.11) 171.38,91.53 U636.33 ; UV2.19 154.49,112.4 v2(154.41,112.33) ; v2(117.7,116.75) 118.22,117.27 RH323.1 ; RH83.1 130.17,117.78 v2(130.11,117.72) ; U630.8 149.21,134.32 149.9,135.01 v2(151.3,135.01) ; U631.18 v2(153.76,96.3) ; v2(146.61,96.05) 146.63,96.05 146.95,96.37 147.76,96.37 U631.33 ; v2(167.43,97.99) 167.38,97.93 U636.8 ; v2(178.19,136.31) 178.39,136.51 U629.41 ; v2(168.38,94.64) 168.18,94.44 U636.41 ; v2(117.7,114.29) 117.68,114.26 117.68,114.02 118.02,113.68 RH325.1 ; v2(183.61,135.71) U629.57 ; v2(148.21,136.18) 148.41,136.38 U630.41 ; v2(154.61,135.13) 154.17,135.58 U630.57 ; v2(189.95,23.31) 189.32,22.68 189.32,20.48 189.22,20.38 RC222.2 ; v2(174.86,140.33) 174.86,140.16 175.09,139.94 175.09,139.52 175.19,139.42 U629.33 ; PU1202.26 240.75,41.52 v2(240.47,41.8) ; PU200.3 v2(59.78,17.42) ; v2(234.09,71.84) 234.11,71.81 PU1700.26 ; v2(170.67,95.02) 170.73,95.08 170.73,95.63 171.38,96.27 U636.18 ; CH64.2 114.16,114.21 v2(114.18,114.22) ; v2(145.27,132.8) 145.21,132.85 U630.18 ; v2(60.29,16.91) 60.58,16.62 PU200.1 ; U629.8 v2(179.19,132.94)
  BOTTOM w0.254: v2(183.25,157.26) 183.25,157.26 JDOCK1.96 ; JDOCK1.47 169.25,149.27 v2(169.25,149.28) 169.58,149.28 169.75,149.1 JDOCK1.49 ; v2(180.25,149.27) 180.25,149.27 JDOCK1.87 ; JDOCK1.1 157.75,149.11 v2(157.95,149.31) ; v2(165.39,157.62) 165.39,157.36 165.25,157.23 JDOCK1.32 ; v2(126.23,106.04) 126.37,106.04 126.72,105.68 126.72,104.1 CH47.2 ; v2(166.75,157.26) 166.75,157.26 JDOCK1.38 ; v2(163.75,157.26) 163.75,157.26 JDOCK1.26 ; v2(39.55,19.89) JSATA2.10 ; JDOCK1.137 193.75,149.27 v2(193.75,149.28) ; v2(187.86,157.26) 187.75,157.15 JDOCK1.114 ; JDIMM4.213 109.39,70.17 v2(109.34,70.23) ; v2(123.23,29.88) 123.52,30.17 JDIMM2.61 ; JDIMM4.247 108.97,78.67 108.5,79.14 v2(108.5,79.27) ; v2(172.75,157.26) 172.75,157.26 JDOCK1.58 ; QE2.1 214.46,104.28 214.76,104.59 v2(214.76,105.07) 215.28,105.58 QE2.4 ; v2(184.63,157.28) 184.75,157.16 JDOCK1.102 ; JDIMM4.171 109.48,59.68 108.69,60.46 v2(108.69,60.68) ; v2(165.49,149.22) 165.25,148.98 JDOCK1.31 ; v2(134.85,79.24) 134.16,79.92 JDIMM2.252 ; JDOCK1.19 162.25,149.27 v2(162.25,149.28) ; JDOCK1.126 190.75,157.26 v2(190.75,157.26) ; JDOCK1.43 168.25,148.99 168.53,149.27 v2(168.57,149.27) ; JSATA2.13 38.05,19.8 v2(38.14,19.9) ; JDOCK1.94 181.75,157.26 v2(181.75,157.26) ; v2(184.75,149.28) 184.75,149.27 JDOCK1.101 ; JDOCK1.107 186.25,149.27 v2(186.25,149.28) ; C747.2 198.62,102.55 v2(198.62,102.04) ; v2(177.25,149.28) 177.25,149.27 JDOCK1.75 ; JDIMM4.231 109.42,74.67 v2(109.35,74.75) ; JDIMM4.10 119.84,17.42 120.36,16.9 121.35,16.9 121.5,17.04 v2(121.5,17.35) ; U637.9 189.96,127.05 190.37,127.46 v2(190.42,127.46) ; v2(108.74,63.88) 108.74,64.21 109.71,65.17 JDIMM4.193 ; v2(183.25,149.28) 183.25,148 JDOCK1.95 ; JDOCK1.76 177.25,157.26 v2(177.25,157.26) ; JDOCK1.57 172.75,148.01 172.75,149.1 172.57,149.28 v2(172.25,149.28) 172.25,149.27 JDOCK1.55 ; JDOCK1.91 181.25,149.27 v2(181.25,149.28) 181.52,149.28 181.75,149.04 JDOCK1.93 ; JDIMM2.35 124.59,23.69 v2(123.25,23.69) ; v2(39.79,21.8) 40.24,21.8 42.55,19.49 JSATA2.4 ; v2(192.25,149.28) 192.25,149.27 JDOCK1.131 ; v2(175.75,149.28) 175.75,149.27 JDOCK1.69 ; JDOCK1.82 178.75,157.26 v2(178.75,157.26) ; JDOCK1.123 190.25,149.27 v2(190.25,149.28) 190.49,149.28 190.75,149.02 190.75,149.02 JDOCK1.125 ; JDOCK1.37 166.75,149.07 v2(167.17,149.5) ; JDOCK1.113 187.75,149.27 v2(187.75,149.28) ; JDOCK1.64 174.25,157.26 v2(174.25,157.26) ; JDOCK1.70 175.75,157.26 v2(175.75,157.26) ; JDOCK1.44 168.25,157.26 v2(168.25,157.26) ; JDIMM4.185 109.62,63.17 108.72,62.28 v2(108.72,62.25) ; v2(195.06,127.29) 194.83,127.05 U637.32 ; JDIMM4.175 109.36,60.68 109.38,60.66 v2(109.37,60.66) ; JDOCK1.119 189.25,149.27 v2(189.25,149.28) ; v2(162.25,157.26) 162.25,157.26 JDOCK1.20 ; v2(47.22,19.71) 47.17,19.77 44.24,19.77 44.05,19.58 JSATA2.1 ; 108.75,75.65 108.78,75.67 JDIMM4.235 ; v2(171.03,157.72) 171.25,157.5 JDOCK1.52 ; RP4.8 169.55,114.88 v2(169.3,114.62) 169.54,114.38 RP4.7 ; v2(190.42,130.13) 190,130.55 U637.16 ; JDOCK1.50 169.75,156 v2(169.75,157.26) ; PC1546.2 178.76,35.28 v2(178.56,35.08) ; 169.25,113.76 v2(169.25,113.77) ; 169.25,113.76 169.36,113.88 RP4.6 ; 169.25,113.76 169.25,113.74 169.61,113.38 RP4.5 ; v2(109.36,62.22) 109.41,62.17 JDIMM4.181 ; JDIMM4.217 109.41,71.17 108.72,70.48 v2(108.72,70.23) ; JDIMM4.209 108.92,69.17 v2(108.01,68.26) ; JDIMM4.197 109.29,66.17 v2(109.07,66.39) ; JDOCK1.81 178.75,149.27 v2(178.75,149.28) ; JDOCK1.7 159.25,146.86 v2(159.37,146.74) ; v2(108.14,31.89) 108.85,31.17 JDIMM4.65 ; v2(34.01,19.9) 34.05,19.86 JSATA2.21 ; v2(193.75,157.26) 193.75,157.26 JDOCK1.138 ; JDOCK1.63 174.25,148 174.25,149.07 174.05,149.28 v2(173.75,149.28) 173.75,149.27 JDOCK1.61 ; v2(193.08,132.16) 193,132.08 U637.23 ; v2(192.25,157.26) 192.25,157.26 JDOCK1.132 ; v2(109.34,63.86) 109.65,64.17 JDIMM4.189 ; v2(159.25,157.26) 159.25,157.26 JDOCK1.8 ; JDOCK1.51 171.25,148.81 171.05,149.01 v2(170.78,149.01) ; JDIMM4.167 109.34,58.68 v2(108.85,59.17) ; JDOCK1.14 160.75,157.26 v2(160.75,157.26) ; JDOCK1.120 189.25,154.94 188.96,154.66 v2(188.56,154.66) ; JDIMM4.205 108.88,68.17 v2(108.87,68.19) ; v2(160.75,149.28) 160.75,149.27 JDOCK1.13 ; v2(163.75,149.28) 163.75,149.27 JDOCK1.25 ; JDOCK1.108 186.25,157.26 v2(186.25,157.26) ; v2(21.25,5.35) JNGFF3.67 ; JDOCK1.88 180.25,157.26 v2(180.25,157.26) ; JDIMM4.223 110.56,72.71 109.42,72.71 109.21,72.92 v2(109.21,72.97) ; JSATA2.7 41.05,19.6 v2(40.84,19.81)
  BOTTOM w0.305: JDIMM2.243 123.62,77.67 123.37,77.92 v2(123.37,78.59) 123.42,78.59 123.5,78.67 JDIMM2.247 ; JNGFF2.5 329.38,24.43 v2(329.65,24.15) 329.43,23.93 JNGFF2.3 ; v2(210.9,127.46) 211.17,127.2 JNGFF1.7 ; v2(120.82,32.14) 120.6,31.93 JDIMM4.68 ; JDIMM2.48 134.91,26.93 v2(134.97,26.99) ; JDIMM2.78 133.75,34.42 134.47,33.7 v2(134.47,33.67) ; JDIMM4.180 119.86,61.92 v2(120.27,62.33) 119.68,62.92 JDIMM4.184 ; v2(123.13,21.17) 123.49,20.68 JDIMM2.23 ; v2(109.22,40.66) 109.24,40.68 JDIMM4.103 ; JDIMM2.99 123.2,39.68 v2(123.07,39.54) ; JDIMM2.231 123.44,74.67 v2(123.1,75.02) 123.76,75.67 JDIMM2.235 ; v2(135.01,76.89) 134.55,76.43 JDIMM2.238 ; JNGFF1.37 212.74,117.69 213.47,117.69 213.75,117.96 213.75,118 213.97,118.23 ; v2(221.98,102.19) 221.92,102.14 221.92,97.61 221.98,97.55 JAPS1.10 ; JDIMM2.82 134.68,35.42 v2(135.01,35.75) ; JDIMM4.93 109.26,38.17 v2(109.26,38.17) ; JDIMM2.103 123.24,40.68 122.49,41.43 v2(122.49,41.62) ; JDIMM4.9 108.78,17.17 v2(108.75,17.21) ; v2(123.36,79.19) 123.35,79.2 123.35,79.49 123.53,79.67 JDIMM2.251 ; JDIMM4.222 121.09,72.43 v2(121.89,73.22) 121.68,73.43 JDIMM4.226 ; JDIMM2.51 123.25,27.68 v2(123.2,27.73) 123.2,26.89 123.42,26.68 JDIMM2.47 ; JDIMM2.44 134.63,25.93 v2(135.28,25.27) ; JNGFF3.51 v2(15.25,5.21) ; JDIMM4.36 120.7,23.93 v2(120.97,23.66) 120.97,23.65 119.74,22.42 JDIMM4.30 ; v2(122.98,71.47) 122.98,71.43 123.23,71.17 JDIMM2.217 ; JDIMM2.205 123.63,68.17 v2(123.19,67.73) 123.74,67.17 JDIMM2.201 ; JDIMM2.185 123.07,63.17 122.25,62.36 v2(122.25,62.33) ; JDIMM4.69 109.05,32.17 v2(108.85,31.97) 108.85,32.77 109.25,33.17 JDIMM4.73 ; JNGFF3.45 v2(13.75,5.21) ; JDIMM4.234 121.25,75.43 v2(121.43,75.24) 121.43,76.05 121.06,76.43 JDIMM4.238 ; v2(121.83,29.86) 121.83,29.84 120.92,28.93 JDIMM4.56 ; JNGFF2.65 327.63,41.43 v2(327.38,41.18) 327.64,40.93 JNGFF2.63 ; JDIMM2.193 123.22,65.17 122.42,65.98 v2(122.42,66.08) ; v2(203.62,131.91) 203.62,131.72 204.16,131.18 JLPDE1.9 ; v2(134.59,21.11) 134.27,21.42 JDIMM2.26 ; JDIMM2.9 122.83,17.17 v2(122.75,17.26) ; JDIMM4.106 120.38,41.42 v2(120.58,41.62) ; JDIMM4.188 119.98,63.92 v2(120.16,63.75) 120.28,63.86 120.28,64.66 120.02,64.92 JDIMM4.192 ; JDIMM2.184 134,62.92 v2(134.65,63.58) 134.3,63.92 JDIMM2.188 ; v2(123.08,41.64) 123.08,41.65 123.11,41.68 JDIMM2.107 ; U51.B66 203.5,115.11 v2(203.56,115.05) ; JDIMM2.40 134.18,24.93 v2(134.52,25.27) ; v2(220.55,97.56) 220.79,97.32 220.79,97.05 220.81,97.03 220.81,96.94 220.98,96.77 JAPS1.12 ; JDIMM2.192 134.86,64.92 v2(134.97,65.04) ; JDIMM2.85 123.33,36.17 122.25,35.09 122.25,34.96 v2(122.26,34.96) ; 134.23,67.43 134.23,67.99 133.8,68.43 JDIMM2.206 ; 134.23,67.43 134.89,66.76 v2(134.89,66.7) ; 134.23,67.43 JDIMM2.202 ; JDIMM4.39 109.09,24.68 108.08,25.68 v2(108.08,25.69) ; v2(109.33,36.22) 109.37,36.17 JDIMM4.85 ; JDIMM2.239 123.05,76.67 v2(122.98,76.6) ; JDIMM2.223 123.5,72.67 123.01,73.16 v2(123.01,73.26) 123.47,73.67 JDIMM2.227 ; JNGFF1.49 211.91,114.7 v2(211.46,115.15) 211.43,115.18 211.43,115.97 211.66,116.2 JNGFF1.43 ; JDIMM2.64 133.63,30.93 134.17,30.39 v2(134.17,30.34) 134.17,30.31 133.78,29.93 JDIMM2.60 ; JDIMM4.35 108.81,23.68 v2(108.8,23.69) ; JDIMM2.196 134.84,65.92 v2(135.73,65.04) ; JNGFF3.65 20.75,4.92 v2(20.52,5.16) 20.25,4.89 JNGFF3.63 ; JDIMM2.213 123.24,70.17 v2(122.52,69.45) 122.8,69.17 JDIMM2.209 ; JDIMM2.14 133.91,18.42 v2(134.96,19.47) 133.94,19.47 133.89,19.42 JDIMM2.18 ; JDIMM2.214 134.79,70.43 ; 134.79,70.43 134.82,70.45 134.82,71.08 134.47,71.43 JDIMM2.218 ; 134.79,70.43 v2(135.69,69.52) ; JDEG2.10 180.16,101 v2(179.94,100.77) ; JDIMM4.107 109.48,41.68 v2(109.2,41.4) ; JDIMM4.51 108.87,27.68 v2(108.82,27.73) ; JDIMM2.19 123,19.68 v2(122.8,19.47) ; v2(217.02,124.29) 217.18,124.45 JNGFF1.10 ; JDIMM4.6 120,16.42 120.41,16.01 v2(122.03,16.01) 121.45,15.42 JDIMM4.2 ; v2(108.82,25.69) 108.84,25.68 JDIMM4.43 ; v2(121.5,17.35) 121.5,17.75 120.82,18.42 JDIMM4.14 ; JDIMM2.197 123.24,66.17 v2(123.11,66.04) ; JDIMM2.167 123.4,58.68 v2(123.18,58.89) ; v2(327.19,37.61) 327.38,37.43 JNGFF2.49 ; JDIMM4.102 120.14,40.42 121.29,41.57 v2(121.29,41.62) ; JDIMM2.22 134.66,20.42 v2(135.35,21.11) ; JDIMM2.10 134.54,17.42 134.91,17.79 134.91,17.84 134.9,17.84 v2(134.9,17.86) ; JDIMM4.89 109.49,37.17 v2(108.54,38.12) ; JDIMM2.56 134.76,28.93 134.97,28.71 v2(134.97,28.69) ; JDIMM2.5 122.99,16.17 v2(122.81,15.99) 123.63,15.17 JDIMM2.1 ; U51.B18 204.5,106.31 204.76,106.05 v2(204.76,105.77) ; JDIMM2.90 132.82,37.45 135.22,37.45 135.25,37.48 v2(135.25,37.45) ; v2(121.03,66.05) 120.9,65.92 JDIMM4.196 ; v2(123.15,63.97) 123.35,64.17 JDIMM2.189 ; v2(120.8,36.68) 120.8,36.09 120.13,35.42 JDIMM4.82 ; JNGFF3.1 2.75,4.89 v2(3.01,5.14) 3.26,4.9 JNGFF3.3 ; v2(134.97,62.16) 134.05,62.16 133.81,61.92 JDIMM2.180 ; JNGFF3.27 v2(9.25,5.21) ; JDIMM4.210 121.83,69.43 v2(121.83,69.43) 120.84,70.43 JDIMM4.214 ; JDIMM4.78 119.8,34.42 v2(120.74,33.49) 120.18,32.93 JDIMM4.72 ; JDIMM4.5 109.03,16.17 107.96,17.24 v2(107.96,17.26) ; v2(211.59,110.35) 211.74,110.2 JNGFF1.67 ; v2(107.98,21.5) 109.16,22.68 JDIMM4.31 ; v2(109.34,77.78) 109.45,77.67 JDIMM4.243 ; JDIMM4.239 109.32,76.67 108.75,76.11 108.75,75.65 ; JDIMM2.6 134.79,16.42 v2(134.97,16.25) ; JDIMM2.248 134.04,78.92 v2(134.96,78) 134.92,77.96 132.84,77.96 JDIMM2.244 ; v2(122.31,37.43) 122.31,37.48 123.01,38.17 JDIMM2.93 ; v2(121.02,25.93) JDIMM4.44 ; JDIMM4.52 118.84,27.89 120.96,27.89 v2(121.08,27.76) 120.25,26.93 JDIMM4.48 ; v2(108.61,73.01) 108.61,73.2 109.09,73.67 JDIMM4.227 ; JNGFF3.15 v2(6.26,5.21) ; JDIMM4.176 120.2,60.92 v2(120.76,60.37) ; v2(211.57,112.03) 211.91,111.7 JNGFF1.61 213.46,111.7 213.78,112.02 213.78,112.88 213.46,113.2 JNGFF1.55 ; v2(122.19,31.99) 122.19,31.88 122.89,31.17 JDIMM2.65 ; JNGFF2.25 v2(329.73,31.43) ; v2(120.02,38.04) 119.63,38.42 JDIMM4.94 ; 123.47,60.68 JDIMM2.175 ; U51.B60 200.57,115.64 200.57,115.03 v2(200.59,115.01) ; JDIMM4.27 109,21.68 v2(108.8,21.47) 109.6,20.68 JDIMM4.23 ; v2(121.98,19.49) 122.8,18.68 JDIMM2.15 ; JNGFF3.39 v2(12.25,5.21) ; JDIMM2.77 123.02,34.17 122.32,33.48 v2(122.32,33.47) 122.79,33.01 123.29,33.01 123.46,33.17 JDIMM2.73 ; JDIMM2.222 133.88,72.43 134.27,72.82 v2(134.27,73.14) 133.98,73.43 JDIMM2.226 ; v2(108.62,29.92) 109.36,29.17 JDIMM4.57 ; JDIMM2.168 134.75,58.92 v2(134.97,59.14) 134.18,59.92 JDIMM2.172 ; JDIMM2.30 134.19,22.42 v2(134.97,23.15) 134.24,23.93 JDIMM2.36 ; v2(108.82,15.23) 108.88,15.17 JDIMM4.1 ; JDIMM4.18 121.07,19.42 v2(121.14,19.49) 120.21,20.42 JDIMM4.22 ; v2(218.88,97.62) 218.88,97.63 219.13,97.63 219.98,96.78 JAPS1.14 ; JDIMM2.106 134.78,41.42 v2(134.97,41.62) 134.99,41.6 134.99,40.75 134.66,40.42 JDIMM2.102 ; 213.97,118.23 213.97,118.82 213.59,119.2 JNGFF1.31 ; 213.97,118.23 v2(213.95,118.23) ; v2(221.7,123.01) 221.67,122.95 JNGFF1.16 ; v2(221.51,119.54) 221.42,119.54 221.01,119.95 JNGFF1.28 ; JDIMM4.99 109.25,39.68 v2(109.21,39.63) ; v2(123.09,62.35) 123.29,62.35 123.47,62.17 JDIMM2.181 ; v2(213.89,120.76) 213.78,120.76 213.78,120.74 213.74,120.7 JNGFF1.25 ; JDIMM4.77 109.32,34.17 v2(109.29,34.2) ; JDIMM4.218 121.12,71.43 121.57,70.98 121.94,70.98 122.33,71.37 v2(122.33,71.48) ; JDIMM2.230 133.68,74.43 v2(134.4,74.89) 133.86,75.43 JDIMM2.234 ; JDIMM4.206 121.13,68.43 v2(121.83,67.73) 121.53,67.43 JDIMM4.202 ; v2(109.33,29.95) 109.55,30.17 JDIMM4.61 ; JDIMM4.248 119.78,78.92 120.03,78.67 v2(121.4,78.67) ; JNGFF3.21 v2(7.75,5.21) ; v2(123.2,25.92) 123.45,25.68 JDIMM2.43 ; v2(330.03,35.77) 329.88,35.93 JNGFF2.43 ; v2(121.58,21.17) 123.11,22.68 JDIMM2.31 ; JNGFF2.19 v2(330.03,29.93) ; JDIMM4.172 120.13,59.92 120.35,59.7 v2(120.35,58.92) JDIMM4.168 ; JDIMM4.251 111.43,79.67 111.76,80 111.76,80.01 111.95,80.21 111.95,80.81 v2(112.3,81.16) ; JDIMM4.244 121.41,77.92 122.05,78.56 v2(122.05,78.67) ; v2(135.73,35.75) 135.06,36.42 JDIMM2.86 ; v2(116.2,82.46) 116.2,82.89 116.33,83.01 117.1,83.01 117.37,82.75 117.37,80.39 117.83,79.92 JDIMM4.252 ; v2(122.49,25.92) 122.49,25.84 123.66,24.68 JDIMM2.39 ; JDIMM2.89 123.32,37.17 v2(123.05,37.43) ; JNGFF1.15 211.7,123.2 v2(211.54,123.03) 211.56,123.01 211.56,121.94 211.8,121.7 JNGFF1.21 ; v2(135.86,37.45) 135.86,37.66 135.09,38.42 JDIMM2.94 ; JNGFF2.31 v2(329.94,32.93) ; JDIMM4.81 109.43,35.17 108.69,35.92 v2(108.69,36.2) ; v2(122.34,21.17) 122.96,21.71 123.48,21.71 123.52,21.68 JDIMM2.27 ; JDIMM2.69 123.05,32.17 v2(122.85,31.97) ; v2(134.43,32) 134.43,32.02 134.33,31.93 JDIMM2.68 ; JDIMM2.210 134.87,69.43 v2(134.97,69.52) ; JNGFF1.1 v2(211.59,128.7) ; JDIMM4.19 109,19.68 v2(108.8,19.47) ; v2(108.14,27.67) 108.14,27.66 109.12,26.68 JDIMM4.47 ; v2(134.97,14.65) 134.19,15.42 JDIMM2.2 ; JDIMM4.15 108.8,18.68 v2(107.98,19.49) ; JDIMM4.201 109.66,67.17 108.87,67.96 v2(108.87,68.19) ; v2(327.05,26.69) 327.05,26.29 327.42,25.93 JNGFF2.11 ; JAPS1.8 222.98,96.77 222.81,96.94 222.81,98.77 223.02,98.99 223.02,100.52 222.81,100.73 222.81,102.05 222.93,102.17 v2(222.93,102.43) ; v2(135.73,26.99) 135.17,27.54 134.23,27.54 133.85,27.93 JDIMM2.52 ; v2(135.06,31.97) 135.06,32.71 134.85,32.93 JDIMM2.72 ; JNGFF1.22 221.56,121.45 v2(221.7,121.31) ; JDIMM4.64 120.54,30.93 121.07,30.39 v2(121.07,29.83) 120.13,29.83 120.04,29.93 JDIMM4.60 ; v2(121.75,25.92) 121.75,25.91 120.77,24.93 JDIMM4.40 ; v2(122.49,29.86) 123.17,29.17 JDIMM2.57 ; JDIMM2.81 123.21,35.17 v2(123,34.97) ; JNGFF3.57 16.75,5.21 17.22,5.68 v2(17.22,6.52) ; v2(134.97,39.53) 134.9,39.46 132.84,39.46 JDIMM2.98 ; v2(204.28,110.69) 204.28,110.65 204.83,110.11 U51.B11 ; v2(121.21,38.04) 121.21,38.51 120.29,39.42 JDIMM4.98 ; U46.B27 183.29,110.26 v2(183.23,110.2) ; v2(134.97,61.13) 134.7,60.92 JDIMM2.176 ; v2(120.94,21.17) 120.69,21.42 JDIMM4.26 ; v2(197.76,115.09) 197.75,115.09 197.75,115.06 197.78,115.06 197.78,115.17 197.5,115.45 U51.B54 ; JNGFF3.33 v2(10.75,5.21) ; JNGFF3.9 v2(4.75,5.21) ; v2(108.17,91.35) 108.17,91.29 108.22,91.25 108.22,91.25 108.4,91.07 108.4,91.07 CD65.2 ; JDIMM4.230 121.43,74.43 v2(122.15,75.14) ; JNGFF2.37 v2(330.02,34.43)
  BOTTOM w0.356: v2(182.73,41.99) 182.81,41.91 PC1518.2 182.81,41.26 PC1524.2 ; v2(184.52,41.99) 184.6,41.91 PC1493.2 ; PC1483.2 183.4,41.91 v2(183.33,41.99) ; v2(183.92,41.99) 184,41.91 PC1492.2
  BOTTOM w0.381: 342.25,15.43 349.1,15.43 JSIM1.13 349.1,15.43 351.31,15.43 352.05,16.17 v2(353.78,16.17) ; 342.25,15.43 JSIM1.12 ; 342.25,15.43 341.55,15.43 339.79,17.19 JSIM1.11 ; PC1274.2 183.54,49.43 v2(183.84,49.13) 184.14,49.42 PC1308.2 ; v2(216.38,46.53) PC1293.2 ; v2(217.59,45.83) PC1296.2 ; v2(216.32,47.8) PC1294.2 ; v2(178.56,40.56) 179.16,41.16 PC1475.2 ; PC1638.2 185.74,46.07 v2(185.75,46.08) PC1635.2 ; Q347.1 171,133.22 v2(171.15,133.37) ; C744.2 210.96,110.98 v2(211.59,110.35) 211.4,110.35 211.04,109.99 210.85,109.99 210.65,109.8 210.04,109.8 209.87,109.97 209.45,109.97 209.03,109.55 C1355.2 ; v2(217.59,47.17) PC1330.2 ; PC1501.2 182.84,35.6 PC1496.2 182.72,35.47 v2(182.72,35.01) ; v2(179.82,39.65) 179.29,39.12 PC1474.2 ; v2(108.88,91.33) 109.62,91.33 CD74.2 ; v2(218.79,46.53) PC1322.2 ; Q353.1 152.05,123.99 151.62,124.42 v2(151.62,124.92) ; v2(341.38,29.76) 342.86,29.76 JSIM1.17 ; PC1631.2 v2(184.48,45.44) PC1633.2 ; v2(188.35,44.94) PC1628.2 ; PC1276.2 183.52,51.14 v2(183.8,50.86) 184.12,51.19 PC1310.2 ; v2(183.31,35.01) 183.31,35.47 PC1491.2 ; PC1277.2 184.03,47.73 v2(183.72,47.41) 183.43,47.7 PC1278.2 ; v2(218.67,49.13) PC1288.2 ; v2(185.1,35.01) 185.1,35.47 PC1488.2 ; v2(216.19,50.6) PC1272.2 ; PC1281.2 184.76,53.16 v2(185.05,52.87) 185.36,53.18 PC1315.2 ; PC1305.2 185.33,49.48 v2(184.99,49.13) 184.74,49.38 PC1292.2 ; PC1637.2 v2(187.02,45.51) PC1636.2 ; v2(184.52,41.99) PC1533.2 ; v2(184.51,35.01) 184.51,35.47 PC1489.2 ; PC1639.2 v2(188.35,46.08) PC1629.2 ; v2(183.33,41.99) PC1535.2 ; v2(217.52,48.44) PC1332.2 ; PC1309.2 185.22,47.73 v2(184.91,47.41) 184.63,47.7 PC1275.2 ; v2(218.79,47.8) PC1290.2 ; PC1502.2 185.19,41.91 v2(185.12,41.99) PC1484.2 ; v2(185.75,44.94) PC1634.2 ; JSIM1.16 348.54,29.76 348.32,29.55 v2(348.32,29.17) ; PC1536.2 v2(182.73,41.99) ; v2(217.46,49.9) PC1300.2 ; v2(169.64,135.35) 169.7,135.29 Q347.4 ; PC1306.2 184.17,53.2 v2(183.84,52.87) 183.57,53.15 PC1327.2 ; v2(216.32,49.13) PC1295.2 ; PC1279.2 185.31,51.19 v2(184.99,50.86) 184.71,51.14 PC1280.2 ; v2(218.92,45.13) PC1307.2 ; PC1632.2 v2(183.27,46.08) PC1630.2 ; v2(218.67,50.6) PC1328.2 ; v2(183.92,41.99) PC1534.2 ; PC1490.2 183.91,35.47 v2(183.91,35.01)
  BOTTOM w0.406: v2(110.34,156.23) 110.34,155.79 109.71,155.15 U3.3 ; Q353.4 151.19,122.69 v2(151.62,122.26)
  BOTTOM w0.457: CH34.2 125.08,108.22 v2(125.19,108.33) ; CC166.2 164.82,34.14 v2(165.7,33.27) ; v2(137.83,127.69) 138.17,127.69 CH35.2 138.03,126.72 CH38.2 ; C327.2 199.75,96.09 v2(199.75,96.86) ; v2(130.73,91.4) 131.07,91.05 131.07,89.71 RD36.2 ; RC173.2 186.3,34.49 v2(186.3,34.51)
  BOTTOM w0.508: v2(167.84,28.78) 166.77,27.71 CC165.2 CC164.2 ; JAPS1.20 215.62,93.57 v2(215.62,95.21) ; JLPDE1.11 199.15,125.08 198.8,125.43 v2(198.8,126) ; v2(212.23,42.44) PC1424.2 PC1425.2 ; v2(112.82,157.19) 112.79,157.19 R336.1 ; v2(186.3,42.84) PC1463.2 ; v2(112.06,91.63) CD71.2 112.36,89.82 112.92,89.27 RD56.2 ; v2(136,74.87) 136.85,74.87 140.7,78.72 JDIMM2.262 ; PR802.1 102.98,129.15 v2(102.85,129.28) ; v2(180.46,46.97) 180.3,46.81 PC1245.2 ; CH68.2 122.74,122.92 v2(122.8,122.98) ; C734.2 209.76,122.16 C733.2 210.22,122.17 v2(210.43,122.38) ; v2(219.09,77.99) 219.09,78.41 218.87,78.63 PC1706.2 ; C719.2 191.05,116.48 v2(191.11,116.42) ; v2(188.08,36.67) PC1469.2 ; v2(232.93,48.22) PC1211.2 ; PC1453.2 191.7,40.95 v2(191.79,40.85) 191.7,40.75 PC1454.2 ; v2(209.86,116.2) 209.77,116.29 C1354.2 C1352.2 ; JTAG1.2 192.75,122.82 192.89,122.96 192.89,123.21 v2(192.9,123.21) ; v2(353.78,16.17) 354.16,15.8 354.92,15.8 ; R879.1 202.49,123.63 v2(202.48,123.63) 202.47,123.63 R876.2 ; v2(335.88,25.86) CZ65.2 ; C737.2 204.91,102.59 204.58,102.25 203.99,102.25 v2(203.94,102.2) ; 354.92,29.4 354.03,29.4 v2(353.9,29.52) ; v2(182.22,53.92) PC1263.2 ; v2(155.74,126.13) 155.74,126.95 JSPI1.22 ; v2(232.88,58.38) PC1209.2 ; v2(109.96,141.75) 109.45,141.24 107.99,141.24 107.47,140.72 C296.2 104.73,140.08 103.55,138.89 D21.1 v2(102.49,138.09) ; v2(121.77,147.34) 121.77,146.96 121.47,146.65 R222.1 ; C1356.2 337.06,17.19 v3(337.41,17.19) 339.7,17.19 JSIM1.11 ; PD8.2 v2(49.69,45.51) ; JUART1.5 108.38,121.05 v2(108.67,120.77) 108.93,120.5 JUART1.4 ; JNGFF1.69 213.91,109.51 213.91,109.75 214.48,110.32 v2(214.61,110.32) ; CH66.2 133.51,118.2 133.86,118.54 v2(133.86,118.79) ; PC1702.2 226.01,68.13 v2(226.58,68.13) ; CH62.2 112.98,118.02 v2(112.6,117.64) ; JRTC1.3 53.8,25.59 v2(53.95,25.74) ; CH44.2 135.33,115.37 v2(135.3,115.41) ; v2(237.96,37.74) 238.4,37.29 PC1249.2 ; v2(132.82,129.5) 132.82,128.75 133.16,128.42 ; v2(148.91,107.27) v3(148.15,107.27) ; RZ20.2 194.47,131.8 v2(194.1,132.16) ; C1469.2 206.66,133.52 v2(206.05,134.13) ; PC1251.2 191.91,48.24 v2(191.97,48.3) ; CH37.2 CH67.2 126.92,128.52 v2(126.92,129.39) ; CH63.2 111.49,124.43 v2(111.87,124.81) ; C1467.2 C1468.2 112.5,139.42 112.58,139.34 v2(112.58,138.88) ; v2(186.3,38.76) PC1459.2 ; JSATA2.31 27.05,16.74 v2(25.8,15.49) ; PC1467.2 v2(181.51,38.27) ; CC182.2 183.19,15.9 CC181.2 CC180.2 ; CC182.2 183.02,16.74 CC177.2 ; CC182.2 183.02,14.72 v2(182.44,14.14) ; CH45.2 137.13,120.23 v2(136.4,120.23) ; CC183.2 CC184.2 178.51,13.13 v2(178.22,12.85) ; C293.2 111.47,136.72 v2(111.74,136.99) ; v2(191.52,113.44) 192.19,113.44 R892.1 ; v2(335.88,40.67) 335.41,40.2 R416.2 ; v2(99.29,134.08) 99.67,134.46 C299.2 99.67,135.66 C300.2 ; RD55.2 116.12,88.47 v2(116.12,88.22) ; CZ9.2 190.07,135.81 190.71,136.44 v2(190.71,136.88) ; v2(143.43,123.09) 143.06,123.46 CH268.1 ; v2(126.26,144.51) 126.17,144.6 R3727.2 ; PC1420.2 PC1421.2 v2(212.29,39.45) ; CH269.2 137.09,128.52 137.16,128.59 137.16,129.41 v2(137.14,129.43) ; v2(48.73,25.8) 49.53,26.6 JRTC1.2 ; C1345.2 200.04,119.56 C757.2 ; PC1618.2 191.7,45.39 v2(191.88,45.57) 191.7,45.75 PC1615.2 ; v2(190.17,48.91) PC1262.2 ; v2(200.36,121.28) 200.06,120.97 C757.2 ; v2(177.31,126.39) 177,126.69 U52.4 ; C782.2 194.84,103.16 C780.2 195.37,103.11 195.37,102.51 195.24,102.38 v2(195.24,102.32) ; v2(181.23,54.15) PC1264.2 ; JDEG2.12 178.06,100.25 178.6,100.79 179.91,100.79 v2(179.94,100.77) ; v2(166.06,44.09) 165.74,44.41 CC84.2 CC168.2 ; v2(188.08,40.9) PC1444.2 ; v2(56.99,14.21) 56.99,13.75 57.32,13.42 PC214.2 PC209.2 ; v2(229.1,94.88) 228.58,94.36 JAPS1.19 ; PU900.1 236.5,84.27 v2(236.96,84.73) ; JSATA2.32 30.59,14.24 v2(30.59,12.21) ; v2(122.66,91.18) 122.45,90.98 CD38.2 ; v2(186.3,37.34) PC1449.2 ; v2(188.08,38.07) PC1464.2 ; v2(186.3,35.96) PC1448.2 ; v2(137.71,14.61) 137.85,14.75 JDIMM2.261 ; v2(188.08,35.22) PC1468.2 ; R1069.2 C747.2 198.94,102.84 C777.2 ; PC1617.2 190.85,45.27 v2(190.78,45.34) PC1616.2 ; CV30.2 165.45,115.08 v2(165.87,114.66) 165.87,114.15 165.32,113.61 RV40.2 ; v2(191.88,43.69) 191.7,43.51 PC1452.2 ; v2(133.18,115.33) 133.47,115.03 CH36.2 ; C509.2 175.63,94.83 176.25,94.83 v2(176.51,94.57) ; 133.16,128.42 RH308.2 CH266.2 ; 133.16,128.42 CMOS1.1 134.12,128.82 134.61,129.32 CH40.1 ; C248.2 107.73,157.19 v2(108.06,156.87) ; v2(151.17,109.68) 151.22,109.64 RV41.2 ; JNGFF2.69 327.08,43.03 326.56,42.5 v2(326.56,41.61) ; PC1445.2 191.7,35.1 v2(191.82,35.22) 191.7,35.35 PC1455.2 ; PQ1005.1 268.92,39.69 v2(268.9,39.71) 268.9,39.06 PR1035.2 ; v2(122.28,144.19) 122.19,144.1 U33.2 ; PC1266.2 191.93,49.78 v2(191.95,49.81) PC1255.2 ; v2(96.5,128.42) 96.5,129.56 97.01,130.07 C301.2 ; C1344.2 150.72,122.64 Q353.4 ; CC212.2 v2(217.66,70.27) ; R3730.1 210.34,113.2 v2(209.53,113.2) 209.52,113.19 R432.1 ; CE6.2 v2(206.35,143.78) ; JNGFF1.68 v2(213.5,131.11) ; v2(148.28,124.71) 147.31,124.71 v3(146.93,124.33) ; v2(237.34,83.85) 237.34,82.44 236.94,82.04 PR903.2 ; C1352.2 C1353.2 ; C1352.2 208.9,116.8 C1348.2 ; CC192.1 197.4,74.7 196.9,74.2 v2(196.61,74.2) ; JDEG2.11 186.76,97.27 187.3,96.73 v2(187.3,94.69) ; QV1.3 159.55,137.44 159.25,137.14 v2(159.02,137.14) ; C508.2 176.14,97.56 v2(176.33,97.37) ; PC1428.2 PC1422.2 v2(212.29,33.55) ; CC179.2 CC178.2 180.7,16.58 v2(180.7,15.58) ; v2(205.14,118.55) 205.1,118.59 C741.2 ; C249.1 111.26,140.1 111.28,140.08 v2(111.28,139.21) ; C328.2 214.13,88.82 v2(214.41,89.11) ; v2(181.12,120.29) 180.87,120.03 C1216.2 ; C757.2 C736.2 ; C743.2 201.82,118.43 201.72,118.32 201.69,118.32 v2(201.66,118.3) ; PC1700.2 238.23,72.19 v2(238.84,71.58) ; v2(189.86,35.98) PC1479.2 ; v2(188.39,48.09) PC1261.2 ; v2(191.47,110.61) 191.8,110.61 192.03,110.37 C781.2 192.18,110.32 R843.1 ; v2(208.28,153.09) PWRSW1.2 209.24,152.94 C759.2 ; v2(191.88,52.66) 191.95,52.59 PC1259.2 ; v2(186.73,19.9) 186.73,17.43 186.17,16.87 CC175.2 CC176.2 ; C320.2 R425.2 208.27,98.24 v2(208.55,98.52) ; v2(188.13,68.28) 188.38,68.28 188.76,68.66 188.76,69.74 189.02,70 RC178.2 RC179.2 191.08,70.69 CC193.1 CC194.1 191.85,69.08 191.05,68.28 CC191.1 ; PC1258.2 v2(233.75,39.26) ; v2(188.08,42.26) PC1480.2 ; v2(189.92,42.79) PC1462.2 ; 151.43,102.38 v2(151.43,102.26) ; v2(166.91,25.1) 166.29,25.72 CC209.1 CC210.1 ; v2(227.56,69.5) 227.61,69.45 PC1704.2 ; C292.2 195.35,119.61 v2(195.35,120.3) ; v2(22.35,6.83) JNGFF3.69 v2(23.5,4.85) ; v2(335.09,22.16) CZ66.2 ; JSIM1.8 339.77,21.24 337.43,21.24 336.44,20.25 CZ67.2 335.04,20.25 v2(335.04,20.25) ; v2(190.17,54.93) PC1246.2 ; JSPI1.21 168.27,128.31 166.03,130.55 v2(163.05,130.55) ; v2(201.53,136.8) 201.59,136.74 JLPDE1.12 ; v2(189.86,34.52) PC1451.2 ; v2(182.28,50.49) PC1242.2 ; v2(186.3,34.51) PC1447.2 ; JSATA2.33 42.5,12.29 v2(42.87,11.92) ; v2(58.48,20.25) 57.82,20.91 PC213.2 57.3,20.91 PC210.2 ; PC1247.2 180.68,50.72 v2(181.18,50.72) ; C298.2 v2(119.93,136.74) ; v2(186.57,53.5) PC1268.2 ; RD31.2 138.92,90.38 139.64,89.66 v2(140.64,89.66) ; CD74.2 109.75,91.2 CD73.2 ; v2(49.99,30.51) 49.78,30.31 PC2.2 ; v2(181.45,39.65) PC1466.2 ; v2(132.86,133.63) 132.86,133.39 133.39,132.86 CH41.1 ; v2(181.45,41.06) PC1465.2 ; v2(248.95,42.95) 249.64,43.64 PR1168.2 ; v2(188.08,39.45) PC1443.2 ; v2(188.08,33.93) PC1470.2 ; v2(188.41,51.03) PC1240.2 ; v2(109.69,88.03) 109.68,88.04 CD69.2 109.68,88.92 CD62.2 ; PC1212.2 v2(233.77,59.61) ; v2(232.39,91.21) 233.82,91.21 PC900.2 PR901.2 PC902.2 ; v2(115.55,136.99) 116.16,136.38 D20.1 ; v2(182.28,52.18) PC1254.2 ; CH50.2 CH51.2 130.23,134.84 130.53,135.14 v2(130.53,135.51) ; v2(126.71,112.71) 126.8,112.62 CH31.2 ; v2(186.58,47.55) PC1267.2 ; PC1446.2 191.7,37.9 v2(191.85,38.04) 191.7,38.19 PC1450.2 ; v2(143.68,107.24) 143.86,107.24 v3(144.65,106.45) ; v2(124.31,87.09) 126.93,87.09 127.52,87.68 RD35.2 ; v2(186.62,48.98) PC1256.2 ; v2(188.37,52.56) PC1252.2 ; v2(169.65,110.48) 170.57,110.48 R803.2 ; R135.2 C1470.2 164.25,63.01 164.82,62.44 168.58,62.44 169.59,61.42 v2(169.59,60.48) ; CE1.2 172.88,119.26 v2(172.41,119.73) 172.04,120.1 C746.2 ; v2(189.86,38.78) PC1473.2 ; v2(324.76,24.18) 326.61,22.33 JNGFF2.68 ; v2(189.86,41.53) PC1471.2 ; CH49.2 CH42.2 131.3,135.44 v2(131.25,135.48) ; v2(30.15,44.52) PR18.2 ; D33.1 211.33,143.77 211.56,143.54 v2(211.56,143.09) ; PC11.2 v2(49.25,50.44) ; v2(189.86,40.19) PC1472.2 ; U53.4 185.7,126.87 185.5,126.66 v2(185.39,126.66) ; v2(182.28,48.75) PC1260.2 ; PC207.2 59.96,12.38 v2(59.54,11.96) ; v2(270.15,36.34) 270.06,36.25 269.31,36.25 268.95,36.61 PR1037.2 ; PC1423.2 PC1429.2 v2(212.29,36.4) ; v2(165.7,31.15) 165.7,31.34 165.27,31.77 CC83.2 CC171.2 ; CC172.2 CC166.2 ; v2(116.55,91.33) RD54.2 ; v2(166.68,57.7) 165.33,56.34 CC82.2 CC161.2 ; v2(182.07,43.03) 181.82,43.03 PC1461.2 ; v2(181.58,33.78) PC1476.2 ; R1138.2 111.72,152.45 R1137.2 110.82,152.45 v2(110.28,152.99) ; CD37.2 123.72,90.93 123.44,91.21 v2(123.42,91.21) ; v2(166.34,38.98) 166.3,38.95 CC170.2 CC163.2 ; v2(201.27,102) 201.27,102.66 C739.2 C1349.2 ; CC189.2 194.23,69.55 v2(193.91,69.24) ; v2(186.3,40.17) PC1456.2 ; v2(190.19,53.31) PC1248.2 ; C1466.2 187.42,123.15 186.8,123.76 v2(186.8,125.32) ; v2(47.92,17.93) 47.92,17.36 47.37,16.8 JSATA2.34 ; PH1103.2 240.93,66.76 240.37,66.76 ; Q22.3 112.49,133.61 v2(112.06,133.18) 112.82,132.42 112.82,131.47 113.28,131.01 QH3.3 ; v2(190.18,50.38) PC1265.2 ; JUART1.6 109.18,116.8 109.78,117.41 v2(109.78,117.39) ; v2(104.78,122.07) 104.78,122.6 105.24,123.06 RH196.2 ; v2(195.05,12.15) 194.53,12.67 PC1620.2 PC1621.2 PC1622.2 193.53,17.04 PC1623.2 ; PC1213.2 233.84,49.45 v2(233.82,49.42) ; v2(188.4,54.04) PC1253.2 ; PR1125.1 v2(217.86,44.04) ; v2(166.17,50.87) 165.52,51.52 CC81.2 CC167.2 ; v2(188.39,49.53) PC1239.2 ; JSIM1.18 339.7,27.3 339.7,28.79 340.68,29.76 v2(341.38,29.76) ; v2(186.24,41.51) PC1460.2 ; PC1238.2 191.95,54.45 v2(191.88,54.52) ; v2(197.63,120.3) 197.59,120.26 197.59,120.14 197.39,119.94 C740.2 ; v2(186.55,52.01) PC1243.2 ; v2(186.62,50.51) PC1257.2 ; v2(181.24,49) PC1241.2 ; PC1417.2 PC1416.2 v2(212.29,30.59) ; v2(190.17,51.82) PC1244.2 ; v2(189.86,37.39) PC1478.2 ; v2(1.65,6.71) JNGFF3.68
  vias: v2(0.51,64.47) v2(0.51,56.85) v2(0.51,49.23) v2(0.51,41.61) v2(0.51,33.99) v2(0.51,26.37) v2(0.51,18.75) v2(0.51,11.13) v2(3.39,7.17) v2(4.62,70.89) v2(4.67,9.48) v2(6.27,6.18) v2(6.43,8.33) v2(6.76,9.67) v2(8.12,8.76) v2(8.63,2.61) v2(9.28,9.62) v2(9.38,5.86) v2(10.65,5.86) v2(12.24,70.89) v2(12.36,7.26) v2(12.62,9.61) v2(13.12,15.01) v2(14.39,15.96) v2(15.28,7.25) v2(16.25,2.61) v2(17.68,37.59) v2(17.85,6.52) v2(18,41.74) v2(18.49,6.52) v2(18.82,41.74) v2(18.9,34.84) v2(19.12,6.52) v2(19.83,70.89) v2(23.87,2.61) v2(24.97,22.96) v2(25.57,49.55) v2(25.71,30.12) v2(25.68,28.11) v2(26.33,47.52) v2(26.6,23.24) v2(26.71,51.58) v2(26.71,29.13) v2(26.86,67.89) v2(27.06,34.54) v2(27.77,30.17) v2(27.77,28.09) v2(29.25,51.58) v2(29.25,47.33) v2(30.52,49.49) v2(31.49,2.87) v2(33.18,35.81) v2(33.44,44.03) v2(33.44,43.39) v2(34.01,61.15) v2(34.01,60.51) v2(34.01,59.88) v2(34.48,67.89) v2(34.65,61.15) v2(34.65,60.51) v2(34.65,59.88) v2(35.28,61.15) v2(35.28,60.51) v2(35.28,59.88) v2(36.99,29.9) v2(36.99,28.51) v2(37.19,61.12) v2(37.19,60.49) v2(37.19,59.85) v2(37.69,29.2) v2(37.82,61.12) v2(37.82,60.49) v2(37.82,59.85) v2(38.13,23.36) v2(38.39,29.9) v2(38.39,28.51) v2(38.46,61.12) v2(38.46,60.49) v2(38.46,59.85) v2(39.1,2.76) v2(41.83,23.64) v2(42.1,67.89) v2(43.22,25.86) v2(43.22,21.29) v2(43.29,5.16) v2(43.92,3.7) v2(44.24,6.94) v2(45.83,25.86) v2(45.76,21.29) v2(46.13,60.68) v2(46.13,59.84) v2(46.71,6.94) v2(47.16,23.39) v2(47.16,3.7) v2(47.58,41.7) v2(47.67,5.04) v2(48.21,41.7) v2(49,41.93) v2(49.11,70.89) v2(50,29.83) v2(50.4,7.88) v2(50.7,29.85) v2(51.14,61.85) v2(51.54,7.01) v2(51.54,6.37) v2(52.11,20.4) v2(52.18,7.64) v2(52.18,7.01) v2(52.18,6.37) v2(52.81,7.64) v2(52.81,7.01) v2(52.81,6.37) v2(53.89,2.61) v2(54.53,58.38) v2(54.57,25.75) v2(55.22,8.52) v2(55.92,8.52) v2(56.73,70.9) v2(58.89,30.44) v2(58.86,28.6) v2(59.07,57.32) v2(59.21,17.93) v2(59.29,58.88) v2(59.27,16.91) v2(60.29,17.93) v2(60.88,20.28) v2(61.07,11.55) v2(61.26,20.72) v2(61.51,2.61) v2(61.7,11.55) v2(62.34,11.55) v2(62.86,66.43) v2(62.97,11.55) v2(63.61,11.55) v2(64.22,25.61) v2(64.22,24.98) v2(64.22,24.34) v2(64.22,23.71) v2(64.24,11.55) v2(65.67,73.51) v2(66.13,15.89) v2(69.13,2.61) v2(70.19,7.26) v2(70.19,6.62) v2(70.83,7.26) v2(70.83,6.62) v2(71.46,7.26) v2(71.46,6.62) v2(72.1,7.26) v2(72.1,6.62) v2(72.41,77.06) v2(72.5,8.67) v2(73.13,8.67) v2(75.78,27.9) v2(75.78,27.26) v2(75.78,26.63) v2(75.78,25.99) v2(75.78,25.36) v2(75.78,21.55) v2(75.78,20.09) v2(75.78,19.45) v2(75.78,18.24) v2(75.78,17.61) v2(76.42,27.9) v2(76.42,27.26) v2(76.42,26.63) v2(76.42,25.99) v2(76.42,25.36) v2(76.75,2.61) v2(77.05,27.9) v2(77.05,27.26) v2(77.05,26.63) v2(77.05,25.99) v2(77.05,25.36) v2(77.69,27.9) v2(77.69,27.26) v2(77.69,26.63) v2(77.69,25.99) v2(77.69,25.36) v2(81.64,15.32) v2(82.27,15.32) v2(82.69,87.48) v2(82.91,15.32) v2(83.54,15.32) v2(84.18,15.32) v2(84.37,2.61) v2(84.81,15.32) v2(85.12,9.42) v2(86.16,94.26) v2(88.15,101.62) v2(88.61,118.02) v2(88.59,109.23) v2(89.51,7.21) v2(89.69,125.27) v2(89.83,6.64) v2(90.14,7.21) v2(90.46,6.64) v2(90.78,111.72) v2(91.74,113.94) v2(91.74,109.24) v2(91.99,2.61) v2(93.96,109.18) v2(94.4,113.94) v2(94.51,93.9) v2(95.38,117.88) v2(95.67,111.59) v2(95.79,117.44) v2(96.3,131.9) v2(96.27,116.86) v2(96.4,117.47) v2(96.6,139.49) v2(96.85,116.83) v2(96.93,116.23) v2(96.98,117.44) v2(97.67,115.51) v2(97.85,127.2) v2(97.82,126.56) v2(98.09,115.08) v2(98.15,90.95) v2(98.21,104.35) v2(98.48,127.22) v2(98.51,126.56) v2(98.71,143.46) v2(99.29,92.03) v2(99.61,2.61) v2(100.37,93.17) v2(100.94,84.48) v2(101.43,141.04) v2(101.39,84.92) v2(101.45,94.25) v2(102.15,144.8) v2(102.24,16.91) v2(102.94,16.91) v2(103.09,45.61) v2(103.1,43.07) v2(103.29,142.77) v2(103.95,144.36) v2(104.53,130.14) v2(104.61,145.38) v2(104.86,134.26) v2(105.01,156) v2(105.01,149.31) v2(105.97,138.42) v2(106.09,146.96) v2(106.15,153.06) v2(106.53,154.66) v2(106.64,7.01) v2(106.64,6.37) v2(107.17,144.8) v2(107.18,74.75) v2(107.23,2.61) v2(107.28,7.01) v2(107.28,6.37) v2(107.87,77.81) v2(108.31,150.9) v2(108.31,149.05) v2(109.58,151.28) v2(109.83,132.61) v2(110.09,95.81) v2(111.83,159.39) v2(112.31,146.9) v2(112.53,124.87) v2(112.46,39.97) v2(112.54,37.75) v2(112.67,102.63) v2(112.73,73.19) v2(112.73,49.63) v2(112.7,33.6) v2(112.66,16.31) v2(112.79,66.49) v2(112.83,50.96) v2(112.79,30.3) v2(112.77,17.93) v2(112.96,102.08) v2(113.12,56.91) v2(113.17,63.58) v2(113.22,48.13) v2(113.16,35.77) v2(113.32,71.49) v2(113.32,45.6) v2(113.32,41.59) v2(113.34,19.7) v2(113.39,79.28) v2(113.41,21.4) v2(113.47,81.12) v2(113.53,76.61) v2(113.5,28.64) v2(113.58,53.01) v2(113.6,23.07) v2(113.85,43.68) v2(113.89,37.77) v2(113.99,77.78) v2(113.96,74.89) v2(113.98,65.04) v2(113.97,33.63) v2(113.99,32.15) v2(113.96,26.94) v2(114.06,66.46) v2(114.1,30.3) v2(114.08,17.89) v2(114.05,16.47) v2(114.25,69.88) v2(114.26,59.05) v2(114.41,62.16) v2(114.41,39.96) v2(114.36,25.21) v2(114.49,48.1) v2(114.52,42.44) v2(114.51,35.76) v2(114.59,71.52) v2(114.61,49.72) v2(114.69,81.12) v2(114.68,54.71) v2(114.67,50.93) v2(114.83,76.6) v2(114.8,45.6) v2(114.85,28.66) v2(114.94,23.1) v2(114.85,2.61) v2(115.05,43.57) v2(115.12,52.98) v2(115.25,77.79) v2(115.2,74.86) v2(115.22,65.04) v2(115.17,63.61) v2(115.28,68.25) v2(115.32,49.83) v2(115.25,19.7) v2(115.44,73.08) v2(115.4,66.51) v2(115.35,33.67) v2(115.38,30.3) v2(115.43,17.88) v2(115.52,146.63) v2(115.45,69.88) v2(115.6,79.24) v2(115.59,59.05) v2(115.55,21.43) v2(115.68,25.21) v2(115.82,42.46) v2(115.82,37.77) v2(115.78,35.8) v2(115.93,62.33) v2(115.87,56.32) v2(116.08,54.71) v2(116.11,32.16) v2(116.12,26.93) v2(116.16,47.94) v2(116.25,40.79) v2(116.15,28.67) v2(116.29,15.7) v2(116.44,154.07) v2(116.56,145.18) v2(116.67,50.94) v2(116.83,14.44) v2(117.16,145.18) v2(117.58,159.33) v2(117.96,156.67) v2(118.09,151.4) v2(120.95,156.67) v2(120.88,151.4) v2(121.81,76.64) v2(122.33,78.06) v2(122.47,154.07) v2(122.54,23.66) v2(122.47,2.61) v2(122.78,79.09) v2(122.76,78.51) v2(124.99,154.15) v2(125.78,95.77) v2(126.37,73.11) v2(126.61,39.49) v2(126.73,49.63) v2(126.73,37.75) v2(126.79,66.49) v2(126.83,33.54) v2(126.79,30.3) v2(126.77,17.93) v2(126.93,50.8) v2(127.04,56.92) v2(127.05,146.83) v2(127.14,63.57) v2(127.11,54.88) v2(127.14,26.94) v2(127.2,41.52) v2(127.16,35.77) v2(127.34,19.7) v2(127.32,16.53) v2(127.37,47.86) v2(127.41,45.63) v2(127.41,21.4) v2(127.53,76.6) v2(127.5,28.66) v2(127.58,53.35) v2(127.55,43.57) v2(127.6,23.07) v2(127.71,81.15) v2(127.7,71.48) v2(127.76,79.28) v2(127.8,59.15) v2(127.95,132.39) v2(127.93,31.96) v2(127.99,77.78) v2(127.96,74.89) v2(128.01,68.22) v2(127.98,65.04) v2(127.98,37.78) v2(128.06,66.46) v2(128.11,60.67) v2(128.05,33.56) v2(128.1,30.3) v2(128.08,17.94) v2(128.2,73.1) v2(128.21,69.85) v2(128.41,62.16) v2(128.36,25.21) v2(128.48,54.88) v2(128.46,41.54) v2(128.54,39.48) v2(128.51,35.76) v2(128.64,47.86) v2(128.61,16.5) v2(128.75,49.66) v2(128.83,76.6) v2(128.8,45.6) v2(128.85,43.57) v2(128.85,28.66) v2(128.92,81.15) v2(128.92,50.8) v2(128.94,23.1) v2(128.96,71.48) v2(129.05,53.35) v2(129.25,77.79) v2(129.2,74.86) v2(129.22,65.04) v2(129.21,63.58) v2(129.15,26.95) v2(129.28,68.25) v2(129.31,60.67) v2(129.25,19.7) v2(129.44,73.11) v2(129.4,66.51) v2(129.42,49.64) v2(129.35,33.67) v2(129.38,30.3) v2(129.43,17.92) v2(129.45,69.85) v2(129.53,21.42) v2(129.56,79.27) v2(129.58,59.17) v2(129.68,62.16) v2(129.72,41.51) v2(129.68,25.21) v2(129.78,35.8) v2(129.88,54.88) v2(130.02,56.52) v2(130.01,37.77) v2(130.06,32.04) v2(130.09,2.61) v2(130.2,82.46) v2(130.22,43.57) v2(130.17,28.69) v2(130.39,47.8) v2(130.52,15.24) v2(130.85,50.8) v2(133.76,103.32) v2(133.89,101.76) v2(134.38,144.73) v2(134.59,101.76) v2(135.89,123.95) v2(136,138.83) v2(136.3,41.61) v2(136.76,140.74) v2(137.27,136.8) v2(137.71,2.61) v2(139.55,136.8) v2(139.68,140.86) v2(139.77,150.12) v2(140.25,26.6) v2(140.69,138.83) v2(141.58,109.43) v2(142.98,148.74) v2(143.62,156.69) v2(143.87,133.5) v2(144.5,151.34) v2(144.63,146.07) v2(145.01,135.08) v2(145.33,2.61) v2(147.43,146.07) v2(147.49,151.34) v2(147.93,112.42) v2(149.01,148.74) v2(150.75,159.39) v2(152.79,125.99) v2(152.95,2.61) v2(153.12,54.52) v2(153.53,54.09) v2(153.98,53.69) v2(154.39,53.28) v2(157.06,12.98) v2(158.35,153.44) v2(158.37,159.39) v2(158.74,49.25) v2(158.87,77.9) v2(158.97,104.98) v2(159.24,108.99) v2(160.14,49.25) v2(160.57,143.47) v2(160.57,2.61) v2(161.21,78.13) v2(162.25,75.79) v2(162.28,143.21) v2(163.06,49.25) v2(163.52,41.53) v2(163.69,37.75) v2(164,152.55) v2(163.98,145.1) v2(164.89,103.97) v2(165.27,102.64) v2(165.42,41.53) v2(165.59,37.75) v2(165.99,159.39) v2(166.06,46.55) v2(166.51,34.04) v2(167.23,151.86) v2(167.23,32.71) v2(167.33,41.53) v2(167.38,105.17) v2(167.69,52.94) v2(167.7,49.97) v2(167.74,30.37) v2(168.02,56.33) v2(167.96,46.55) v2(167.96,44.03) v2(167.96,23.02) v2(168.21,59.31) v2(168.19,2.61) v2(168.32,39.02) v2(168.26,26.45) v2(168.46,125.6) v2(168.47,125.01) v2(168.5,124.29) v2(168.82,33.5) v2(168.9,150.95) v2(169.12,51.74) v2(169.23,49.07) v2(169.23,41.53) v2(169.19,30.13) v2(169.31,24.36) v2(169.48,54.9) v2(169.56,57.96) v2(169.61,27.8) v2(169.9,150.01) v2(169.87,44.04) v2(170.09,20.78) v2(170.36,127.54) v2(170.65,25.71) v2(171.11,103.78) v2(171.17,151.21) v2(171.43,22.5) v2(171.55,102.73) v2(171.94,129.31) v2(172.04,86.23) v2(172.28,20.57) v2(173.61,159.39) v2(173.63,21.94) v2(174.73,145.75) v2(175.23,11.56) v2(175.37,151.02) v2(175.6,69.86) v2(175.75,152.48) v2(175.66,71.92) v2(175.81,11.56) v2(175.81,2.61) v2(175.91,146.21) v2(176.3,22.14) v2(177.27,112.8) v2(177.27,110.76) v2(177.27,108.73) v2(177.46,151.17) v2(177.68,22.15) v2(177.69,20.3) v2(178.01,69.96) v2(178.16,71.97) v2(178.2,68.18) v2(178.29,66.23) v2(178.78,74.31) v2(179.09,108.74) v2(179.3,112.8) v2(179.3,110.76) v2(179.43,129.11) v2(179.82,49.71) v2(180.47,31.42) v2(180.69,74.25) v2(180.73,71.13) v2(180.73,69.2) v2(180.73,67.23) v2(180.75,48.15) v2(180.67,38.27) v2(180.67,35.35) v2(181.23,159.39) v2(181.18,52.37) v2(181.33,112.8) v2(181.33,110.76) v2(181.33,108.73) v2(181.38,47.45) v2(181.51,35.35) v2(182.67,38.49) v2(182.7,32.87) v2(183.02,43.6) v2(183.12,67.29) v2(183.14,50.78) v2(183.08,49.06) v2(183.18,69.18) v2(183.21,52.56) v2(183.27,38.49) v2(183.34,32.87) v2(183.43,2.61) v2(183.65,21.38) v2(183.59,19.47) v2(183.7,74.22) v2(183.87,100.08) v2(183.91,54.65) v2(183.86,38.49) v2(183.91,32.87) v2(184.46,38.49) v2(184.54,32.87) v2(184.8,43.6) v2(185.06,38.49) v2(185.44,20.43) v2(185.58,69.25) v2(185.58,67.33) v2(186.03,74.32) v2(186.01,21.41) v2(186.3,33.06) v2(186.3,31.54) v2(186.79,72.16) v2(187.62,13.74) v2(188.12,66.35) v2(188.7,15.7) v2(188.7,11.7) v2(188.85,159.39) v2(188.99,43.48) v2(189.11,93.37) v2(189.23,152.19) v2(189.42,151.09) v2(189.49,74.29) v2(189.95,21.41) v2(190.42,128.8) v2(190.52,123.83) v2(190.69,151.04) v2(190.8,152.24) v2(191.12,123.86) v2(191.05,2.61) v2(191.24,73.6) v2(191.3,11.77) v2(191.43,15.58) v2(191.75,130.13) v2(191.75,128.8) v2(191.75,127.46) v2(191.9,150.91) v2(192.11,93.3) v2(192.18,74.3) v2(192.32,13.61) v2(193.04,68.29) v2(193.08,130.13) v2(193.08,128.8) v2(193.08,127.46) v2(193.29,105.54) v2(193.39,119.56) v2(193.39,118.92) v2(194.35,66.28) v2(194.82,73.88) v2(195.55,92.76) v2(195.95,67.78) v2(196.47,159.39) v2(197.23,67.33) v2(198.04,70.63) v2(198.52,72.5) v2(198.74,112.36) v2(198.67,2.61) v2(198.85,110.8) v2(198.85,109.09) v2(199.29,74.67) v2(199.88,68.03) v2(200.55,112.38) v2(200.55,110.8) v2(200.55,109.09) v2(200.83,65.68) v2(201.73,46.33) v2(201.67,41.57) v2(202.28,109.09) v2(202.53,110.85) v2(204.09,159.39) v2(204.12,8.45) v2(204.34,41.57) v2(204.4,46.33) v2(204.95,97.9) v2(205.53,98.04) v2(205.96,8.03) v2(206.29,2.61) v2(206.59,8.03) v2(207.23,8.03) v2(207.51,43.25) v2(207.86,8.03) v2(208.46,8.05) v2(209.53,8.05) v2(210.16,8.05) v2(210.8,8.05) v2(210.86,137.31) v2(210.86,136.67) v2(211.21,156.69) v2(211.42,52.53) v2(211.43,8.05) v2(211.5,137.31) v2(211.5,136.67) v2(211.89,86.71) v2(212.07,8.05) v2(212.43,49.93) v2(212.43,47.33) v2(212.7,8.05) v2(213.45,149.41) v2(213.91,2.61) v2(214.34,52.53) v2(214.55,80.86) v2(215.16,56.41) v2(215.43,96.41) v2(215.35,49.93) v2(215.35,47.33) v2(215.35,44.72) v2(215.56,86.76) v2(215.67,62.95) v2(215.82,81.55) v2(215.8,56.41) v2(215.92,86.27) v2(216.26,86.76) v2(216.31,62.95) v2(216.45,81.55) v2(216.5,56.41) v2(216.77,81.05) v2(216.81,28.53) v2(216.94,62.95) v2(217.08,89.06) v2(217.09,81.55) v2(217.13,56.41) v2(217.38,86.74) v2(217.4,81.05) v2(217.45,28.53) v2(217.7,64.35) v2(217.77,56.41) v2(218.15,64.79) v2(218.4,56.41) v2(218.59,65.23) v2(218.91,28.53) v2(219.04,65.68) v2(219.35,144.58) v2(219.48,66.12) v2(219.54,28.53) v2(219.93,66.57) v2(220.37,67.01) v2(220.81,67.46) v2(220.9,75.46) v2(221.26,67.9) v2(221.54,75.51) v2(221.53,2.61) v2(221.7,68.35) v2(222.34,103.4) v2(223.49,6.31) v2(224.11,121.62) v2(224.11,120.99) v2(224.12,6.31) v2(224.76,6.31) v2(225.39,6.31) v2(226.44,147.4) v2(226.67,86.76) v2(227.3,87.4) v2(227.29,86.77) v2(227.91,87.37) v2(227.91,86.78) v2(228.01,154.85) v2(229.15,2.61) v2(230.29,141.69) v2(230.42,118.38) v2(230.65,119.62) v2(230.71,93.69) v2(230.8,96.34) v2(231.25,95.89) v2(231.29,93.62) v2(231.3,9.56) v2(231.56,143.91) v2(231.63,139.21) v2(231.79,8.97) v2(231.88,93.62) v2(231.88,9.56) v2(232.18,74.38) v2(232.18,73.74) v2(232.18,73.11) v2(232.2,72.52) v2(232.19,20.09) v2(232.39,71.97) v2(232.41,30.27) v2(232.38,29.67) v2(232.39,29.08) v2(232.43,8.97) v2(232.5,36.16) v2(232.5,33.65) v2(232.5,33.01) v2(232.5,32.38) v2(232.5,31.74) v2(232.5,25.98) v2(232.5,23.46) v2(232.5,22.83) v2(232.5,22.19) v2(232.5,21.56) v2(232.5,13.1) v2(232.5,12.47) v2(232.5,11.83) v2(232.5,11.2) v2(232.49,9.57) v2(232.82,74.38) v2(232.82,73.74) v2(232.82,73.11) v2(232.82,72.47) v2(232.77,70.38) v2(232.9,71.65) v2(232.96,71.01) v2(233.13,36.16) v2(233.13,34.28) v2(233.13,33.65) v2(233.13,33.01) v2(233.13,32.38) v2(233.13,31.74) v2(233.13,25.98) v2(233.13,24.1) v2(233.13,23.46) v2(233.13,22.83) v2(233.13,22.19) v2(233.13,21.56) v2(233.13,13.74) v2(233.13,13.1) v2(233.13,12.47) v2(233.13,11.83) v2(233.13,11.2) v2(233.09,9.57) v2(233.15,98.95) v2(233.43,70.57) v2(233.45,73.74) v2(233.45,73.11) v2(233.45,72.47) v2(233.5,71.85) v2(233.5,71.27) v2(233.83,119.04) v2(233.77,36.16) v2(233.77,35.55) v2(233.77,34.92) v2(233.77,34.28) v2(233.77,33.65) v2(233.77,33.01) v2(233.77,32.38) v2(233.77,31.74) v2(233.77,25.98) v2(233.77,25.37) v2(233.77,24.73) v2(233.77,24.1) v2(233.77,23.46) v2(233.77,22.83) v2(233.77,22.19) v2(233.77,21.56) v2(233.77,15.01) v2(233.77,14.37) v2(233.77,13.74) v2(233.77,13.1) v2(233.77,12.47) v2(233.77,11.83) v2(233.77,11.2) v2(234.04,70.57) v2(234.09,73.11) v2(234.09,72.47) v2(234.09,71.2) v2(234.29,139.28) v2(234.4,36.16) v2(234.4,35.55) v2(234.4,34.92) v2(234.4,33.65) v2(234.4,33.01) v2(234.4,32.38) v2(234.4,31.74) v2(234.4,25.98) v2(234.4,25.37) v2(234.4,24.73) v2(234.4,23.46) v2(234.4,22.83) v2(234.4,22.19) v2(234.4,15.01) v2(234.4,14.37) v2(234.4,13.1) v2(234.4,12.47) v2(234.4,11.83) v2(234.4,11.2) v2(234.48,143.85) v2(234.8,100.79) v2(235.18,96.03) v2(235.69,141.43) v2(236.77,100.79) v2(236.77,2.61) v2(237.2,119.68) v2(237.2,118.4) v2(237.53,96.29) v2(237.74,67.5) v2(237.74,66.91) v2(237.74,66.33) v2(237.77,46.26) v2(237.77,45.65) v2(238.09,56.68) v2(238.09,56.09) v2(238.38,67.5) v2(238.38,66.91) v2(238.38,66.33) v2(238.4,46.26) v2(238.4,45.65) v2(238.47,64.84) v2(238.47,64.21) v2(238.47,63.57) v2(238.47,62.94) v2(238.47,60.42) v2(238.52,54.55) v2(238.52,53.92) v2(238.52,53.28) v2(238.52,52.65) v2(238.52,50.13) v2(238.57,44.34) v2(238.57,43.71) v2(238.57,43.07) v2(238.57,42.44) v2(238.57,39.92) v2(238.74,98.57) v2(238.72,56.68) v2(238.72,56.09) v2(239.1,64.84) v2(239.1,64.21) v2(239.1,63.57) v2(239.1,62.94) v2(239.1,62.3) v2(239.1,60.42) v2(239.15,54.55) v2(239.15,53.92) v2(239.15,53.28) v2(239.15,52.65) v2(239.15,52.01) v2(239.15,50.13) v2(239.2,44.34) v2(239.2,43.71) v2(239.2,43.07) v2(239.2,42.44) v2(239.2,41.8) v2(239.2,39.92) v2(239.74,64.84) v2(239.74,64.21) v2(239.74,63.57) v2(239.74,62.94) v2(239.74,62.3) v2(239.74,61.67) v2(239.74,61.03) v2(239.74,60.42) v2(239.79,54.55) v2(239.79,53.92) v2(239.79,53.28) v2(239.79,52.65) v2(239.79,52.01) v2(239.79,51.38) v2(239.79,50.74) v2(239.79,50.13) v2(239.84,44.34) v2(239.84,43.71) v2(239.84,43.07) v2(239.84,42.44) v2(239.84,41.8) v2(239.84,41.17) v2(239.84,40.53) v2(239.84,39.92) v2(240.37,64.84) v2(240.37,64.21) v2(240.37,63.57) v2(240.37,62.94) v2(240.37,61.67) v2(240.37,61.03) v2(240.37,60.42) v2(240.42,54.55) v2(240.42,53.92) v2(240.42,53.28) v2(240.42,52.65) v2(240.42,51.38) v2(240.42,50.74) v2(240.42,50.13) v2(240.47,44.34) v2(240.47,43.71) v2(240.47,43.07) v2(240.47,42.44) v2(240.47,41.17) v2(240.47,40.53) v2(240.47,39.92) v2(241.33,80.16) v2(241.33,79.27) v2(243.67,15.26) v2(243.67,14.63) v2(243.67,13.55) v2(243.67,12.91) v2(243.67,11.77) v2(243.67,11.13) v2(244.25,32.98) v2(244.25,32.34) v2(244.25,25.42) v2(244.25,24.79) v2(244.25,18.24) v2(244.25,17.61) v2(244.88,32.98) v2(244.88,32.34) v2(244.88,25.42) v2(244.88,24.79) v2(244.88,18.24) v2(244.88,17.61) v2(245.56,124.22) v2(246.61,2.81) v2(246.61,2.18) v2(246.61,1.54) v2(246.85,48.47) v2(246.85,47.84) v2(246.85,46.76) v2(246.85,46.12) v2(246.85,44.98) v2(246.85,44.34) v2(247.25,2.81) v2(247.25,2.18) v2(247.25,1.54) v2(247.99,55.96) v2(247.99,55.33) v2(247.99,53.86) v2(248.14,124.61) v2(248.49,157.9) v2(248.49,154.63) v2(249.28,115.34) v2(249.6,55.65) v2(249.91,110) v2(249.98,111.08) v2(249.98,108.8) v2(250.17,151.18) v2(250.53,27.9) v2(250.66,31.96) v2(251.04,124.14) v2(251.13,109.94) v2(251.18,111.15) v2(251.25,63.33) v2(251.17,27.9) v2(251.31,108.73) v2(251.29,31.96) v2(251.69,26.31) v2(251.72,0.51) v2(251.8,27.9) v2(252.07,25.86) v2(252.07,25.23) v2(252.2,65.49) v2(252.26,111.08) v2(252.33,110) v2(252.26,108.8) v2(252.37,31.96) v2(252.44,27.9) v2(252.65,61.42) v2(252.56,26.18) v2(252.56,25.55) v2(252.56,24.91) v2(253.01,31.96) v2(253.07,27.9) v2(253.2,26.18) v2(253.2,25.55) v2(253.2,24.91) v2(253.3,144.84) v2(253.36,124.49) v2(254.31,142.8) v2(254.38,146.61) v2(254.8,65.55) v2(254.87,61.68) v2(255.82,63.71) v2(256.02,27.96) v2(256.62,142.84) v2(256.66,146.61) v2(257.11,28.2) v2(257.15,151.05) v2(257.24,33.69) v2(257.22,29.42) v2(257.28,141.29) v2(257.31,136.62) v2(257.84,29) v2(257.87,27.41) v2(258.43,33.66) v2(258.49,29.36) v2(258.55,28.21) v2(258.55,26.63) v2(259.12,21.36) v2(259.29,128.82) v2(259.29,121.2) v2(259.29,113.58) v2(259.29,105.96) v2(259.29,98.34) v2(259.29,90.72) v2(259.34,0.51) v2(259.5,83.1) v2(260.34,34.26) v2(260.53,48.34) v2(260.93,47.9) v2(261,34.26) v2(261.1,75.65) v2(261.45,21.93) v2(264.21,68.69) v2(264.5,17.8) v2(265.66,2.81) v2(265.66,2.18) v2(265.66,1.54) v2(265.96,25.93) v2(265.96,24.66) v2(266.28,25.29) v2(266.3,2.81) v2(266.3,2.18) v2(266.3,1.54) v2(268.7,62.53) v2(268.76,21.04) v2(269.39,21.04) v2(270.25,7.68) v2(270.44,43.94) v2(270.54,21.04) v2(270.6,35.83) v2(271.14,9.52) v2(271.08,5.59) v2(271.17,21.04) v2(274.25,5.33) v2(274.37,57.44) v2(274.44,9.59) v2(275.06,2.62) v2(275.59,7.49) v2(280.97,53.64) v2(281.9,2.61) v2(287.43,21.55) v2(287.43,20.91) v2(287.36,20.28) v2(287.36,19.64) v2(288,20.28) v2(288,19.64) v2(288.06,22.18) v2(288.06,21.55) v2(288.06,20.91) v2(288.22,51.28) v2(288.63,20.28) v2(288.63,19.64) v2(288.7,22.18) v2(288.7,21.55) v2(288.7,20.91) v2(289.52,2.61) v2(295.8,50.49) v2(297.14,2.61) v2(302.37,20.15) v2(302.68,37.61) v2(302.87,36.28) v2(303.13,48.85) v2(303.38,51.28) v2(304.08,17.42) v2(304.27,22.51) v2(304.44,30.94) v2(304.44,29.45) v2(304.65,43.52) v2(304.76,2.61) v2(305.92,46.63) v2(306.81,17.36) v2(306.87,22.5) v2(308.46,19.83) v2(310.63,53.64) v2(312.38,2.61) v2(313.35,52.22) v2(313.67,44.03) v2(313.86,47.9) v2(316.13,13.1) v2(316.46,47.39) v2(316.76,13.1) v2(317.54,38.44) v2(317.84,13.1) v2(317.95,54.75) v2(318.37,38.18) v2(318.48,13.1) v2(319.6,45.36) v2(319.62,13.1) v2(320,2.61) v2(320.26,13.1) v2(321.4,13.1) v2(322.03,13.1) v2(323.45,33.34) v2(324.13,33.34) v2(324.55,58.53) v2(324.55,50.91) v2(326.06,47.31) v2(326.95,30.55) v2(327.62,2.61) v2(328.08,6.81) v2(328.17,46.73) v2(328.45,15.9) v2(328.63,44.34) v2(328.83,15.26) v2(328.83,14.63) v2(329.08,15.9) v2(329.15,14.05) v2(329.39,64.41) v2(329.46,15.26) v2(329.46,14.63) v2(329.48,9.48) v2(329.62,40.56) v2(329.78,14.05) v2(329.86,3.7) v2(329.95,46.35) v2(330.1,15.26) v2(330.1,14.63) v2(330.45,40.55) v2(331.22,40.53) v2(332.19,52.09) v2(332.26,55.07) v2(332.27,35.58) v2(332.35,38.12) v2(332.8,30.55) v2(332.87,31.67) v2(333.13,31.11) v2(333.23,9.61) v2(333.16,3.77) v2(333.63,31.69) v2(333.56,30.58) v2(333.89,31.14) v2(333.86,26.33) v2(334.29,30.58) v2(334.37,31.69) v2(334.62,31.14) v2(334.81,6.75) v2(335.18,55.07) v2(335.18,52.09) v2(335.23,33.8) v2(335.23,32.81) v2(335.24,2.61) v2(335.26,31.85) v2(335.26,30.78) v2(335.26,29.89) v2(335.28,29.05) v2(337.01,64.49) v2(341.16,28.85) v2(341.46,27.64) v2(341.59,28.28) v2(341.8,28.85) v2(341.77,27.11) v2(342.1,27.64) v2(342.23,28.28) v2(342.43,28.85) v2(342.48,27.13) v2(342.86,28.28) v2(342.86,27.64) v2(342.86,2.61) v2(343.07,28.85) v2(343.12,26.5) v2(343.17,27.13) v2(343.39,33.19) v2(343.47,28.3) v2(343.5,27.64) v2(344.05,33.19) v2(344.29,62.19) v2(345.56,64.41) v2(345.63,59.71) v2(346.93,10.62) v2(346.93,9.86) v2(346.93,9.1) v2(348.29,59.78) v2(348.48,64.35) v2(348.7,37.55) v2(348.7,36.91) v2(349.08,36.28) v2(349.34,37.55) v2(349.34,36.91) v2(349.34,11.26) v2(349.48,61.87) v2(349.49,58.62) v2(349.54,51) v2(349.72,36.28) v2(349.97,37.55) v2(349.97,36.91) v2(350.24,30.7) v2(350.27,31.57) v2(350.35,36.28) v2(350.43,3.52) v2(350.61,37.55) v2(350.61,36.91) v2(350.99,36.28) v2(351.01,10.73) v2(351.08,31.57) v2(351.11,30.7) v2(351.24,37.55) v2(351.24,36.91) v2(352.5,43.4) v2(352.5,42.76) v2(353.14,43.4) v2(353.14,42.76) v2(353.81,35.05) v2(353.81,34.44) v2(355.49,46.23) v2(355.49,38.61) v2(355.49,30.99) v2(355.49,17.27) v3(24.81,30.19) v3(26.75,27.73) v3(26.98,5.28) v3(30.31,43.12) v3(77.29,23.31) v3(77.32,20.79) v3(77.32,19.01) v3(77.32,17.24) v3(77.41,28.43) v3(84.72,14.51) v3(139.68,144.29) v3(146.34,135.16) v3(147.45,137.14) v3(167.66,123.36) v3(197.19,85.6) v3(201.22,85.6) v3(207.94,140.6) v3(215.72,82.44) v3(221.86,74.73) v3(231.02,74.23) v3(231.06,70.87) v3(231.15,92.51) v3(233.75,92.49) v3(237.25,44.79) v3(237.34,52.65) v3(237.36,61.8) v3(239.94,66.44) v3(261.65,47.24) v3(308.4,37.25) v3(317.9,47.79) v4(14.84,55.07) v4(15.03,54.44) v4(15.85,57.87) v4(16.55,57.87) v4(16.55,57.23) v4(16.71,55.98) v4(16.68,54.76) v4(18.58,62.76) v4(19.28,62.76) v4(20.04,62.76) v4(20.74,62.76)
