# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UG_+1VSP: length 6
  IN4 w1.016: 101.86,123.74 101.86,119.35 101.2,118.69
  BOTTOM w0.102: v2(100.21,118.26) 100.21,118.23 v1(100.69,117.75)
  vias: v2(99.62,118.26) v2(101.5,124.58) v2(102.09,124.43)
UGATE_CHG: length 9.1
  IN1 w1.016: 276.78,32.02 276.78,31.57 277.31,31.04 277.31,30.54 282.46,25.39 282.58,25.39
  vias: v1(281.54,24.1) v2(276.02,33.04) v2(276.59,32.87) v2(282.45,24.1) v2(283.01,24.33)
UIM_CLK: length 24.8
  IN4 w0.109: v2(334.35,26.79) 334.35,27.37 333.81,27.91 330.55,27.91 328.44,30.02 328.44,30.84 328.06,31.22 326.94,31.22 v2(326.85,31.13)
  BOTTOM w0.102: v2(326.85,31.13) 321.84,31.13 321.8,31.18 JNGFF2.24 ; v2(334.35,26.79) 334.46,26.69 334.46,24.09 335.17,23.38 335.57,23.38 CZ66.1 336.21,23.4 338.95,23.4 339.01,23.34 339.41,23.34 339.41,23.35 JSIM1.5
UIM_DATA: length 25
  IN4 w0.109: v2(326.85,31.72) 326.94,31.63 328.28,31.63 328.85,31.06 328.85,30.19 330.72,28.32 333.98,28.32 334.77,27.54 334.77,26.96 v2(334.94,26.79)
  BOTTOM w0.102: v2(326.85,31.72) 326.68,31.54 322.04,31.54 321.91,31.68 JNGFF2.26 ; JSIM1.4 339.01,24.05 338.77,23.81 v1(337.67,23.81) 336.16,23.81 CZ65.1 335.57,23.78 335.4,23.78 334.87,24.31 334.87,26.72 v2(334.94,26.79)
UIM_RESET: length 25.2
  IN1 w0.109: v2(322.68,30.56) 322.68,28.42 323.42,27.68 323.42,26.4 324.21,25.61 326.43,25.61 329.54,22.5 332.21,22.5 v2(332.68,22.03)
  BOTTOM w0.102: v2(332.68,22.03) 333.38,22.03 v1(333.62,21.79) 334.31,21.1 335.81,21.1 CZ67.1 336.65,21.94 339.77,21.94 JSIM1.7 ; v2(322.68,30.56) 322.57,30.68 JNGFF2.22
UPD_EN1_4#: length 175.9
  TOP w0.102: v2(164.06,105.3) 164.06,106.3 165.28,107.52 165.28,108.45 165.65,108.81 165.65,109.73 167.89,111.97 168.34,111.97 170.07,113.7 170.07,114.98 169.65,115.4 169.65,116.73 169.97,117.05 170.94,117.05 v2(171.23,116.76) ; v2(58.22,37.99) 56.81,37.99 56.68,37.85 JIO2.63
  IN2 w0.127: v2(107.23,89.68) 107.27,89.73 107.27,90.62 107.58,90.92 107.58,93.27 108.17,93.86 108.17,97.44 106.49,99.13 106.49,99.57 106.81,99.89 106.81,100.27 107.06,100.52 111.64,100.52 113.9,98.25 124.14,98.25 124.18,98.22 132.34,98.22 138.98,104.86 146.98,104.86 147.55,105.43 156.14,105.43 157.21,106.5 160.68,106.5 162.26,104.92 163.68,104.92 v2(164.06,105.3)
  IN4 w0.109: v2(58.22,37.99) 58.54,38.31 63.73,38.31 68.03,42.61 69.6,42.61 95.25,68.25 95.25,76.19 107.23,88.17 v2(107.23,89.68)
  BOTTOM w0.102: v2(171.23,116.76) 171.25,116.79 171.25,117.55 171.7,118 172.62,118 172.85,117.77 174.65,117.77 175.06,117.36 175.72,117.36 176.05,117.03 U46.A2
UPD_GPU_SMBCLK: length 273.5
  TOP w0.102: v2(54.08,40.34) 53.59,39.85 JIO2.72 ; Q295.3 209.56,74.61 210.04,74.12 v2(210.23,74.12)
  IN1 w0.109: v2(193.84,114.36) 194.11,114.08 196.57,114.08 v2(196.85,114.36) 197.17,114.36 198.25,113.28 198.86,113.28 199.62,112.52 199.62,112.23 200.18,111.67 200.96,111.67 202.53,110.1 202.53,109.9 203.2,109.23 203.44,109.23 203.94,109.72 205.88,109.72 206.1,109.49 207.81,109.49 208.35,108.96 208.35,108.43 210.04,106.74 210.07,106.74 210.51,106.3 210.51,105.7 210.88,105.33 210.88,105.29 211.17,105 211.21,105 211.28,104.93 212.22,104.93 213.87,103.28 214.61,103.28 216.32,101.57 216.32,94.19 217.66,92.86 217.66,89.38 218.1,88.94 218.1,80.01 217.19,79.11 217.19,76.12 213.93,72.85 211.38,72.85 210.8,72.85 210.65,73 210.29,73.36 210.29,74.06 v2(210.23,74.12)
  IN2 w0.127: v2(54.08,40.34) 52.96,39.22 52.96,35.48 53.62,34.82 56.95,34.82 57.43,35.3 59.46,35.3 60.3,34.46 69.72,34.46 73.76,38.5 74.87,38.5 96.53,60.17 96.53,71.54 99.33,74.34 99.33,74.82 100.86,76.34 103.58,76.34 106.99,79.75 107.82,79.75 108.26,80.18 119.29,80.18 120.22,81.11 125.59,81.11 126.31,81.83 131.06,81.83 131.77,81.11 137.22,81.11 142.37,75.97 150.03,75.97 154.66,80.6 154.66,81.04 154.66,81.25 155.33,81.91 156.32,81.91 156.36,81.87 165.46,81.87 165.72,81.62 169.29,81.62 169.67,82 176.91,82 177.1,81.81 182.34,81.81 184.52,83.99 203.63,83.99 209.76,77.86 209.76,74.32 209.95,74.12 v2(210.23,74.12)
  BOTTOM w0.102: U51.B49 196.06,114.11 196.16,114.01 196.4,114.01 196.74,114.36 v2(196.85,114.36) ; R822.2 193.15,115.11 193.84,114.42 v2(193.84,114.36)
UPD_GPU_SMBDAT: length 271.6
  TOP w0.102: v2(53.47,40.35) JIO2.74 ; Q295.6 210.83,73.34 v2(210.83,73.99)
  IN1 w0.109: v2(210.83,73.99) 210.78,73.99 210.57,73.79 210.57,73.42 210.82,73.17 210.9,73.09 211.28,73.09 213.83,73.09 216.96,76.22 216.96,79.2 217.87,80.11 217.87,88.84 217.42,89.28 217.42,92.76 216.09,94.09 216.09,101.47 214.51,103.05 213.77,103.05 212.12,104.7 211.18,104.7 211.11,104.77 211.07,104.77 210.64,105.19 210.64,105.23 210.27,105.6 210.27,106.2 209.97,106.5 209.95,106.5 208.11,108.33 208.11,108.86 207.72,109.26 206.01,109.26 205.78,109.49 204.03,109.49 203.54,108.99 203.11,108.99 202.29,109.8 202.29,110.01 200.86,111.44 200.08,111.44 199.39,112.13 199.39,112.42 198.76,113.04 198.15,113.04 198,113.2 197.76,113.2 197.12,113.83 v2(197.12,113.81) 197.05,113.75 196.38,113.75 196.29,113.85 193.92,113.85 v2(193.84,113.77)
  IN2 w0.127: v2(210.83,73.99) 210.54,73.71 210.01,73.71 209.51,74.21 209.51,77.76 208.89,78.38 203.53,83.74 184.63,83.74 182.45,81.55 177,81.55 176.81,81.74 169.78,81.74 169.4,81.36 165.61,81.36 165.36,81.62 156.25,81.62 156.22,81.66 155.43,81.66 154.92,81.14 154.92,80.5 150.13,75.71 142.26,75.71 137.12,80.86 131.67,80.86 130.95,81.57 126.41,81.57 125.7,80.86 120.32,80.86 119.4,79.93 108.36,79.93 107.93,79.5 107.09,79.5 103.68,76.09 100.96,76.09 99.59,74.71 99.59,74.23 96.79,71.43 96.79,60.06 74.97,38.25 74.06,38.25 70.02,34.21 60.2,34.21 59.36,35.05 57.53,35.05 57.05,34.56 53.52,34.56 52.71,35.37 52.71,39.33 53.47,40.09 v2(53.47,40.35)
  BOTTOM w0.102: U51.B48 196.36,113.61 196.57,113.81 v2(197.12,113.81) ; R829.2 193.33,114.29 v2(193.84,113.77)
UPD_SMBUS_ALERT#: length 185.7
  TOP w0.102: v2(54.14,39.35) JIO2.70
  IN2 w0.127: v2(54.14,39.35) 54.5,39.71 54.51,39.71 54.57,39.77 54.92,39.77 55.3,39.39 57.37,39.39 58.17,39.39 58.71,38.84 61.52,38.84 61.71,38.65 65.92,38.65 67.04,39.78 67.23,39.78 73.98,46.52 73.98,46.83 75.62,48.47 78.75,48.47 92.4,62.12 92.4,74.51 98.33,80.45 99.83,80.45 102.92,83.55 105.28,83.55 105.94,84.21 106.74,84.21 108.15,85.62 110.83,85.62 111.58,86.37 116.71,86.37 117.08,86 122.81,86 123.63,85.17 125.2,85.17 126.28,86.26 131.34,86.26 131.98,85.61 136.04,85.61 136.8,84.85 138.13,84.85 138.61,84.38 143.28,84.38 144.03,83.63 152.01,83.63 156.28,87.9 159.08,87.9 161.69,85.29 167.12,85.29 v2(167.68,84.73)
  IN3 w0.127: v2(174.35,91.4) 174.52,91.56 174.52,93.89 173.54,94.87 173.54,96.75 173.56,96.77 173.56,99.21 172.6,100.18 172.6,101.04 174.12,102.56 174.12,103.92 173.47,104.58 173.47,104.96 174.43,105.92 174.43,110.72 173.47,111.68 v2(173.12,111.68)
  BOTTOM w0.102: v2(174.35,91.4) 174.35,89.94 v1(173.93,89.51) 173.33,88.92 173.33,86.72 173.03,86.42 172.99,86.42 172.19,85.62 169.9,85.62 169.12,84.83 167.78,84.83 v2(167.68,84.73) ; R3740.1 171.98,112.24 172.53,111.68 v2(173.12,111.68) 173.29,111.51 U46.A58
USB2_COMP: length 6.4
  TOP w0.089: RH193.1 138.66,114.5 138.66,114.02 v1(138.41,113.76)
  TOP w0.102: v1(138.41,113.76) 138.35,113.76 137.97,114.13 136.77,114.13 136.09,114.8 134.75,114.8 134.52,115.03 134.1,115.03 133.85,115.28 UH1.AG3
USB2_ID: length 3.1
  TOP w0.089: RH357.1 136.71,114.99 134.81,114.99 134.53,115.28 UH1.AG2
USB2_VBUSSENSE: length 3.5
  TOP w0.089: UH1.AD10 v2(130.65,114.25)
  BOTTOM w0.089: v2(130.65,114.25) 130.61,114.29 v1(130.61,114.85) 130.73,114.97 130.73,115.59 130.53,115.78 129.47,115.78 RH356.1
USB3_PRX_DTX_N1: length 105.9
  TOP w0.089: v2(132.33,99.99) 132.5,100.17 132.5,100.3 132.16,100.64 132.16,101.3 132.01,101.45 132.01,101.56 131.84,101.73 131.72,101.73 131.54,101.91 131.54,102.32 131.78,102.57 131.78,102.68 131.9,102.79 UH1.B7
  TOP w0.102: JIO2.91 56.75,44.85 56.87,44.72 56.87,44.66 56.97,44.57 58.25,44.57 58.43,44.74 58.43,44.95 v2(58.02,45.36)
  IN3 w0.127: v2(58.02,45.36) 58.21,45.55 58.21,45.87 58.59,46.25 59.7,46.25 103.11,89.66 105.53,89.66 106.56,90.69 109.57,90.69 110.08,91.2 112.33,91.2 113.29,92.16 115.17,92.16 115.87,92.86 127.83,92.86 129.99,95.02 129.99,97.02 132.51,99.53 132.51,99.81 v2(132.33,99.99)
USB3_PRX_DTX_N2: length 243.1
  TOP w0.089: UH1.C8 131.32,103.17 131.03,102.88 131.03,102.55 131.14,102.44 131.14,102.02 131.06,101.94 131.06,101.16 131.3,100.92 131.66,100.92 v2(131.78,100.8)
  TOP w0.102: v2(325.5,47.13) 325.51,47.13 v4(325.51,45.46) 325.51,44.55 326.98,43.07 328.45,43.07 329.04,42.49 329.04,42.36 329.2,42.2 UZ29.18
  IN4 w0.089: 141.76,103.39 141.67,103.39 141.65,103.41 138.63,103.41 135.89,100.67 133.61,100.67 132.95,101.33 132.42,101.33 132.27,101.17 132.02,101.17 131.93,101.08 131.93,100.98 131.78,100.83 v2(131.78,100.8)
  IN4 w0.109: 141.76,103.39 143.78,103.39 146.14,101.02 146.32,101.02 147.32,101.02 147.68,100.67 158.26,100.67 158.39,100.54 160.52,100.54 161.81,99.25 162.63,99.25 164.47,97.4 165.05,97.4 167.36,95.09 169.58,95.09 170.51,94.17 171.4,94.17 173.43,92.13 175.39,92.13 176.7,90.82 179.06,90.82 179.46,90.42 181.77,90.42 182.08,90.11 203.35,90.11 203.66,90.42 204.92,90.42 205.35,89.99 205.72,89.99 206.86,88.85 209.04,88.85 210.2,87.69 216.67,87.69 216.86,87.49 226.73,87.49 227.69,88.45 230.58,88.45 230.85,88.17 235.49,88.17 237.13,86.54 237.13,85.97 238.15,84.94 245.38,84.94 247.72,82.61 247.72,81.23 248.06,80.89 248.06,80.05 249.76,78.35 249.76,77.72 252.61,74.87 252.61,71.06 254.74,68.92 254.74,68.1 256.9,65.93 256.9,62.97 265.44,54.43 266.9,54.43 275.43,45.9 279.92,45.9 281.5,44.32 284.37,44.32 285.51,43.17 289,43.17 289.37,42.81 289.63,42.81 299,42.81 299.52,42.29 300.87,42.29 301.23,41.93 305.3,41.93 306.81,43.44 308.4,43.44 309.09,44.13 311.34,44.13 313.07,42.4 313.99,42.4 315.04,43.45 316.15,43.45 316.77,44.08 317.59,44.08 317.77,43.9 318.94,43.9 319.58,44.55 319.9,44.55 320.44,45.08 320.83,45.08 322.13,46.38 325.02,46.38 325.33,46.68 325.33,46.97 v2(325.5,47.13)
USB3_PRX_DTX_N3: length 241.2
  TOP w0.089: 130.51,99.28 130.67,99.45 130.68,99.45 130.72,99.49 131.15,99.92 131.15,100.37 130.67,100.85 130.67,101.53 130.61,101.59 130.61,102.09 130.62,102.1 130.62,102.45 130.72,102.55 UH1.B10
  TOP w0.102: JIO1.10 308.92,46.3 305.6,49.61 303,49.61 302.47,49.08 302.47,43.55 303.43,42.6 v2(303.43,36.66) ; 130.51,99.28 130.51,97.89 133.21,95.19 135.91,95.19 136.25,95.54 v4(141.81,95.54) 144.31,95.54 145.62,94.23 147.64,94.23 148.98,92.9 150.02,92.9 150.19,92.73 150.44,92.73 150.58,92.59 152.21,92.59 152.81,91.99 153.62,91.99 153.84,91.78 153.84,91.03 154.23,90.64 154.41,90.64 154.59,90.46 v2(154.59,90.44)
  IN4 w0.109: v2(303.43,36.66) 303.43,36.93 303.32,37.04 303,37.04 302.18,36.22 298.43,36.22 297.88,36.76 292.04,36.76 291.54,36.25 287.13,36.25 285.51,37.88 281.22,37.88 280.83,37.49 273.79,37.49 272.71,38.56 272.71,39.84 268.88,43.67 268.88,45.23 264.74,49.37 262.29,49.37 260.83,50.83 260.01,50.83 257.71,53.13 257.71,53.79 254.82,56.69 250.84,56.69 246.62,60.91 246.62,72.06 246.4,72.27 246.14,72.53 243.72,74.95 241.06,74.95 240.51,75.5 236.24,75.5 233.48,78.25 219.61,78.25 218.91,78.95 215.37,78.95 215.12,79.2 209.53,79.2 207.93,80.8 204.81,80.8 201.5,84.12 184.82,84.12 183.83,83.13 175.84,83.13 174.54,84.42 168.83,84.42 168.47,84.07 166.07,84.07 164.16,85.97 161.37,85.97 159.78,87.56 156.48,87.56 155.53,88.51 155.53,90.29 154.96,90.86 154.5,90.86 154.44,90.8 154.44,90.6 v2(154.59,90.44)
USB3_PRX_DTX_N4: length 227.4
  TOP w0.102: v2(130.41,104.73) 130.41,104.69 130.18,104.46 UH1.E11 ; v2(313.4,44.6) 313.4,45.59 313.96,46.16 313.96,47.4 314.17,47.61 314.26,47.61 314.45,47.8 JIO1.3
  IN4 w0.109: v2(313.4,44.6) 313.4,44.88 312.3,45.97 309.15,45.97 307.88,44.7 290.21,44.7 289.52,45.39 286.28,45.39 285.44,46.23 282.26,46.23 280.7,47.79 276.22,47.79 267.73,56.28 267.73,56.28 267.69,56.32 266.22,56.32 258.79,63.75 258.79,66.84 257.56,68.08 257.56,69.03 256.04,70.54 256.04,72.38 255.11,73.31 255.11,76.16 249.95,81.32 249.95,81.67 249.61,82.01 249.61,83.39 244.93,88.07 242.98,88.07 242.29,87.38 240.02,87.38 239.33,88.07 238.26,88.07 236.27,90.06 234.29,90.06 232.54,91.82 229.89,91.82 228.62,93.09 221.97,93.09 220.13,91.24 212.41,91.24 211.97,91.69 210.1,91.69 209.66,91.24 208.65,91.24 207.89,92.01 206.34,92.01 206.03,92.32 204.11,92.32 203.2,93.23 200.54,93.23 200.46,93.3 199.72,93.3 199.45,93.58 198.83,93.58 198.75,93.51 196.51,93.51 195.34,94.67 191.84,94.67 190.61,95.91 190.37,95.91 190.24,96.03 183.46,96.03 182.32,94.88 179.57,94.88 178.43,96.03 177.4,96.03 176.7,96.73 175.7,96.73 175.09,97.33 168.74,97.33 168.17,97.91 168.17,98.74 167.78,99.12 166.89,99.12 165.24,100.77 164.04,100.77 160.86,103.94 158.8,103.94 158.65,103.79 157.27,103.79 156.49,104.57 153.43,104.57 152.82,103.97 147.82,103.97 146.6,105.19 145.96,105.19 145.24,105.91 141.59,105.91 141.36,105.68 137.32,105.68 135.4,103.77 134.37,103.77 134.29,103.69 132.6,103.69 131.16,105.13 130.38,105.13 130.28,105.02 130.28,104.86 v2(130.41,104.73)
USB3_PRX_DTX_N5: length 240.6
  TOP w0.089: 129.14,105.08 v2(129.57,104.65)
  TOP w0.102: JIO1.25 316.08,42.3 316.19,42.19 316.19,42.1 316.27,42.02 317.96,42.02 318.3,42.36 318.3,43.34 v4(318.45,43.49) 319.27,44.31 319.27,44.53 319.15,44.65 318.88,44.65 318.77,44.75 318.69,44.75 318.49,44.55 v2(318.49,44.55) ; UH1.G13 129.14,105.08
  IN4 w0.109: v2(129.57,104.65) 129.4,104.48 129.4,104.35 129.51,104.25 129.75,104.25 129.81,104.19 129.81,103.99 130.6,103.21 131.16,103.21 131.69,102.68 135.65,102.68 138.02,105.05 141.36,105.05 141.59,105.28 144.98,105.28 145.7,104.56 146.27,104.56 147.51,103.31 153.05,103.31 153.69,103.94 156.23,103.94 157.67,102.5 160.72,102.5 162.36,100.87 163.05,100.87 163.88,100.03 165.03,100.03 166.35,98.71 166.35,98.06 167.81,96.6 171.49,96.6 171.61,96.48 171.61,96.48 173.65,94.44 175.23,94.44 175.84,95.05 175.95,95.05 175.96,95.05 176.48,95.05 176.48,95.05 177.18,95.05 177.52,95.4 178.08,95.4 179.23,94.25 182.58,94.25 183.72,95.4 189.98,95.4 190.83,94.55 190.83,92.06 191.53,91.37 202.75,91.37 203.05,91.68 205.78,91.68 206.09,91.37 207.57,91.37 208.58,90.37 209.31,90.37 209.39,90.29 209.76,90.29 209.8,90.34 210.14,90.34 210.18,90.29 220.65,90.29 222.2,91.84 228.97,91.84 231.37,89.43 236.01,89.43 238.01,87.43 238.84,87.43 239.78,86.49 242.47,86.49 243.42,87.43 244.68,87.43 248.98,83.13 248.98,81.75 249.32,81.41 249.32,80.57 250.76,79.13 251.25,79.13 254.29,76.09 254.29,73.25 255.41,72.12 255.41,70.21 256.93,68.7 256.93,67.82 258.16,66.58 258.16,63.49 265.96,55.69 267.43,55.69 267.48,55.64 275.96,47.17 280.44,47.17 282,45.6 285.05,45.6 285.89,44.76 289.25,44.76 289.95,44.07 308.14,44.07 308.83,44.76 311.73,44.76 313.09,43.4 313.98,43.4 315.42,44.84 315.42,45.28 316.18,46.04 317.76,46.04 318.62,45.18 318.62,44.9 318.7,44.82 318.7,44.75 v2(318.49,44.55)
USB3_PRX_DTX_N6: length 89.6
  TOP w0.102: v2(128.58,106.91) 128.51,106.83 128.49,106.83 128.21,106.55 UH1.K15
  IN1 w0.089: v2(128.58,106.91) 128.58,106.81 128.72,106.68 128.9,106.68 129.07,106.85 129.07,107.72 129.51,108.15 133.58,108.15 134.44,109.01 134.44,110.25 137.2,113 138.95,113 139.86,113.92 139.86,114.91 141.54,116.59 141.54,118.08 141.6,118.14
  IN1 w0.109: v2(179.21,157.7) 179.58,157.33 179.58,155.22 178.28,153.93 167.36,153.93 166.45,153.02 166.39,153.02 162.7,149.33 162.7,148.76 161.66,147.72 161.66,143.28 159.97,141.6 159.97,130.09 158.32,128.44 158.32,127.14 156.52,125.33 155.84,125.33 154.13,123.62 153.49,123.62 153.45,123.58 149.56,123.58 148.68,122.7 146.73,122.7 143.01,118.98 142.45,118.98 141.6,118.14
  BOTTOM w0.102: v2(179.21,157.7) 179.21,157.7 179.47,157.44 179.47,157.27 179.25,157.05 JDOCK1.84
USB3_PRX_DTX_P1: length 105.9
  TOP w0.089: UH1.A7 131.8,102.29 131.74,102.22 131.74,101.99 131.8,101.93 131.93,101.93 132.22,101.64 132.22,101.56 132.27,101.51 132.58,101.51 132.69,101.39 132.69,101.32 132.62,101.24 132.43,101.24 132.36,101.18 132.36,100.73 132.71,100.38 132.71,100.22 132.71,100.2 v2(132.91,99.99)
  TOP w0.102: v2(58.65,45.36) 58.65,45.35 58.65,44.65 58.34,44.35 JIO2.89
  IN3 w0.127: v2(132.91,99.99) 132.76,99.84 132.76,99.43 130.24,96.91 130.24,94.91 127.94,92.61 115.97,92.61 115.27,91.91 113.39,91.91 112.44,90.95 110.19,90.95 109.68,90.44 106.66,90.44 105.63,89.42 103.22,89.42 59.8,46 58.69,46 58.46,45.77 58.46,45.55 v2(58.65,45.36)
USB3_PRX_DTX_P2: length 243.1
  TOP w0.089: v2(131.65,101.37) 131.65,101.21 131.56,101.12 131.38,101.12 131.26,101.25 131.26,101.85 131.35,101.94 131.35,102.37 131.53,102.55 131.53,102.71 131.68,102.85 131.68,102.95 131.61,103.02 131.56,103.02 131.26,102.72 UH1.B8
  TOP w0.102: UZ29.19 328.7,42.15 328.82,42.27 328.82,42.4 328.36,42.86 326.86,42.86 v4(325.89,43.84) 325.28,44.44 325.28,46.67 v2(324.76,47.19)
  IN4 w0.089: v2(131.65,101.37) 132.19,101.37 132.34,101.52 133.03,101.52 133.69,100.86 135.81,100.86 138.55,103.6 141.76,103.6
  IN4 w0.109: 141.76,103.6 143.87,103.6 146.23,101.24 147.41,101.24 147.77,100.88 158.35,100.88 158.48,100.76 160.61,100.76 161.9,99.46 162.72,99.46 164.56,97.62 165.14,97.62 167.45,95.31 169.67,95.31 170.6,94.38 171.49,94.38 173.52,92.35 175.48,92.35 176.79,91.03 179.15,91.03 179.55,90.63 181.86,90.63 182.17,90.33 203.27,90.33 203.57,90.63 205.01,90.63 205.44,90.2 205.81,90.2 206.95,89.06 209.13,89.06 210.29,87.9 216.76,87.9 216.95,87.71 226.64,87.71 227.6,88.67 230.67,88.67 230.94,88.39 235.58,88.39 237.34,86.62 237.34,86.06 238.24,85.16 245.47,85.16 247.93,82.7 247.93,81.32 248.27,80.98 248.27,80.14 249.97,78.44 249.97,77.81 252.82,74.96 252.82,71.15 254.96,69.01 254.96,68.19 257.12,66.02 257.12,63.06 265.53,54.65 266.99,54.65 275.52,46.12 280,46.12 280.86,45.26 281.59,44.53 284.46,44.53 285.6,43.39 289.09,43.39 289.46,43.02 289.54,43.02 299.09,43.02 299.61,42.51 300.96,42.51 301.32,42.15 305.21,42.15 306.72,43.65 308.31,43.65 309,44.35 311.43,44.35 313.16,42.62 313.9,42.62 314.95,43.67 316.06,43.67 316.68,44.29 317.68,44.29 317.85,44.12 318.85,44.12 319.49,44.76 319.81,44.76 320.35,45.3 320.75,45.3 322.04,46.59 324.93,46.59 325.11,46.77 325.11,46.97 324.9,47.19 v2(324.76,47.19)
USB3_PRX_DTX_P3: length 241.2
  TOP w0.089: 130.81,99.28 130.87,99.34 130.87,99.35 131.35,99.84 131.35,100.45 130.88,100.93 130.88,101.61 130.82,101.67 130.82,101.94 130.94,102.07 130.94,102.19 UH1.A9
  TOP w0.102: 130.81,99.28 130.73,99.2 130.73,97.98 133.3,95.41 135.82,95.41 136.16,95.75 v4(143.18,95.75) 144.4,95.75 145.71,94.44 147.73,94.44 149.06,93.11 150.11,93.11 150.28,92.94 150.53,92.94 150.67,92.81 152.3,92.81 152.9,92.21 153.71,92.21 154.06,91.87 154.06,91.12 154.31,90.86 154.86,90.86 154.94,90.95 154.94,91.16 154.84,91.27 v2(154.6,91.27) ; JIO1.12 310.81,45.8 310.75,45.86 310.75,45.99 310.65,46.08 308.83,46.08 305.51,49.4 303.09,49.4 302.68,48.99 302.68,43.64 303.64,42.69 303.64,37.03 v2(304.01,36.66)
  IN4 w0.109: v2(154.6,91.27) 154.79,91.08 155.05,91.08 155.74,90.38 155.74,88.6 156.57,87.78 159.87,87.78 161.46,86.19 164.25,86.19 166.16,84.28 168.38,84.28 168.74,84.64 174.63,84.64 175.92,83.34 183.74,83.34 184.73,84.33 201.59,84.33 204.9,81.02 208.02,81.02 209.62,79.42 215.21,79.42 215.46,79.17 219,79.17 219.7,78.47 233.57,78.47 236.33,75.71 240.6,75.71 241.15,75.17 243.81,75.17 246.19,72.79 246.19,72.79 246.83,72.15 246.83,61 250.93,56.9 254.91,56.9 257.93,53.88 257.93,53.22 260.1,51.05 260.92,51.05 262.38,49.59 264.83,49.59 269.09,45.32 269.09,43.76 272.93,39.93 272.93,38.65 273.88,37.7 280.74,37.7 281.13,38.09 285.6,38.09 287.22,36.47 291.45,36.47 291.95,36.98 297.97,36.98 298.52,36.43 302.09,36.43 302.91,37.26 303.41,37.26 304.01,36.66 v2(304.01,36.66)
USB3_PRX_DTX_P4: length 227.5
  TOP w0.102: v2(313.98,44.6) 314.09,44.71 314.09,44.89 313.96,45.02 313.67,45.02 313.61,45.07 313.61,45.51 314.18,46.07 314.18,47.31 314.26,47.4 314.37,47.4 314.47,47.3 JIO1.5 ; UH1.G11 130.04,105.12 130.42,105.51 v2(130.45,105.51)
  IN4 w0.109: v2(313.98,44.6) 312.39,46.18 309.06,46.18 307.79,44.91 290.3,44.91 289.61,45.61 286.37,45.61 285.53,46.45 282.35,46.45 280.79,48.01 276.31,48.01 267.78,56.54 266.31,56.54 259.01,63.84 259.01,66.93 257.77,68.17 257.77,69.12 256.26,70.63 256.26,72.47 255.33,73.4 255.33,76.25 250.16,81.41 250.16,81.76 249.82,82.1 249.82,83.48 245.02,88.29 242.89,88.29 242.2,87.6 240.11,87.6 239.42,88.29 238.35,88.29 236.36,90.28 234.38,90.28 232.63,92.03 229.98,92.03 228.71,93.3 221.89,93.3 220.04,91.46 212.5,91.46 212.06,91.9 210.01,91.9 209.57,91.46 208.74,91.46 207.98,92.22 206.43,92.22 206.12,92.53 204.2,92.53 203.29,93.44 200.63,93.44 200.55,93.52 199.81,93.52 199.53,93.8 198.74,93.8 198.66,93.72 196.6,93.72 195.43,94.89 191.93,94.89 190.7,96.12 190.46,96.12 190.33,96.24 183.37,96.24 182.23,95.1 179.66,95.1 178.52,96.24 177.49,96.24 176.79,96.95 175.79,96.95 175.18,97.55 168.83,97.55 168.38,98 168.38,98.83 167.87,99.34 166.98,99.34 165.33,100.99 164.13,100.99 160.95,104.16 158.71,104.16 158.56,104 157.36,104 156.58,104.79 153.34,104.79 152.73,104.19 147.91,104.19 146.69,105.4 146.05,105.4 145.33,106.12 141.5,106.12 141.27,105.9 137.23,105.9 135.31,103.99 134.28,103.99 134.2,103.9 132.69,103.9 131.25,105.34 130.61,105.34 v2(130.45,105.51)
USB3_PRX_DTX_P5: length 240.6
  TOP w0.089: v2(129.53,105.46) 129.36,105.46 UH1.H13
  TOP w0.102: v2(319.05,45.05) 319.49,44.62 319.49,44.22 318.52,43.25 318.52,42.27 318.05,41.8 v4(317.19,41.8) JIO1.27
  IN4 w0.109: v2(129.53,105.46) 129.53,105.29 130.03,104.8 130.03,104.08 130.69,103.42 131.25,103.42 131.78,102.9 135.56,102.9 137.93,105.26 141.27,105.26 141.5,105.49 145.07,105.49 145.79,104.77 146.36,104.77 147.6,103.53 152.96,103.53 153.6,104.16 156.32,104.16 157.76,102.72 160.81,102.72 162.45,101.08 163.14,101.08 163.97,100.25 165.12,100.25 166.56,98.8 166.56,98.15 167.9,96.82 171.58,96.82 171.83,96.57 173.74,94.66 175.14,94.66 175.75,95.27 176.04,95.27 176.05,95.27 176.39,95.27 176.39,95.27 177.09,95.27 177.44,95.61 178.17,95.61 179.32,94.47 182.49,94.47 183.63,95.61 190.07,95.61 191.05,94.64 191.05,92.15 191.62,91.59 202.66,91.59 202.96,91.89 205.87,91.89 206.18,91.59 207.66,91.59 208.67,90.58 209.4,90.58 209.48,90.51 209.67,90.51 209.71,90.55 210.23,90.55 210.27,90.51 220.57,90.51 222.11,92.06 229.06,92.06 231.46,89.65 236.1,89.65 238.1,87.65 238.93,87.65 239.87,86.71 242.38,86.71 243.33,87.65 244.59,87.65 244.77,87.65 249.19,83.22 249.19,81.84 249.53,81.5 249.53,80.66 250.85,79.35 251.34,79.35 254.5,76.18 254.5,73.34 255.63,72.21 255.63,70.3 257.14,68.79 257.14,67.91 258.38,66.67 258.38,63.58 266.05,55.91 267.52,55.91 267.57,55.85 276.05,47.38 280.53,47.38 282.09,45.82 285.14,45.82 285.98,44.98 289.34,44.98 290.03,44.28 308.05,44.28 308.74,44.98 311.82,44.98 313.18,43.62 313.89,43.62 315.21,44.93 315.21,45.37 316.09,46.25 317.85,46.25 v2(319.05,45.05)
USB3_PRX_DTX_P6: length 89.6
  TOP w0.102: UH1.K13 128.98,106.6 128.6,106.21 v2(128.6,106.17)
  IN1 w0.089: v2(128.6,106.17) 128.6,106.28 128.8,106.48 128.98,106.48 129.27,106.77 129.27,107.64 129.59,107.95 133.66,107.95 134.64,108.93 134.64,110.17 137.28,112.81 139.03,112.81 140.06,113.84 140.06,114.83 141.76,116.53 141.76,117.96 141.74,117.97 141.76,117.99
  IN1 w0.109: v2(179.79,157.7) 179.79,155.13 178.37,153.71 167.45,153.71 166.54,152.8 166.48,152.8 162.92,149.25 162.92,148.67 161.87,147.63 161.87,143.2 160.19,141.51 160.19,130 158.54,128.35 158.54,127.05 156.61,125.12 155.93,125.12 154.22,123.4 153.58,123.4 153.54,123.36 149.65,123.36 148.77,122.49 146.82,122.49 143.1,118.77 142.54,118.77 141.76,117.99
  BOTTOM w0.102: v2(179.79,157.7) 179.68,157.59 179.68,157.12 179.75,157.05 JDOCK1.86
USB3_PTX_C_DRX_N2: length 4.5
  TOP w0.102: UZ29.16 330.2,42.34 v4(329.52,43.02) 328.76,43.78 327.79,43.78 327.54,44.04 327.54,44.37 CZ25.2
USB3_PTX_C_DRX_P2: length 4.4
  TOP w0.102: UZ29.17 329.7,42.51 328.68,43.53 v4(328.17,43.53) 327.74,43.53 327.32,43.95 327.32,44.1 CZ26.2
USB3_PTX_DRX_N1: length 103.8
  TOP w0.089: UH1.C11 130.21,103.17 129.98,102.94 129.98,102.55 130.23,102.31 130.23,101.95 130.24,101.94 130.24,101.35 130.29,101.29 130.29,100.21 v2(130.14,100.06)
  TOP w0.102: v2(57.64,46.81) 58.01,46.44 58.01,46.29 57.7,45.98 57.02,45.98 56.94,46.07 56.94,46.25 56.84,46.35 JIO2.97
  IN3 w0.127: v2(57.64,46.81) 57.83,47 57.83,47.43 58.17,47.77 60.07,47.77 103.46,91.15 105.49,91.15 106.37,92.03 110.3,92.03 110.75,92.47 112.59,92.47 112.97,92.85 114.62,92.85 115.32,93.55 127.56,93.55 129.31,95.3 129.31,97.67 130.28,98.64 130.28,99.92 v2(130.14,100.06)
USB3_PTX_DRX_N2: length 240.2
  TOP w0.089: UH1.B12 129.59,102.7 130.05,102.24 130.05,101.88 130.07,101.87 130.07,101.39 129.93,101.24 v2(129.93,101)
  TOP w0.102: CZ25.1 327.38,45.84 327.38,46.51 v2(327.57,46.69)
  IN4 w0.089: 141.4,102.76 141.2,102.95 138.88,102.95 136.08,100.16 133.35,100.16 133.15,100.36 132.12,100.36 132.01,100.24 131.54,100.24 131.38,100.24 131.27,100.36 131.27,100.36 130.32,101.3 129.96,101.3 129.84,101.18 129.84,101.09 v2(129.93,101)
  IN4 w0.109: v2(327.57,46.69) 327.57,46.03 327.28,45.74 322.39,45.74 321.47,44.83 321.47,44.41 320.91,43.85 319.78,43.85 319.2,43.27 317.81,43.27 317.2,42.67 315.47,42.67 315.28,42.48 315.28,41.78 314.54,41.04 313.42,41.04 310.96,43.5 309.35,43.5 308.66,42.81 307.25,42.81 305.7,41.26 301.01,41.26 300.61,41.66 299.25,41.66 298.76,42.16 289.13,42.16 288.84,42.45 283.58,42.45 282.89,43.14 281.47,43.14 280.78,43.84 276.52,43.84 266.55,53.8 265.18,53.8 261.38,57.6 258.2,60.78 256.34,62.64 256.27,62.71 256.27,63.23 256.28,63.23 256.28,65.41 254.11,67.58 254.11,68.58 254.11,68.67 251.77,71 251.77,74.81 249,77.58 249,78.22 247.43,79.79 247.43,80.63 245.36,82.7 242.49,82.7 241.96,83.23 237.13,83.23 236.61,82.71 228.61,82.71 226.23,85.08 218.66,85.08 218.4,85.34 211.65,85.34 208.78,88.22 206.57,88.22 205.54,89.25 205.2,89.25 204.68,89.77 203.97,89.77 203.68,89.48 181.82,89.48 181.51,89.79 179.2,89.79 178.8,90.19 174.86,90.19 174.31,90.74 173.87,90.74 172.15,92.45 171.14,92.45 169.8,93.78 167.78,93.78 164.79,96.77 163.45,96.77 162.1,98.12 160,98.12 159.3,98.83 157.47,98.83 156.27,100.03 147.6,100.03 147.49,99.91 146.54,99.91 146.54,99.91 146.36,99.91 143.52,102.76 141.4,102.76
USB3_PTX_DRX_N3: length 240.1
  TOP w0.089: UH1.C13 129.04,103.17 129.16,103.04 129.16,102.45 129.01,102.29 129.01,101.94 128.88,101.82 128.88,100.96 129.14,100.71 129.14,99.91 129.52,99.52 129.52,99.28
  TOP w0.102: v2(301.52,37.61) 301.52,49.2 302.59,50.27 306.15,50.27 308.62,47.8 JIO1.4 ; v2(153.33,90.63) 153.33,90.64 153.14,90.64 153.06,90.72 153.06,90.9 152.96,91 152.84,91 151.88,91.96 150.33,91.96 150.18,92.11 149.53,92.11 149.43,92.2 148.78,92.2 147.38,93.61 145.36,93.61 144.06,94.91 v4(138.66,94.91) 136.64,94.91 136.3,94.57 132.9,94.57 129.52,97.95 129.52,99.28
  IN4 w0.109: v2(153.33,90.63) 153.15,90.81 152.99,90.81 152.66,91.14 152.66,91.54 153.47,92.35 155.1,92.35 156.6,90.85 156.6,88.88 157.07,88.41 160.13,88.41 160.28,88.26 163.07,88.26 163.89,87.45 165.44,87.45 165.92,86.97 165.92,86.33 166.48,85.77 168.85,85.77 169.23,85.39 174.77,85.39 176.19,83.97 183.48,83.97 184.47,84.96 201.85,84.96 205.13,81.68 210.15,81.68 211.65,80.18 215.44,80.18 215.82,79.8 219.26,79.8 219.96,79.1 236.9,79.1 239.66,76.34 240.86,76.34 241.41,75.8 244.18,75.8 247.54,72.44 247.54,61.19 251.14,57.59 256,57.59 258.68,54.91 258.68,53.36 260.36,51.68 261.18,51.68 262.64,50.22 265.09,50.22 275.22,40.09 279.37,40.09 280.46,39 281.29,39 281.57,38.72 285.86,38.72 287.48,37.1 291.19,37.1 291.7,37.61 298.99,37.61 299.48,37.12 301.31,37.12 301.52,37.33 v2(301.52,37.61)
USB3_PTX_DRX_N4: length 251.7
  TOP w0.089: UH1.A14 128.58,102.26 128.58,102.08 128.49,102 128.49,100.54 128.58,100.45 128.58,99.71 128.9,99.39 128.9,99.28
  TOP w0.102: v2(152.05,90.44) 151.75,90.74 151.2,90.74 150.61,91.33 150.08,91.33 149.93,91.48 149.27,91.48 149.17,91.58 148.46,91.58 147.06,92.98 145.11,92.98 143.8,94.29 136.97,94.29 136.63,93.95 v4(135.51,93.95) 132.64,93.95 128.9,97.69 128.9,99.28 ; v2(319.57,38.25) 319.57,39.77 319.19,40.15 319.19,40.93 319.44,41.17 319.85,41.59 319.85,42.67 321.28,44.09 321.28,47.21 320.76,47.73 319.61,47.73 318.05,46.17 316.15,46.17 316.01,46.3 JIO1.9
  IN4 w0.109: v2(319.57,38.25) 319.5,38.17 319.5,37.74 319.29,37.53 318.84,37.53 318.76,37.45 318.58,37.45 318.06,37.45 317.75,37.13 315.49,37.13 315.23,37.4 307.23,37.4 305.35,35.52 297.92,35.52 297.6,35.83 295.38,35.83 295.27,35.72 292.35,35.72 291.35,34.72 289.65,34.72 288.81,35.55 286.77,35.55 285.08,37.25 281.48,37.25 281.07,36.84 273.5,36.84 272.08,38.26 272.08,39.58 268.3,43.36 266.85,43.36 266.08,44.13 266.08,44.81 264.66,46.24 263.57,46.24 262.8,47 262.8,47.63 262.8,47.97 260.57,50.2 259.75,50.2 256.98,52.97 256.98,53.52 254.46,56.04 250.6,56.04 245.97,60.67 245.97,71.7 243.36,74.32 240.8,74.32 240.25,74.87 235.97,74.87 233.25,77.59 219.71,77.59 219.32,77.21 213.62,77.21 213.6,77.23 211.77,77.23 211.09,77.91 209.89,77.91 207.7,80.09 204.63,80.09 201.24,83.49 185.08,83.49 184.09,82.5 175.57,82.5 174.42,83.65 169.16,83.65 168.62,83.12 165.49,83.12 164.03,84.58 164.02,84.58 163.58,85.02 159.33,85.02 157.42,86.93 156.22,86.93 154.9,88.25 154.9,88.76 153.77,89.89 152.99,89.89 152.45,90.44 v2(152.05,90.44)
USB3_PTX_DRX_N5: length 248.9
  TOP w0.089: UH1.B14 128.45,102.99 128.58,103.12 128.72,103.12 128.81,103.03 128.81,102.9 128.71,102.79 128.71,102.74 128.51,102.54 128.46,102.54 128.33,102.41 128.33,102.4 128.31,102.38 128.31,99.57 128.48,99.4 128.48,99.38 128.49,99.37 128.49,99.28
  TOP w0.102: v2(318.57,38.83) 318.57,39.2 318.65,39.28 318.65,39.75 318.18,40.21 317.57,40.82 316.15,40.82 316.12,40.8 JIO1.31 ; v2(152.05,89.66) 152.05,89.6 151.93,89.48 151.76,89.48 151.24,90 151.24,90.13 150.44,90.93 149.91,90.93 149.76,91.08 149.1,91.08 149,91.18 148.22,91.18 146.82,92.58 144.94,92.58 143.63,93.89 137.28,93.89 136.94,93.54 v4(134.29,93.54) 132.47,93.54 131.63,94.39 128.49,97.52 128.49,99.28
  IN4 w0.109: v2(152.05,89.66) 152.3,89.41 152.47,89.41 156.08,85.8 157.69,85.8 159.14,84.35 163.29,84.35 164.93,82.7 169.95,82.7 170.59,82.06 171.32,82.06 171.96,82.7 174.78,82.7 175.4,82.08 184.26,82.08 185.25,83.07 201.07,83.07 204.49,79.65 207.35,79.65 210.18,76.82 213.43,76.82 213.94,76.31 219.92,76.31 220.4,76.8 233.45,76.8 236.29,73.96 240.18,73.96 240.23,73.9 242.77,73.9 245.55,71.12 245.55,60.66 245.55,60.5 249.15,56.9 249.15,55.38 249.5,55.04 250.17,55.04 250.52,55.39 254.47,55.39 256.53,53.33 256.53,52.83 259.58,49.79 260.4,49.79 262.39,47.8 262.39,46.78 264.9,44.26 264.9,43.76 265.71,42.95 268.13,42.95 271.67,39.4 271.67,38.09 273.33,36.43 281.24,36.43 281.65,36.83 284.91,36.83 286.61,35.14 288.51,35.14 290.29,33.36 297.25,33.36 299,35.11 305.52,35.11 307.33,36.91 314.86,36.91 315.63,36.15 316.84,36.15 317.29,36.6 319.96,36.6 320.27,36.91 320.27,38.56 319.22,39.62 318.76,39.62 318.13,38.99 318.13,38.81 318.26,38.69 318.43,38.69 v2(318.57,38.83)
USB3_PTX_DRX_N6: length 98.3
  TOP w0.089: v2(127.61,101.3) 127.94,101.63 UH1.B15
  IN1 w0.089: 141.6,115.78 141.59,115.76 141.59,115.75 140.98,115.14 140.59,114.75 140.59,113.61 139.23,112.24 138.11,112.24 135.67,109.81 135.67,108.22 133.9,106.45 133.26,106.45 132.94,106.13 132.57,106.13 132.06,105.62 132.06,104.51 130.97,103.43 128.03,103.43 126.91,102.31 126.91,101.69 127.17,101.42 127.49,101.42 v2(127.61,101.3)
  IN1 w0.109: v2(180.71,157.76) 180.71,154.19 179.81,153.3 167.75,153.3 166.2,151.75 166.2,148.83 162.79,145.42 162.79,143.06 160.6,140.87 160.6,129.83 159.94,129.16 159.94,125.93 159.15,125.14 157.27,125.14 156.61,124.48 155.88,124.48 154.31,122.91 150.68,122.91 149.72,121.95 147.83,121.95 147.4,121.52 146.56,121.52 143.39,118.35 142.77,118.35 142.19,117.78 142.19,116.37 141.6,115.78
  BOTTOM w0.102: JDOCK1.90 180.75,157.05 180.83,157.13 180.83,157.65 v2(180.71,157.76)
USB3_PTX_DRX_P1: length 103.8
  TOP w0.089: UH1.B11 130.21,102.88 130.29,102.96 130.4,102.96 130.47,102.89 130.47,102.52 130.43,102.48 130.43,102.04 130.44,102.02 130.44,101.43 130.5,101.38 130.5,100.29 v2(130.73,100.06)
  TOP w0.102: v2(58.23,46.81) 58.23,46.2 57.79,45.77 56.93,45.77 56.85,45.85 JIO2.95
  IN3 w0.127: v2(130.73,100.06) 130.53,99.87 130.53,98.53 129.56,97.56 129.56,95.2 127.66,93.3 115.42,93.3 114.72,92.6 113.07,92.6 112.69,92.22 110.85,92.22 110.41,91.78 106.47,91.78 105.59,90.9 103.56,90.9 60.18,47.52 58.27,47.52 58.08,47.33 58.08,46.96 v2(58.23,46.81)
USB3_PTX_DRX_P2: length 240.1
  TOP w0.089: v2(129.47,101.39) 129.79,101.39 129.87,101.47 129.87,101.68 129.77,101.77 129.65,101.77 129.58,101.84 129.58,101.93 129.65,102 129.77,102 129.85,102.08 129.85,102.16 129.72,102.29 UH1.A12
  TOP w0.102: v2(326.98,46.69) 327.17,46.51 327.17,45.8 CZ26.1
  IN4 w0.089: 141.5,102.97 141.47,102.97 141.43,103.02 141.43,103.02 141.3,103.15 138.79,103.15 136,100.36 133.43,100.36 133.23,100.55 132.04,100.55 131.93,100.44 131.46,100.44 130.4,101.5 129.57,101.5 v2(129.47,101.39)
  IN4 w0.109: v2(326.98,46.69) 326.98,46.69 326.98,46.67 326.81,46.5 326.81,46.38 326.94,46.25 327.26,46.25 327.32,46.18 327.32,46.08 327.19,45.96 322.3,45.96 321.26,44.92 321.26,44.5 320.82,44.07 319.69,44.07 319.11,43.49 317.72,43.49 317.11,42.88 315.38,42.88 315.07,42.57 315.07,41.87 314.45,41.25 313.51,41.25 311.05,43.72 309.26,43.72 308.57,43.02 307.16,43.02 305.61,41.48 301.1,41.48 300.7,41.88 299.34,41.88 298.85,42.37 289.22,42.37 288.93,42.67 283.67,42.67 282.98,43.36 281.56,43.36 280.87,44.05 276.61,44.05 266.64,54.02 265.27,54.02 261.47,57.82 258.35,60.94 256.49,62.8 256.49,63.14 256.49,63.14 256.49,65.5 254.32,67.67 254.32,68.49 254.32,68.49 254.32,68.76 251.99,71.09 251.99,74.9 249.22,77.67 249.22,78.31 247.64,79.88 247.64,80.72 245.45,82.91 242.58,82.91 242.05,83.44 237.04,83.44 236.52,82.93 228.7,82.93 226.32,85.3 218.75,85.3 218.49,85.56 211.74,85.56 208.87,88.43 206.66,88.43 205.63,89.47 205.29,89.47 204.77,89.99 203.88,89.99 203.59,89.7 181.91,89.7 181.6,90 179.29,90 178.89,90.4 174.95,90.4 174.4,90.95 173.96,90.95 172.24,92.67 171.23,92.67 169.89,94 167.87,94 164.88,96.99 163.54,96.99 162.19,98.34 160.09,98.34 159.39,99.04 157.56,99.04 156.36,100.24 147.51,100.24 147.4,100.13 146.45,100.13 143.61,102.97 141.5,102.97
USB3_PTX_DRX_P3: length 240.1
  TOP w0.089: 129.73,99.28 129.72,99.3 129.72,99.61 129.34,99.99 129.34,100.79 129.09,101.05 129.09,101.7 129.19,101.8 129.19,102.23 129.34,102.38 129.34,103.39 129.3,103.43 UH1.D13
  TOP w0.102: JIO1.6 310.75,47.3 310.67,47.38 310.67,47.5 310.59,47.58 308.54,47.58 306.06,50.06 302.68,50.06 301.73,49.11 301.73,37.98 v2(302.1,37.61) ; v2(153.39,91.22) 152.92,91.22 151.97,92.17 150.42,92.17 150.27,92.32 149.62,92.32 149.52,92.42 148.87,92.42 147.46,93.82 145.45,93.82 144.15,95.13 v4(140.19,95.13) 136.55,95.13 136.21,94.79 132.99,94.79 129.73,98.04 129.73,99.28
  IN4 w0.109: v2(302.1,37.61) 302.1,37.36 302,37.26 301.75,37.26 301.4,36.91 299.39,36.91 298.9,37.4 291.79,37.4 291.28,36.89 287.39,36.89 285.77,38.51 281.48,38.51 281.2,38.78 280.37,38.78 279.28,39.87 275.13,39.87 265,50 262.55,50 261.09,51.46 260.27,51.46 258.46,53.27 258.46,54.82 255.91,57.37 251.05,57.37 247.32,61.1 247.32,72.35 244.09,75.58 241.32,75.58 240.77,76.13 239.57,76.13 236.81,78.88 219.87,78.88 219.17,79.58 215.73,79.58 215.35,79.97 211.56,79.97 210.06,81.47 205.04,81.47 201.76,84.75 184.56,84.75 183.57,83.76 176.1,83.76 174.68,85.17 169.14,85.17 168.76,85.55 166.39,85.55 165.7,86.24 165.7,86.88 165.35,87.23 163.8,87.23 162.98,88.04 160.19,88.04 160.04,88.19 156.98,88.19 156.38,88.79 156.38,90.76 155.01,92.13 153.56,92.13 152.87,91.45 152.87,91.23 153.08,91.03 153.2,91.03 v2(153.39,91.22)
USB3_PTX_DRX_P4: length 251.7
  TOP w0.089: 129.11,99.28 129.11,99.46 128.78,99.79 128.78,100.54 128.69,100.62 128.69,101.91 128.78,102 128.78,102.57 128.88,102.67 UH1.B13
  TOP w0.102: v2(318.99,38.25) 318.99,38.46 319.05,38.53 319.27,38.53 319.36,38.62 319.36,39.68 318.98,40.06 318.98,41.02 319.29,41.33 319.64,41.68 319.64,42.76 321.06,44.18 321.06,47.12 320.67,47.52 319.7,47.52 318.14,45.95 316.23,45.95 316.08,45.8 JIO1.11 ; 129.11,99.28 129.11,97.78 132.73,94.17 136.54,94.17 136.88,94.51 v4(137.22,94.51) 143.89,94.51 145.2,93.2 147.15,93.2 148.55,91.8 149.26,91.8 149.36,91.7 150.02,91.7 150.17,91.55 150.7,91.55 151.29,90.95 151.93,90.95 v2(152.06,91.08)
  IN4 w0.109: v2(152.06,91.08) 152.06,91.01 152.41,90.66 152.54,90.66 153.08,90.11 153.86,90.11 155.11,88.85 155.11,88.34 156.31,87.15 157.51,87.15 159.42,85.24 163.67,85.24 164.11,84.79 165.58,83.33 168.53,83.33 169.07,83.87 174.51,83.87 175.66,82.71 184,82.71 184.99,83.7 201.33,83.7 204.72,80.31 207.79,80.31 209.98,78.13 211.18,78.13 211.86,77.45 213.69,77.45 213.71,77.43 219.23,77.43 219.62,77.81 233.34,77.81 236.06,75.08 240.34,75.08 240.89,74.53 243.45,74.53 246.18,71.79 246.18,60.76 250.69,56.26 254.55,56.26 257.19,53.61 257.19,53.06 259.84,50.42 260.66,50.42 263.02,48.06 263.02,47.63 263.02,47.09 263.66,46.45 264.75,46.45 266.3,44.9 266.3,44.22 266.94,43.58 268.39,43.58 272.3,39.67 272.3,38.35 273.59,37.06 280.98,37.06 281.39,37.46 285.17,37.46 286.86,35.77 288.9,35.77 289.73,34.94 291.26,34.94 292.26,35.94 295.18,35.94 295.29,36.05 297.69,36.05 298.01,35.74 305.26,35.74 307.14,37.61 315.32,37.61 315.58,37.35 317.66,37.35 317.97,37.66 318.67,37.66 318.75,37.74 319.2,37.74 319.28,37.83 319.28,37.96 319.16,38.08 319.16,38.15 319.07,38.25 v2(318.99,38.25)
USB3_PTX_DRX_P5: length 248.9
  TOP w0.089: 128.27,99.28 128.27,99.3 128.28,99.31 128.11,99.48 128.11,102.48 128.19,102.56 128.19,103.01 128.45,103.28 UH1.C14
  TOP w0.102: 128.27,99.28 128.27,97.43 131.41,94.3 131.41,94.3 132.38,93.33 v4(132.95,93.33) 137.03,93.33 137.37,93.67 143.54,93.67 144.85,92.36 146.73,92.36 148.13,90.96 148.91,90.96 149.01,90.86 149.67,90.86 149.82,90.71 150.35,90.71 151.02,90.04 151.02,89.91 151.67,89.26 151.87,89.26 v2(152.06,89.07) ; v2(317.89,39.33) 318.08,39.14 318.2,39.14 318.36,39.29 318.36,39.29 318.43,39.37 318.43,39.66 317.97,40.12 317.97,40.12 317.48,40.61 316.23,40.61 316.18,40.56 316.18,40.37 316.12,40.3 JIO1.33
  IN4 w0.109: v2(152.06,89.07) 152.51,89.07 155.99,85.58 157.6,85.58 159.05,84.13 163.2,84.13 164.85,82.49 169.86,82.49 170.5,81.85 171.41,81.85 172.05,82.49 174.69,82.49 175.31,81.87 184.35,81.87 185.34,82.86 200.98,82.86 204.4,79.43 207.26,79.43 210.09,76.6 213.34,76.6 213.85,76.09 220.01,76.09 220.49,76.58 233.36,76.58 236.2,73.74 240.09,73.74 240.15,73.69 242.68,73.69 245.34,71.03 245.34,60.75 245.34,60.41 245.4,60.34 248.94,56.81 248.94,55.29 249.41,54.82 250.26,54.82 250.61,55.18 254.38,55.18 256.32,53.24 256.32,52.74 259.49,49.57 260.31,49.57 262.17,47.71 262.17,46.69 264.69,44.18 264.69,43.67 265.62,42.73 268.04,42.73 271.45,39.31 271.45,38 273.24,36.21 281.33,36.21 281.74,36.62 284.82,36.62 286.52,34.92 288.42,34.92 290.2,33.14 297.34,33.14 299.09,34.89 305.61,34.89 307.42,36.7 314.77,36.7 315.54,35.94 315.71,35.94 315.72,35.94 316.93,35.94 317.38,36.38 320.05,36.38 320.49,36.82 320.49,38.65 319.31,39.83 318.67,39.83 318.16,39.33 v2(317.89,39.33)
USB3_PTX_DRX_P6: length 98.2
  TOP w0.089: UH1.C15 127.94,103.09 127.71,102.86 127.71,102.03 v2(127.55,101.87)
  IN1 w0.089: 141.76,115.63 141.74,115.61 141.73,115.61 140.79,114.67 140.79,113.53 139.31,112.05 138.19,112.05 135.87,109.73 135.87,108.14 133.98,106.25 133.34,106.25 133.02,105.93 132.65,105.93 132.25,105.54 132.25,104.43 131.06,103.23 128.11,103.23 127.11,102.23 127.11,101.77 127.25,101.62 127.42,101.62 127.55,101.75 v2(127.55,101.87)
  IN1 w0.109: 141.76,115.63 142.41,116.28 142.41,117.69 142.86,118.14 143.48,118.14 146.65,121.31 147.49,121.31 147.92,121.74 149.81,121.74 150.77,122.69 154.4,122.69 155.97,124.26 156.7,124.26 157.36,124.92 159.24,124.92 160.15,125.84 160.15,129.07 160.82,129.74 160.82,140.78 163.01,142.97 163.01,145.33 166.41,148.74 166.41,151.66 167.84,153.08 179.9,153.08 180.92,154.1 180.92,157.4 v2(181.29,157.76)
  BOTTOM w0.102: v2(181.29,157.76) 181.04,157.52 181.04,157.26 181.25,157.05 JDOCK1.92
USB20_N1: length 123.7
  TOP w0.101: UH1.AF5 v2(132.58,115.33)
  TOP w0.102: JIO2.85 58.19,43.35 58.44,43.1 v2(58.44,42.5)
  IN3 w0.089: 133.19,114.54 133.19,114.55 133.16,114.55 132.83,114.88 132.52,114.88 132.38,115.01 132.38,115.18 132.54,115.33 v2(132.58,115.33)
  IN3 w0.127: v2(58.44,42.5) 58.21,42.73 58.21,42.88 58.28,42.95 59.07,42.95 62.72,46.59 62.72,47.95 71.11,56.35 71.93,56.35 74.64,59.06 74.64,59.66 101.74,86.76 107.23,86.76 110.6,90.13 115.2,90.13 116.12,91.04 116.12,91.55 116.41,91.85 128.14,91.85 130.92,94.63 130.92,96.58 133.59,99.24 133.59,99.49 133.64,99.55 133.64,101.27 133.39,101.51 133.39,102.18 133.7,102.49 134.15,102.49 134.53,102.87 134.53,110.11 133.41,111.22 133.41,114.32 133.19,114.54
USB20_N2: length 227
  TOP w0.089: UH1.AD5 132.94,113.93 v2(132.58,114.28)
  TOP w0.102: JIO1.16 310.81,44.8 310.69,44.68 310.69,44.59 310.61,44.52 309.05,44.52 307.95,45.61 v4(307.73,45.61) 307.72,45.61 307.32,45.61 306.73,46.2 306.73,46.29 306.83,46.39 306.93,46.39 307.1,46.56 v2(307.1,46.65)
  IN4 w0.089: 141.76,110.7 134.56,110.7 133.3,111.96 133.3,112.33 132.35,113.28 132.35,114.05 v2(132.58,114.28)
  IN4 w0.109: v2(307.1,46.65) 306.76,46.99 306.76,46.99 306.42,47.33 305.73,47.33 305.21,46.8 291.11,46.8 290.42,47.5 287.47,47.5 286.62,48.34 283.13,48.34 281.57,49.9 277.09,49.9 272.72,54.28 268.15,58.85 266.68,58.85 260.9,64.62 260.9,67.71 259.66,68.95 259.66,69.91 258.18,71.4 258.18,73.34 257.34,74.18 257.34,74.27 257.34,76.91 255.82,78.43 255.82,79.42 255.82,79.42 255.82,79.65 254.99,80.47 254.99,82.57 254.35,83.21 254.35,85.23 252.07,87.52 250.7,87.52 247.82,90.4 247.15,91.07 244.28,91.07 243.63,91.71 240.29,91.71 240.1,91.9 239.32,91.9 239.32,91.91 238.8,91.91 238.79,91.9 238.19,91.9 237.76,92.34 237.76,92.57 237.25,93.09 237.24,93.09 237.22,93.1 234.4,93.1 234.24,93.26 232.11,95.4 231.04,95.4 228.19,98.25 225.94,98.25 225.15,99.04 218.83,99.04 218.65,99.04 217.06,97.45 213.75,97.45 212.6,96.3 208.02,96.3 206.99,95.27 205.27,95.27 203.53,97.01 201.16,97.01 200.2,96.05 196.95,96.05 196.22,96.78 195.52,96.78 195.25,97.05 195.07,97.05 194.59,97.05 192.98,98.66 189.96,98.66 189.53,98.23 182.51,98.23 182.15,97.87 181.13,97.87 180.76,98.24 180.37,98.24 179.77,98.85 177.89,98.85 177.25,99.49 177.02,99.72 176.82,99.72 175.97,100.57 175.13,100.57 174.4,101.3 174.1,101.3 173.88,101.52 172.85,101.52 172.19,102.18 168.89,102.18 168.28,102.79 168.28,105.53 167.56,106.26 166.62,106.26 165.35,107.53 164.95,107.53 163.84,108.64 162.88,108.64 162.53,108.99 161.21,108.99 160.72,108.5 156.93,108.5 156.38,109.05 153.79,109.05 152.8,108.06 151.07,108.06 150.34,108.79 149.52,108.79 149.13,109.18 146.92,109.18 145.81,110.28 143.26,110.28 142.84,110.7 141.76,110.7
USB20_N3: length 241.7
  TOP w0.089: v2(131.17,115.33) 131.21,115.33 131.41,115.13 UH1.AG8
  TOP w0.102: JIO1.15 316.11,44.8 316.21,44.7 316.21,44.62 316.28,44.55 v4(317.02,44.55) 317.56,44.55 319,45.99 320.09,45.99 320.27,46.17 320.27,46.69 320.14,46.81 320.04,46.81 319.9,46.95 v2(319.9,47.07)
  IN4 w0.089: 141.76,111.41 139.37,111.41 138.68,112.1 134.67,112.1 133.48,113.29 133.48,114.3 132.94,114.84 130.88,114.84 130.75,114.98 130.75,115.44 130.85,115.54 131.04,115.54 131.17,115.41 v2(131.17,115.33)
  IN4 w0.109: v2(319.9,47.07) 320.12,46.84 320.12,46.73 320.02,46.63 319.37,46.63 319.09,46.91 315.16,50.85 311.93,50.85 309.93,48.84 306.25,48.84 304.92,47.51 291.4,47.51 290.71,48.2 287.84,48.2 287,49.04 283.43,49.04 281.86,50.61 277.38,50.61 262.08,65.91 262.08,67.53 260.37,69.24 260.37,70.82 260.2,70.99 259,72.2 259,73.52 258.05,74.47 258.05,77.2 256.53,78.72 256.53,79.13 256.53,79.13 256.53,80.02 255.76,80.79 255.76,82.82 255.06,83.52 255.06,85.53 252.36,88.22 250.99,88.22 246.76,92.46 241.15,92.46 241,92.61 240.71,92.61 240.3,93.02 238.83,93.02 238.04,93.81 234.7,93.81 231.5,97.01 231.5,97.68 229.16,100.02 225.37,100.02 225.12,99.78 218.18,99.78 217.76,99.36 213.57,99.36 211.71,97.5 207.53,97.5 207.23,97.2 205.07,97.2 204.05,98.23 197.23,98.23 196.63,98.83 193.96,98.83 193.42,99.37 189.29,99.37 188.87,98.94 180.67,98.94 180.06,99.55 179.22,99.55 177.45,101.33 175.98,101.33 175.06,102.26 173.45,102.26 172.34,103.36 170.32,103.36 169.51,104.17 169.51,105.3 167.85,106.96 166.91,106.96 165.52,108.35 165.14,108.35 163.75,109.75 156.68,109.75 156.67,109.76 153.5,109.76 153.49,109.75 153.24,109.75 153.01,109.52 151.97,109.52 151.69,109.24 151.03,109.24 150.78,109.49 149.84,109.49 149.39,109.94 147.16,109.94 146.11,110.99 143.57,110.99 143.14,111.41 141.76,111.41
USB20_N4: length 223.7
  TOP w0.089: UH1.AE1 134.86,114.19 135.56,114.19 135.95,113.81 v2(135.95,113.75)
  TOP w0.102: JIO1.28 310.87,41.8 310.79,41.71 310.79,41.59 310.71,41.52 310.41,41.52 309.93,41.03 309.22,41.03 308.69,41.57 308.69,43.23 v4(305.26,46.65) 303.94,47.97 303.94,48.48 v2(304.31,48.85)
  IN4 w0.089: v2(135.95,113.75) 136.11,113.75 136.21,113.65 136.21,113.5 136.11,113.39 136.01,113.39 135.94,113.32 135.94,113.14 136.04,113.04 139.29,113.04 139.55,113.3 141.09,113.3 141.22,113.43 141.66,113.43 141.67,113.44 141.73,113.44 141.74,113.45 141.76,113.45
  IN4 w0.109: v2(304.31,48.85) 304.27,48.89 304.27,49.68 303.67,50.27 302.71,50.27 302.05,49.61 288.52,49.61 287.66,50.48 284.02,50.48 282.46,52.04 277.95,52.04 263.52,66.47 263.52,68.12 261.8,69.84 261.8,71.48 260.8,72.48 260.8,73.74 259.48,75.07 259.48,77.77 257.94,79.31 257.94,82.74 256.54,84.13 256.54,86.25 250.67,92.13 250.67,92.34 249.95,93.07 249.73,93.07 248.54,94.26 243.51,94.26 243.17,94.6 240.94,94.6 239.95,95.59 234.92,95.59 232.99,97.52 232.99,98.22 229.65,101.56 219.35,101.56 218.63,102.28 215.93,102.28 215.61,102.6 213.17,102.6 213.02,102.45 212.53,102.45 211.41,101.33 210.72,101.33 210.72,101.33 210.02,101.33 208.56,99.87 207.45,99.87 207.22,99.64 198.04,99.64 196.79,100.88 185.04,100.88 184.71,101.22 183.43,101.22 182.56,100.36 181.58,100.36 179.96,101.98 178.96,101.98 178.2,102.74 176.65,102.74 175.2,104.19 173.93,104.19 173.04,105.08 173.04,105.72 172.51,106.26 171.67,106.26 170.82,107.11 170.82,107.11 169.36,108.57 167.34,110.59 164.99,110.59 164.41,111.17 152.63,111.17 152.51,111.04 150.64,111.04 149.82,111.86 149.51,111.86 148,113.37 146.41,113.37 145.97,112.92 145.32,112.92 144.79,113.45 141.76,113.45
USB20_N5: length 76.3
  TOP w0.089: UH1.AC2 134.23,113.1 134.3,113.17 134.42,113.17 134.5,113.09 134.5,113.02 134.67,112.85 136.51,112.85 136.87,112.48 137.32,112.48
  TOP w0.102: v2(141.41,112.1) 141.2,112.3 141.2,112.48 140.9,112.78 v4(139.45,112.78) 139.13,112.78 138.83,112.48 137.32,112.48
  IN1 w0.089: v2(141.41,112.1) 141.24,112.26 141.24,112.53 141.66,112.95 141.66,114 141.73,114.06 141.74,114.06 141.76,114.08
  IN1 w0.109: v2(175.12,152.46) 174.96,152.3 174.96,150.35 174.3,149.69 173.75,149.69 173.5,149.94 173.5,150.48 173.37,150.6 172.79,150.6 172.66,150.48 172.66,149.84 172.88,149.63 172.88,148.48 171.42,147.02 169.97,147.02 168.04,145.09 167.12,145.09 167.01,144.99 166.44,144.41 166.44,143.86 162.62,140.04 162.62,129.34 162.86,129.1 162.86,125.94 159.97,123.06 158.29,123.06 157.51,122.28 157.48,122.28 157.48,122.28 157.11,122.28 155.68,120.85 154.64,120.85 154.23,120.44 154.23,120.02 153.54,119.32 152.28,119.32 152.16,119.2 148.67,119.2 147.74,118.27 145.95,118.27 141.76,114.08
  BOTTOM w0.102: v2(175.12,152.46) 174.92,152.66 174.92,153.5 175.14,153.72 175.14,154.89 175.25,155 JDOCK1.68
USB20_N6: length 110.1
  TOP w0.089: UH1.AF2 134.57,114.59 136.05,114.59 137.36,113.28 137.68,113.28 137.69,113.28 137.71,113.28
  TOP w0.102: 137.71,113.28 140.96,113.28 141.32,112.92 v4(142.93,112.92) 145.48,112.92 145.88,112.53 146,112.53 146.42,112.1 v2(146.42,112.1)
  IN1 w0.109: v2(211,128.04) 210.63,128.41 208.84,128.41 207.88,129.37 204.46,129.37 199.69,134.14 199.69,136.93 198,138.62 197.49,138.62 196.19,139.91 189.54,139.91 188.67,140.77 182.61,140.77 182.35,140.52 182.35,140.01 181.56,139.22 174.08,139.22 173.78,139.53 168.51,139.53 166.03,137.05 166.03,133.42 166.7,132.75 166.7,124.84 163.62,121.76 163.62,120.04 162.92,119.34 162.67,119.34 161.77,118.43 160.86,118.43 159.95,117.52 158.88,117.52 155.21,113.85 154.51,113.85 153.13,115.23 150.6,115.23 150.52,115.31 150,115.31 148.16,113.47 146.82,113.47 146.05,112.71 146.05,112.47 146.42,112.1 v2(146.42,112.1)
  BOTTOM w0.102: v2(211,128.04) 211.05,128.09 211.36,128.09 211.47,127.98 211.68,127.98 211.96,127.7 JNGFF1.5
USB20_N7: length 76.6
  TOP w0.089: UH1.AB3 134.03,112.49 134.41,112.11 134.91,112.11 134.95,112.07 135.65,112.07 136.13,111.6 137.68,111.6 137.68,111.59 137.71,111.59
  TOP w0.102: v2(142.83,112.11) 142.8,112.09 142.8,111.59 142.56,111.35 v4(141.56,111.35) 139.16,111.35 138.92,111.59 137.71,111.59
  IN1 w0.109: v2(142.83,112.11) 142.66,112.28 142.66,113.94 146.28,117.56 148.05,117.56 148.95,118.46 152.44,118.46 152.6,118.61 154.07,118.61 154.26,118.42 155.34,118.42 155.76,118.85 155.76,119.93 157.4,121.57 157.77,121.57 157.78,121.57 157.8,121.57 157.99,121.77 158.52,122.3 160.21,122.3 163.56,125.65 163.56,126.29 164.13,126.85 164.13,128.54 163.71,128.96 163.71,131.87 163.44,132.14 163.44,139.85 166.41,142.83 168.06,142.83 169.9,144.67 170.97,144.67 171.45,145.15 171.45,145.65 176.48,150.68 176.48,150.88 v2(176.79,151.19)
  BOTTOM w0.102: v2(176.79,151.19) 176.54,151.44 176.54,154.8 176.75,155.01 JDOCK1.74
USB20_N8: length 276.8
  TOP w0.089: UH1.AL8 131.1,117.17 130.94,117.33 v2(130.94,117.65)
  IN4 w0.089: v2(130.94,117.65) 130.99,117.65 131.3,117.34 131.3,117.16 131.55,116.92 131.87,116.92 132.99,115.8 133.22,115.8 133.74,115.28 133.74,113.68 134.94,112.47 141.47,112.47 141.53,112.53 141.76,112.53
  IN4 w0.109: 141.76,112.53 143.58,112.53 144.63,111.48 146.31,111.48 147.34,110.45 149.85,110.45 150.19,110.1 152.89,110.1 153.03,110.25 163.96,110.25 165.12,109.09 165.88,109.09 166.58,108.39 168.16,108.39 170.26,106.28 170.26,105.32 170.72,104.86 171.84,104.86 173.46,103.25 174.82,103.25 176.25,101.82 177.69,101.82 178.77,100.74 179.47,100.04 180.26,100.04 180.87,99.43 184.25,99.43 184.72,99.91 196.32,99.91 197.51,98.72 207.61,98.72 207.82,98.93 208.38,98.93 208.38,98.93 208.72,98.93 209.21,98.45 211.75,98.45 213.22,99.91 214.68,99.91 215.96,101.19 218.42,101.19 219.04,100.57 222.85,100.57 223.11,100.3 223.63,100.3 223.89,100.57 229.33,100.57 232.04,97.86 232.04,97.16 234.53,94.67 239.56,94.67 240.89,93.33 248.13,93.33 249.22,92.25 249.22,91.8 249.62,91.4 250.1,91.4 250.44,91.06 250.44,91.03 255.56,85.91 255.56,83.8 256.3,83.05 256.3,81.07 257.02,80.36 257.02,78.92 258.56,77.39 258.56,74.65 259.86,73.35 259.86,72.12 260.88,71.1 260.88,69.46 262.57,67.76 262.57,66.74 262.59,66.72 262.59,66.09 273.5,55.18 277.57,51.12 282.05,51.12 283.31,49.86 283.63,49.53 287.22,49.53 288.06,48.69 296.7,48.69 297.39,48 304.46,48 305.79,49.33 307.04,49.33 309.22,51.52 315.18,51.52 316.41,50.29 317.02,49.67 318.43,48.26 318.87,47.82 323.14,47.82 324.4,49.08 328.86,49.08 331.57,46.37 331.57,44.09 332.48,43.19 332.48,41.69 331.89,41.11 331.89,40.58 331.38,40.07 331.38,38.4 330.56,37.59 330.56,35.64 330.05,35.14 329.24,35.14 325.98,31.88 325.98,25.93 326.18,25.74 326.18,24.38 v2(326.14,24.34)
  BOTTOM w0.102: v2(326.14,24.34) 326.14,25.08 326.49,25.43 JNGFF2.9
