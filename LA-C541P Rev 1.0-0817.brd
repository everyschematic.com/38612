# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPP_F23: length 6.1
  TOP w0.089: UH1.V44 113.46,110.44 113.3,110.28 113.09,110.28 112.37,109.56 112.37,109.09
  TOP w0.102: RH214.1 109.72,108.66 110.6,107.78 v1(110.8,107.78) 111.55,107.78 112.09,108.32 112.09,108.81 112.37,109.09
GPU_EVENT#: length 154.7
  TOP w0.089: UH1.AR24 123.33,118.9 v2(122.94,118.63)
  TOP w0.102: D94.1 209.02,67.58 207.9,66.47 v2(207.9,66.16)
  IN3 w0.089: 167.29,64.74 168.48,64.74 168.66,64.91 174.48,64.91 174.69,65.13 176.58,65.13 177.31,64.4 179.76,64.4 180.65,63.5 180.65,62.34 181.17,61.82 181.17,61.37 181.8,60.74 186.67,60.74 187.27,60.14 191.98,60.14 192.03,60.09 192.8,60.09 193.13,59.76 197.33,59.76 198.81,61.25 199.9,61.25 ; v2(122.94,118.63) 122.94,118.62 124.86,116.7 127.01,116.7 127.5,116.21 128.29,116.21 129.22,117.14 133.71,117.14 134.66,116.18 134.66,113.07 136.12,111.61 136.12,104.59 136.49,104.22 136.49,101.76 135.11,100.38 135.11,99.28
  IN3 w0.127: 135.11,99.28 135.11,98.53 134.12,97.54 134.12,93.25 134.52,92.85 134.52,90.04 135.54,89.02 135.54,87.54 139.76,83.32 139.76,73.03 148.04,64.74 167.29,64.74 ; 199.9,61.25 202.99,61.25 v2(207.9,66.16)
  BOTTOM w0.089: v2(122.94,118.63) 123.21,118.9 123.21,120.32 123.18,120.34 123.18,121.49 123.53,121.84 123.53,123.49 123.97,123.94 123.97,125.26 123.03,126.2
  BOTTOM w0.102: 123.03,126.2 123.02,126.22 v1(123.02,126.97) 123.02,127.73 122.36,128.39 122.36,129.1 122.58,129.33 122.77,129.33 RH345.2
GPU_EVENT#_D: length 11.5
  TOP w0.102: JMXM1.78 203.25,79.19 203.17,79.11 203.17,77.77 205.07,75.86 205.73,75.86 v1(208.43,73.16) 208.72,72.87 208.72,71.35 D94.2
GPU_PWR_LEVEL: length 72.9
  TOP w0.102: U17.2 216.69,76.72 216.36,77.05 216.36,77.67 217.42,78.72 217.79,78.72 218.57,79.51 218.57,88.53 v1(216.78,90.33) 216.06,91.05 210.69,91.05 v2(210.56,90.93)
  IN2 w0.127: v2(172.18,107.78) 172.31,107.91 173.84,107.91 175.53,106.22 178.09,106.22 178.5,105.81 183.86,105.81 184.95,104.72 184.95,104.17 186.1,103.03 189,103.03 189.76,102.27 190.54,102.27 192.09,100.72 192.57,100.72 194.43,98.85 195.73,98.85 196.25,99.37 199.72,99.37 200.24,98.85 201.12,98.85 202.09,97.89 203.09,97.89 203.21,97.77 203.78,97.77 205.04,96.5 207.29,96.5 209.49,94.31 209.49,92.45 210.56,91.38 v2(210.56,90.93)
  BOTTOM w0.102: R782.1 v2(172.18,107.78) 172.92,108.51 U46.A52
GPU_SMBCLK_R: length 10.3
  TOP w0.102: JMXM1.70 205.25,78.85 205.38,78.72 205.38,76.86 205.89,76.35 206.04,76.35 206.91,75.48 208.29,75.48 208.37,75.4 v1(208.37,74.86) 208.37,74.48 Q295.4 209.45,73.2 R1.2
GPU_SMBDAT_R: length 11.6
  TOP w0.102: Q295.1 210.93,75.28 R2.2 211.92,75.8 211.64,76.08 211.35,76.08 210.99,75.71 207.19,75.71 v1(206.61,76.3) 206.33,76.58 205.99,76.58 205.61,76.95 205.61,78.72 205.75,78.85 JMXM1.68
GREEN_DOCK: length 80.8
  TOP w0.102: JMXM1.198 171.25,80.86 175.26,84.88 175.26,85.59 175.61,85.94 v2(175.94,85.94)
  IN3 w0.127: v2(175.94,85.94) 175.76,85.94 175.37,86.33 175.37,88.15 172.89,90.63 172.89,92.87 172.55,93.22 172.55,93.71 172.02,94.24 172.02,97.38 172.03,97.39 172.03,98.59 171.07,99.55 171.07,101.67 171.99,102.58 171.99,103 171.78,103.21 171.09,103.21 170.69,103.61 170.69,103.95 171.79,105.05 171.79,106.85 172.3,107.36 172.36,107.36 172.6,107.61 172.6,110.39 171.24,111.75 171.24,112.37 170.35,113.26 170.35,115.53 169.83,116.05 169.83,121.25 168.92,122.16 168.92,125.73 166.09,128.56 166.09,134.26 167.82,135.98 167.82,136.12 168.63,136.94 168.63,142.64 170.41,144.42 v2(170.41,145.3)
  BOTTOM w0.102: JDOCK1.59 173.25,147.29 172.88,146.92 172.28,146.92 170.66,145.3 v2(170.41,145.3)
H_CATERR#: length 13.4
  TOP w0.089: 195.15,19.45 194.5,20.1 193.74,20.1 v1(193.14,20.7) 192.63,21.21 192.63,23.4 192.81,23.58 192.81,26.39 CPU1.BM30
  TOP w0.102: RC172.1 198,16.98 195.53,19.45 195.15,19.45
H_PECI: length 187.7
  TOP w0.089: v2(195.41,23.31) 195.38,23.34 CPU1.BT34
  TOP w0.102: v2(140.82,116.42) 141.34,115.89 RH73.2 ; v2(190.15,105.3) 189.56,105.3 189.26,105.61 189.26,106.52 190.8,108.06 190.8,110.59 190.65,110.74 190.65,113.87 190.85,114.07 v2(191.49,114.07)
  IN1 w0.109: v2(191.49,114.07) 191.75,114.07 192.19,114.51 192.19,115.4 191.56,116.03 191.56,117.84 191.79,118.07 194.06,118.07 194.66,118.66 194.66,120.25 v2(194.71,120.31)
  IN3 w0.127: v2(190.15,105.3) 190.15,104.66 189.7,104.22 189.7,102.75 190.61,101.85 190.61,100.22 196,94.83 196,91.15 194.5,89.64 194.5,85.42 196.54,83.38 196.54,78.56 196.1,78.12 v2(195.95,78.12)
  IN4 w0.089: 181.17,70.91 181.17,70.67 181.17,65.72 182.35,64.54 182.41,64.54 183.12,63.83 183.12,60.99 183.52,60.6 183.52,58.66 184.27,57.91 184.27,48.69 182.91,47.33 182.91,45.84 183.95,44.8 183.95,43.66 185.61,42 185.61,31.33 186.09,30.86 186.22,30.86 186.22,30.85 187.32,30.85 187.91,30.26 187.91,28.96 188.08,28.8 188.87,28.8 189.69,27.97 191.1,27.97 195.41,23.66 v2(195.41,23.31) ; v2(140.82,116.42) 141.48,115.75 141.76,115.75
  IN4 w0.109: v2(195.95,78.12) 195.95,78.13 190.25,78.13 190.22,78.11 189.88,78.11 189.85,78.13 188.94,78.13 188.94,78.13 188.6,78.13 188.6,78.13 187.2,78.13 187.17,78.11 186.83,78.11 186.81,78.13 183.3,78.13 181.17,76.01 181.17,71.14 181.17,70.91 ; v2(190.15,105.3) 189.94,105.09 185.29,105.09 184.4,105.98 181.04,105.98 180.33,106.7 180.33,108.09 179.26,109.15 176.68,109.15 176.39,108.87 175.26,108.87 174.1,110.03 174.1,110.58 173.48,111.19 172.82,111.19 172.42,111.59 171.92,111.59 170.2,113.3 167.04,113.3 166.73,113.61 164.72,113.61 164.44,113.88 162.41,113.88 162.13,114.16 153.04,114.16 152.45,114.76 150.99,114.76 150.47,115.27 149.35,115.27 148.96,115.67 145.83,115.67 145.74,115.75 141.76,115.75
  BOTTOM w0.102: v2(194.71,120.31) 194.49,120.09 R953.2
H_PM_DOWN: length 181.5
  TOP w0.089: 135.55,115.98 134.65,115.98 UH1.AH2
  TOP w0.102: v2(196.67,9.01) RC168.1 ; 135.55,115.98 135.79,116.23 137.9,116.23 138.09,116.03 138.73,116.03 v2(139.11,115.65)
  IN3 w0.127: v2(187.49,101.62) 187.52,101.59 187.52,98.04 190.73,94.83 190.73,87.98 191.11,87.59 191.11,85.17 193.79,82.49 v2(193.79,80.89)
  IN4 w0.089: 195.24,17.89 195.24,20.82 193.74,22.32 193.74,24.74 190.98,27.51 189.58,27.51 188.74,28.34 187.32,28.34 187.2,28.46 187.2,29.03 187.21,29.05 187.21,29.35 187,29.56 186.79,29.56 186.25,30.09 186.03,30.09 185.69,30.43 185.23,30.43 184.49,31.17 184.3,31.17 184.17,31.31 182.7,31.31 182.12,31.89 182.12,39.93 182.1,39.95 182.1,40.39 182.12,40.41 182.12,41.51 181.7,41.93 181.7,46.31 181.92,46.53 181.92,48.6 181.91,48.6 181.91,53.1 182.58,53.77 182.58,54.07 181.89,54.75 181.89,60 181.47,60.42 181.47,61.5 180.43,62.55 180.43,63.63 179.77,64.28 179.71,64.28 177.64,66.35 177.64,70.91 ; v2(139.11,115.65) 139.17,115.65 139.49,115.34 139.81,115.34 141.2,113.94 141.76,113.94
  IN4 w0.109: 195.24,17.89 195.24,13.87 196.32,12.79 196.32,9.36 v2(196.67,9.01) ; 177.64,70.91 177.64,73.36 178.07,73.79 178.07,75.65 179.6,77.17 180.47,77.17 181.43,78.13 181.43,78.36 181.43,78.7 182.3,79.57 192.59,79.57 193.79,80.78 v2(193.79,80.89) ; 141.76,113.94 144.99,113.94 145.08,113.86 148.21,113.86 149.71,112.35 150.6,112.35 151.05,111.91 153.2,111.91 153.45,111.66 164.63,111.66 164.95,111.34 167.56,111.34 168.06,110.84 168.61,110.84 168.85,110.6 168.85,110.57 171.21,108.21 172.69,108.21 173.78,107.13 173.78,106.22 174.82,105.18 178.04,105.18 178.49,104.73 178.49,103.82 178.79,103.53 179.16,103.53 180.91,101.77 184.86,101.77 185.2,101.44 187.27,101.44 187.44,101.62 v2(187.49,101.62)
H_PM_DOWN_R: length 17.3
  TOP w0.089: v2(194.61,22.55) 194.25,22.91 194.25,23.46 194.31,23.52 194.31,24.96 CPU1.BP31
  TOP w0.102: v1(197.15,12.15) v2(197.15,11.46) 196.67,10.98 RC168.2
  IN4 w0.089: 196.67,17.89 196.67,20.63 194.75,22.55 v2(194.61,22.55)
  IN4 w0.109: v2(197.15,11.46) 197.27,11.59 197.27,13.4 196.67,14.01 196.67,16.2 196.67,16.2 196.67,17.89
H_PM_SYNC: length 17.3
  TOP w0.089: CPU1.BM34 195.53,26.69 v2(195.85,26.36)
  TOP w0.102: v2(197.84,13.42) 197.65,13.23 197.65,10.66 RC167.2
  IN4 w0.089: 197.08,17.89 197.08,23.58 196.99,23.67 196.99,23.67 196.78,23.88 196.78,23.88 195.85,24.81 v2(195.85,26.36)
  IN4 w0.109: 197.08,17.89 197.08,14.18 v2(197.84,13.42)
H_PM_SYNC_R: length 184.5
  TOP w0.089: 138.18,116.52 135.7,116.52 135.36,116.18 134.52,116.18 134.46,116.12 133.66,116.12 UH1.AJ4
  TOP w0.102: 138.18,116.52 138.75,116.52 v2(138.85,116.42) ; v2(197.56,9) RC167.1
  IN3 w0.127: v2(195.04,80.83) 194.86,81.01 194.86,82.76 192.82,84.81 192.82,91.51 193.05,91.74 193.05,93.27 192.63,93.69 192.63,94.76 189.78,97.61 189.78,101.37 v2(189.55,101.59)
  IN4 w0.089: 141.76,114.36 141.1,114.36 139.81,115.65 139.68,115.65 138.92,116.42 v2(138.85,116.42) ; 179.65,70.91 179.65,65.73 182.31,63.06 182.31,61.49 182.73,61.07 182.73,54.17 182.76,54.14 182.76,53.69 182.64,53.58 182.64,42.71 182.29,42.36 182.29,40.34 182.27,40.32 182.27,40.02 182.29,40 182.29,31.96 182.77,31.49 184.42,31.49 185.29,30.62 187.23,30.62 187.57,30.28 187.57,28.8 187.81,28.55 188.78,28.55 189.54,27.79 191.03,27.79 194.05,24.78 194.05,22.4 196.25,20.19 196.25,17.89
  IN4 w0.109: v2(197.56,9) 197.56,10.47 196.73,11.29 196.73,13.36 196.25,13.84 196.25,16.02 196.25,16.03 196.25,17.89 ; 179.65,70.91 179.37,71.18 179.37,75.48 181.84,77.96 181.84,78.53 182.39,79.08 193.29,79.08 v2(195.04,80.83) ; 141.76,114.36 145.16,114.36 145.25,114.27 148.38,114.27 149.89,112.76 151.01,112.76 151.4,112.37 152.08,112.37 152.45,112.74 161.58,112.74 162.24,112.07 164.9,112.07 165.02,112.19 165.36,112.19 165.69,111.86 168.36,111.86 169.27,110.94 170.02,110.94 170.76,110.19 171.72,110.19 172.27,109.64 172.27,109.27 174.19,107.35 174.19,106.39 174.99,105.59 178.53,105.59 179.43,104.69 179.43,103.84 181.08,102.19 184.3,102.19 184.4,102.28 188.97,102.28 189.51,101.74 189.51,101.63 v2(189.55,101.59)
H_PROCHOT#: length 368.2
  TOP w0.102: v2(199.12,7.09) 199.12,8.27 198.8,8.59 195.62,8.59 195.52,8.69 RC158.1 RC180.2 ; v2(267.71,33.64) 267.93,33.42 PR725.1 ; PR1607.2 259.69,33.13 v2(259.69,33.67) ; PR1110.2 v2(263.68,39.83) PR1103.2 ; v2(212.89,107.27) 212.89,108.42 213.3,108.83 213.3,114.63 v1(213.09,114.84) 213.09,116.92 213.62,117.45 v2(214,117.45) ; PQ1074.6 337.19,43.46 337.74,42.92 337.74,41.61 338.26,41.09 v2(339.54,41.09)
  IN1 w0.109: v2(267.71,33.64) 263.82,33.64 263.6,33.42 259.93,33.42 v2(259.69,33.67) 259.85,33.84 262.75,33.84 263.68,34.77 v2(263.68,39.83) 264.29,40.45 264.29,42.69 263.82,43.17 261.54,43.17 259.36,45.34 259.36,46.07 254.21,51.22 250.82,51.22 248.52,53.53 248.52,56.15 243.82,60.86 243.82,65.36 241.57,67.61 241.23,67.61 240.56,68.28 240.56,69.29 237.61,72.24 237.61,72.39 231.77,78.23 227.04,78.23 222.76,82.5 222.76,86 221.58,87.19 221.58,98.59 219.73,100.44 219.34,100.44 218.14,101.64 217.97,101.64 215.65,103.96 215.65,104.83 214.78,105.7 214.47,105.7 v2(212.89,107.27)
  IN3 w0.127: v2(267.71,33.64) 267.89,33.82 269.56,33.82 270.96,32.42 272.13,32.42 273.88,30.67 273.88,28.24 271.9,26.26 271.9,18.05 274.18,15.77 283.95,15.77 284.56,16.38 298.14,16.38 300.17,14.35 311.24,14.35 312.63,15.74 326.19,15.74 327.87,17.42 333.43,17.42 334.48,18.47 334.48,23.28 337.8,26.6 337.8,32.89 339.54,34.63 v2(339.54,41.09)
  IN4 w0.109: v2(194.58,121.7) 194.3,121.42 194.3,119.95 194.98,119.27 200.49,119.27 200.66,119.1 207.7,119.1 209.57,120.97 212.17,120.97 212.43,120.71 212.43,118.59 213.57,117.45 v2(214,117.45) ; v2(199.12,7.09) 201.24,7.09 202.48,5.85 219.49,5.85 220.55,6.91 240.59,6.91 241.89,8.22 244.42,8.22 248.77,12.57 248.77,29.85 249.72,30.79 255.21,30.79 256.3,31.88 258.19,31.88 259.69,33.38 v2(259.69,33.67)
  BOTTOM w0.102: v2(194.58,121.7) 194.58,121.04 194.46,120.92 193.87,120.33 193.87,116.97 193.71,116.82 193.71,115.12 194.45,114.39 194.45,114.1 194.45,114.1 194.68,113.86 U51.A46
H_PROCHOT#_R: length 26.1
  TOP w0.089: CPU1.BR30 193.38,24.45 193.38,23.79 193.47,23.71 193.47,22.49 193.1,22.12 v2(193.1,22.04)
  TOP w0.102: RC158.2 195.88,10.92 v2(195.88,11.2)
  IN4 w0.089: v2(193.1,22.04) 193.29,22.04 193.72,21.61 193.72,21.36 193.45,21.09 193.45,19.65 194.19,18.91 194.19,18.71 194.28,18.62 194.9,18.62 194.99,18.53 194.99,18.35 194.9,18.26 194.28,18.26 194.19,18.17 194.19,17.89
  IN4 w0.109: v2(195.88,11.2) 195.88,10.82 195.75,10.69 195.56,10.69 195.39,10.86 195.39,11.53 195.28,11.64 195.06,11.64 194.95,11.53 194.95,10.99 194.84,10.88 194.62,10.88 194.19,11.31 194.19,12.65 194.3,12.76 194.69,12.76 194.8,12.87 194.8,13.09 194.69,13.2 194.3,13.2 194.19,13.31 194.19,13.52 194.3,13.63 194.69,13.63 194.8,13.74 194.8,13.96 194.69,14.07 194.3,14.07 194.19,14.18 194.19,14.4 194.3,14.51 194.69,14.51 194.8,14.62 194.8,14.84 194.69,14.94 194.3,14.94 194.19,15.05 194.19,15.27 194.3,15.38 194.69,15.38 194.8,15.49 194.8,15.71 194.69,15.82 194.3,15.82 194.19,15.93 194.19,16.15 194.3,16.26 194.69,16.26 194.8,16.36 194.8,16.58 194.69,16.69 194.3,16.69 194.19,16.8 194.19,17.02 194.3,17.13 194.69,17.13 194.8,17.24 194.8,17.46 194.69,17.57 194.3,17.57 194.19,17.68 194.19,17.89
H_PWRGD: length 180.3
  TOP w0.089: CPU1.BT31 193.86,22.35 193.78,22.27 193.78,21.86 194.21,21.43 194.21,21.17 ; v2(133.04,117.6) 133.09,117.55 UH1.AM3
  TOP w0.102: 194.21,21.17 v2(194.61,20.77)
  IN3 w0.127: v2(187.2,105.62) 187.2,103.8 188.53,102.47 188.53,98.24 191.59,95.19 191.59,88.34 192.38,87.55 192.38,84.63 194.23,82.78 194.23,80.71 193.97,80.46 193.6,80.46 v2(193.17,80.89)
  IN4 w0.089: 176.92,70.91 176.92,65.73 178.55,64.1 179.7,64.1 179.91,63.89 179.91,62.73 181.14,61.49 181.14,58.78 181.65,58.27 181.65,48.23 181.74,48.14 181.74,46.72 181.53,46.5 181.53,41.85 181.94,41.44 181.94,40.49 181.92,40.47 181.92,39.87 181.94,39.85 181.94,31.82 182.04,31.71 182.76,31 184.41,31 185.55,29.85 186.12,29.85 186.45,29.52 186.45,28.65 187.12,27.98 188.1,27.98 188.62,27.45 188.62,25.74 189.63,24.73 192.19,24.73 193.48,23.44 193.48,22.3 194.61,21.16 v2(194.61,20.77) ; 141.76,116.41 141.34,116.83 140.35,116.83 139.51,117.67 137.18,117.67 136.77,117.25 133.89,117.25 133.54,117.6 v2(133.04,117.6)
  IN4 w0.109: 141.76,116.41 141.79,116.37 145.79,116.37 145.98,116.57 148.86,116.57 149.59,115.84 150.71,115.84 151.22,115.32 152.68,115.32 153.18,114.83 154.4,114.83 154.56,114.98 154.9,114.98 155.05,114.83 160.56,114.83 160.81,115.08 162.74,115.08 163.11,114.7 164.46,114.7 164.98,114.18 170.12,114.18 170.97,113.34 171.47,113.34 171.74,113.07 171.74,112.57 172.15,112.15 173.33,112.15 174.66,110.82 174.66,110.29 175.25,109.71 176.26,109.71 176.27,109.72 179.77,109.72 181.16,108.32 181.47,108.32 182.03,107.76 182.03,107.39 181.81,107.16 181.81,106.82 182.06,106.57 184.69,106.57 184.87,106.39 186.44,106.39 v2(187.2,105.62) ; 176.92,70.91 176.66,71.16 176.66,75.15 176.96,75.45 176.96,75.59 177.2,75.83 177.34,75.83 179.99,78.49 179.99,78.8 181.18,79.99 192.32,79.99 193.22,80.89 v2(193.17,80.89)
H_SKTOCC#: length 10.2
  TOP w0.089: CPU1.BR33 195.03,24.38 195.03,21.73 195.29,21.48 195.29,20.74 195.57,20.46 195.79,20.46 196.05,20.21 196.05,19.79
  TOP w0.102: 196.05,19.79 v1(196.64,19.2) 198.89,16.95 RC319.2
H_THERMTRIP#: length 32
  TOP w0.089: v2(192.93,60.51) 192.93,60 193.22,59.71 CPU1.J31
  TOP w0.102: v2(215.81,70.71) 216.03,70.94 216.03,71.77 v1(215.69,72.11) 215.34,72.47 RC169.2
  IN3 w0.089: v2(192.93,60.51) 192.93,60.31 193.21,60.03 193.91,60.03 194.42,60.54 197.21,60.54 198.35,61.68 199.9,61.68
  IN3 w0.127: 199.9,61.68 202.8,61.68 207.89,66.77 211.83,66.77 215.81,70.74 v2(215.81,70.71)
H_VCCST_PWRGD_XDP: length 16.9
  TOP w0.102: v2(153.35,7.03) 153.35,7.03 153.86,6.52 JXDP1.39 ; v1(155.87,12.97) 156.48,12.97 v2(156.48,12.98) 156.48,13.54 RC124.2
  BOTTOM w0.102: v2(156.48,12.98) 156.48,12.99 156.05,12.56 155.61,12.56 154.46,13.71 152.93,13.71 151.32,12.1 151.32,10.83 152.82,9.33 152.82,7.56 v2(153.35,7.03)
HDA_BIT_CLK: length 10.9
  TOP w0.089: v2(131.62,121.69) 131.18,122.14 UH1.BA9 ; v2(136.86,125.08) 136.91,125.08 137.82,125.99 138.8,125.99 RH46.2
  BOTTOM w0.089: 132.29,121.54 131.78,121.54 v2(131.62,121.69) ; v2(136.86,125.08) 136.26,124.48 135.69,124.48
  BOTTOM w0.102: 135.69,124.48 135.36,124.16 135.36,122.83 134.65,122.12 v1(132.87,122.12) 132.29,121.54
HDA_BIT_CLK_R: length 264.3
  TOP w0.102: JIO1.73 v1(316.68,30.3) 316.89,30.3 v2(317.35,30.76) ; v2(142.29,125.55) 141.92,125.92 140.11,125.92 RH46.1
  IN1 w0.109: v2(142.29,125.55) 142.48,125.36 142.53,125.36 142.93,124.96 146.83,124.96 147.65,125.78 148.54,125.78 149.98,127.23 150.81,127.23 151.56,127.98 155.73,127.98 156.45,128.7 156.45,128.7 157.72,129.97 157.72,130.58 158.79,131.66 158.86,131.66 v2(158.98,131.78) ; v2(219.2,108.06) 219.56,108.41 219.75,108.41 220.63,107.54 220.78,107.54 220.95,107.71 221.11,107.71 221.26,107.56 221.26,107.4 221.09,107.23 221.09,107.08 221.24,106.92 221.4,106.92 221.57,107.09 221.72,107.09 221.88,106.94 221.88,106.79 221.71,106.61 221.71,106.46 221.97,106.19 221.97,105.5 222.37,105.1 223.26,105.1 223.89,105.72 223.99,105.72 224.2,105.52 224.2,105.41 223.55,104.77 223.55,104.61 224.5,103.67 224.52,103.67 228.79,99.4 228.79,96.87 230.79,94.86 232.08,94.86 233.91,93.04 233.91,91.57 236.5,88.99 236.5,87.16 238.95,84.71 238.95,84.32 244.23,79.04 244.23,78.21 244.64,77.79 244.64,76.29 248.72,72.22 248.72,62.13 252.38,58.47 257.02,58.47 264.4,51.08 265.91,51.08 274.49,42.49 279.66,42.49 281.97,40.17 285.72,40.17 288.75,37.14 291.38,37.14 291.86,37.61 296.04,37.61 297.43,36.23 299.11,36.23 303.98,31.36 304.61,31.36 305.37,30.6 307.39,30.6 307.5,30.49 307.5,30.3 307.61,30.19 307.83,30.19 307.94,30.3 307.94,30.49 308.05,30.6 308.66,30.6 308.77,30.71 308.77,31.21 308.85,31.29 309.13,31.29 309.21,31.21 309.21,29.92 309.28,29.85 309.57,29.85 309.65,29.92 309.65,31.21 309.72,31.29 310.01,31.29 310.08,31.21 310.08,30.16 310.16,30.08 310.44,30.08 310.52,30.16 310.52,31.21 310.6,31.29 310.88,31.29 310.96,31.21 310.96,29.92 311.03,29.85 311.32,29.85 311.39,29.92 311.39,31.08 311.47,31.16 311.75,31.16 311.83,31.08 311.83,30.24 312.02,30.06 313.86,30.06 314.81,29.1 315.38,29.1 315.49,28.99 315.49,28.54 315.6,28.43 315.82,28.43 315.93,28.54 315.93,28.99 316.03,29.1 316.72,29.1 317.03,29.42 317.03,29.99 317.35,30.31 v2(317.35,30.76)
  IN3 w0.127: v2(215.6,127.43) 215.82,127.22 215.82,123.79 216.34,123.27 216.34,117.16 216.13,116.95 216.13,115.35 216.3,115.19 216.3,114.33 217.1,113.53 217.1,112.81 218.08,111.83 218.08,110.96 219.2,109.83 v2(219.2,108.06)
  IN4 w0.109: v2(215.6,127.43) 214.85,127.43 212.71,129.57 196.58,129.57 196.54,129.61 194.71,129.61 194.56,129.46 189.46,129.46 189.22,129.22 187.85,129.22 186.71,128.09 173.01,128.09 172.43,128.67 170.45,128.67 169.52,129.59 165.25,129.59 163.06,131.78 v2(158.98,131.78)
  BOTTOM w0.102: CH268.2 142.29,125.01 v2(142.29,125.55)
HDA_RST#: length 20.6
  TOP w0.089: 133.15,126.2 133.14,126.19 132.77,126.19 132.25,125.67 131.7,125.67 131.44,125.41 131.44,125.03 131.59,124.88 131.59,124.4 131.63,124.37 131.63,124.07 131.44,123.88 131.44,123.87 131.39,123.82 UH1.BD8
  TOP w0.102: 133.15,126.2 134,127.05 139.2,127.05 139.53,127.38 139.53,128.98 141.12,130.58 144.11,130.58 RH50.2 144.57,131.02 145.04,130.55 146.19,130.55 v1(146.41,130.77)
HDA_RST#_R: length 254.4
  TOP w0.102: JIO1.81 317.45,28.3 v2(317.75,28.61) ; RH50.1 145.9,131.45 145.9,132.03 148.33,134.45 153.64,134.45 154.01,134.08 156.45,134.08 157.99,135.62 157.99,136.13 158.03,136.17 158.54,136.69 160.83,136.69 162.38,138.23 171.06,138.23 173.19,140.37 173.19,141.61 174.32,142.73 180.4,142.73 180.5,142.83 182.29,142.83 182.39,142.73 184.93,142.73 185.11,142.55 188.77,142.55 189.09,142.87 192,142.87 193.06,141.81 202.35,141.81 206.09,138.07 206.09,136.58 v1(207.63,135.04) 208.81,133.86 208.81,130.1 209.08,129.82 209.08,126.13 214.29,120.93 214.29,120.75 215.4,119.64 215.4,117.08 215.87,116.61 215.87,116.23 216.67,115.43 216.67,111.25 v2(216.96,110.95)
  IN1 w0.109: v2(216.96,110.95) 217.34,110.57 218.44,110.57 219.11,109.91 219.11,108.93 218.14,107.96 218.14,107.55 218.43,107.26 218.75,107.26 219.11,106.89 219.68,106.89 220.94,105.64 220.94,105.33 222.02,104.24 222.72,104.24 224.91,102.05 224.91,101.53 225.79,100.65 226.33,100.65 227.78,99.21 227.78,95.19 230.95,92.01 232.16,92.01 235.65,88.53 235.65,86.81 238.1,84.35 238.1,83.96 242.69,79.37 242.69,78.46 243.37,77.78 243.37,76.36 247.33,72.4 247.33,62.31 252.03,57.61 256.66,57.61 264.58,49.69 266.09,49.69 274.14,41.64 279.3,41.64 281.62,39.32 285.36,39.32 288.4,36.28 291.75,36.28 292.23,36.76 294.25,36.76 298.66,32.34 299.59,32.34 304.96,26.97 312.2,26.97 312.41,27.18 315.94,27.18 316.32,27.56 316.71,27.56 v2(317.75,28.61)
HDA_SDIN0: length 271.3
  TOP w0.089: 133.48,126.2 133.23,125.96 132.97,125.96 132.34,125.33 132.34,124.68 131.89,124.23 131.89,124.23 UH1.BE7
  TOP w0.102: v2(143.51,129.8) 143.51,129.39 143.25,129.13 142.8,129.13 141.93,128.26 141.93,127.49 141.26,126.82 134.1,126.82 133.48,126.2 ; v2(316.46,29.55) 316.21,29.8 JIO1.75 ; v2(157.59,133.37) 158.28,133.37 v1(159.8,134.88) 162.67,137.75 171.23,137.75 173.65,140.18 173.65,141.42 174.5,142.27 180.59,142.27 180.69,142.37 182.1,142.37 182.38,142.09 188.96,142.09 189.28,142.41 191.81,142.41 192.87,141.35 202.16,141.35 205.63,137.88 205.63,133.59 205.29,133.24 205.29,125.62 206.5,124.41 206.5,122.11 207.76,120.85 207.76,119.87 208.77,118.87 208.77,117.3 209.05,117.02 209.05,115.45 210.18,114.31 210.18,111.67 210.37,111.48 v2(210.37,110.37)
  IN1 w0.109: v2(316.46,29.55) 315.32,30.69 313.09,30.69 311.88,31.9 309.84,31.9 308.83,31.9 308.1,32.63 303.58,32.63 299.36,36.84 297.69,36.84 296.11,38.42 290.97,38.42 290.88,38.52 288.63,38.52 286.36,40.79 282.23,40.79 279.91,43.11 274.75,43.11 266.16,51.7 264.66,51.7 257.27,59.08 252.64,59.08 249.34,62.39 249.34,72.48 245.41,76.4 245.41,78.74 239.57,84.57 239.57,86.06 237.47,88.16 237.47,89 234.55,91.92 234.55,93.27 232.34,95.48 231.05,95.48 229.4,97.13 229.4,99.93 225.29,104.04 225.29,105.3 224.21,106.38 223.46,106.38 218.88,110.96 217.64,110.96 217.12,111.48 216.35,111.48 214.17,109.3 212.45,109.3 211.82,109.94 210.8,109.94 v2(210.37,110.37) ; v2(143.51,129.8) 143.69,129.97 148.11,129.97 148.2,130.07 149.19,130.07 149.75,130.63 151.36,130.63 151.95,130.04 155.02,130.04 155.75,130.78 155.75,131.62 155.76,131.63 155.75,131.63 155.75,131.84 155.66,131.93 155.66,132.27 156.2,132.82 157.04,132.82 v2(157.59,133.37)
HDA_SDOUT: length 21.5
  TOP w0.089: v2(136.25,125.05) 136.25,125.07 136.94,125.76 136.94,126.2 ; UH1.BB7 131.84,122.34 v2(132.19,121.99)
  TOP w0.102: RH45.2 RH328.2 144.28,128.9 142.9,128.9 142.26,128.26 142.26,127.5 141.36,126.6 137.14,126.6 136.94,126.4 136.94,126.2
  BOTTOM w0.102: v2(132.19,121.99) 131.93,122.25 131.93,123.01 131.61,123.33 131.61,124.55 131.46,124.7 131.46,125.21 131.75,125.5 132.78,125.5 133.29,124.99 134.34,124.99 134.54,125.18 v1(134.54,125.43) 134.73,125.62 135.17,125.62 135.74,125.05 v2(136.25,125.05)
HDA_SDOUT_R: length 258.5
  TOP w0.102: RH45.1 146.35,130.07 146.92,130.64 146.92,131.52 149.33,133.93 151.19,133.93 151.49,134.23 153.53,134.23 153.91,133.85 156.54,133.85 158.22,135.53 158.22,136.04 158.41,136.23 158.64,136.46 160.93,136.46 162.48,138.01 171.16,138.01 173.42,140.27 173.42,141.51 174.41,142.5 180.5,142.5 180.6,142.6 182.2,142.6 182.3,142.5 184.83,142.5 185.01,142.32 188.86,142.32 189.18,142.64 191.91,142.64 192.97,141.58 202.25,141.58 205.86,137.97 205.86,135.74 206.89,134.72 206.89,133.93 v1(207.85,132.96) 208.58,132.24 208.58,129.97 208.86,129.69 208.86,125.62 210.93,123.55 210.93,119.95 211.68,119.2 211.68,119.07 211.98,118.77 213.99,118.77 215.17,117.59 215.17,116.99 215.64,116.52 215.64,116.14 216.12,115.66 216.44,115.34 216.44,110.4 216.29,110.25 216.29,108.74 217.29,107.74 218.56,107.74 v2(218.59,107.77) ; JIO1.77 316,29.3 316.27,29.03 316.52,29.03 317.97,30.48 v2(317.97,30.87)
  IN1 w0.109: v2(218.59,107.77) 218.95,107.41 219.29,107.41 219.58,107.13 219.78,107.13 221.18,105.73 221.18,105.42 222.12,104.48 222.82,104.48 225.14,102.15 225.14,101.63 225.88,100.89 226.43,100.89 228.17,99.14 228.17,96.62 230.64,94.14 231.93,94.14 233.26,92.82 233.26,91.35 235.88,88.73 235.88,86.9 238.33,84.45 238.33,84.06 243.61,78.79 243.61,76.45 247.57,72.5 247.57,62.41 252.13,57.85 256.76,57.85 264.68,49.93 266.18,49.93 274.24,41.87 279.4,41.87 281.72,39.56 285.46,39.56 288.5,36.52 291.65,36.52 292.13,37 295.79,37 297.33,35.45 298.52,35.45 302.89,31.09 302.89,30.27 304.27,28.88 304.81,28.88 305.51,29.58 307.94,29.58 308.28,29.23 311.29,29.23 312.71,27.82 316.3,27.82 317.97,29.48 v2(317.97,30.87)
HDA_SYNC: length 19.4
  TOP w0.089: 132.4,126.2 132.05,125.85 131.64,125.85 131.27,125.48 131.27,124.96 131.42,124.81 131.42,124.33 131.46,124.3 131.46,124.14 130.92,123.6 UH1.BD9
  TOP w0.102: RH48.2 144.56,132.02 v1(143.55,131.02) 143.34,130.8 141.03,130.8 139.72,129.5 138.78,129.5 138.43,129.15 138.43,127.53 138.19,127.28 133.91,127.28 133.09,126.46 132.66,126.46 132.4,126.2
HDA_SYNC_R: length 257.4
  TOP w0.102: RH48.1 145.47,132.43 148.54,135.5 151.83,135.5 152.58,134.75 153.78,134.75 154.22,134.31 156.35,134.31 157.76,135.72 157.76,136.23 158.35,136.81 158.35,137.04 159.77,138.46 170.97,138.46 172.97,140.46 172.97,141.7 174.88,143.62 177.21,143.62 177.77,143.06 182.39,143.06 182.45,143 184.99,143 185.2,142.78 188.67,142.78 188.99,143.1 192.1,143.1 193.16,142.04 202.44,142.04 206.32,138.16 206.32,137.11 v1(206.76,136.67) 209.03,134.4 209.03,130.2 210.01,129.22 210.01,125.53 214.76,120.78 214.76,120.6 215.62,119.74 215.62,117.18 216.09,116.71 216.09,116.33 216.89,115.53 216.89,113.76 217.44,113.22 217.44,111.74 v2(217.66,111.53) ; JIO1.79 316.61,28.8 318.38,30.56 318.38,31.04 317.94,31.47 v2(317.94,32.94)
  IN1 w0.109: v2(317.94,32.94) 317.37,32.37 315.73,32.37 314.1,34 312.86,34 311.98,33.12 309.33,33.12 307.08,35.38 302.55,35.38 299.74,38.19 299.74,39.03 299.16,39.6 297.32,39.6 296.68,40.24 291.1,40.24 290.61,40.72 289.26,40.72 287.51,42.48 282.93,42.48 280.61,44.8 275.45,44.8 266.57,53.68 265.07,53.68 256.76,61.99 256.76,64.93 251.03,70.66 251.03,73.17 248.01,76.19 248.01,78.57 241.47,85.11 241.47,86.76 240.5,87.73 240.5,90.42 238.98,91.94 238.28,91.94 237.78,92.44 237.78,94.09 239.71,96.02 239.71,99.24 237.04,101.91 233.82,101.91 232.31,103.43 231.79,103.43 229.4,105.81 226.17,105.81 223.8,108.17 223.8,109.36 223.37,109.79 220.42,109.79 218.76,111.45 217.73,111.45 v2(217.66,111.53)
HDD_DET#: length 187.2
  TOP w0.089: UH1.AG39 v2(116.18,115.33)
  TOP w0.102: RH324.2 38.69,21.53 38.41,21.81 v1(38.16,21.81) 37.82,21.81 36.5,20.49 36.5,19.68 36.28,19.45 35.89,19.45 35.62,19.73 35.62,20.16 35.12,20.66 v2(35.09,20.66)
  IN1 w0.089: 112.37,114.25 112.37,114.26 112.88,114.26 113.95,115.33 v2(116.18,115.33)
  IN1 w0.109: v2(102.29,112.45) 102.53,112.45 103.28,113.2 106.2,113.2 106.93,112.48 110.6,112.48 112.37,114.25
  IN2 w0.127: v2(35.09,20.66) 35.64,21.2 35.64,22.5 34.61,23.52 34.61,24.33 32.77,26.18 32.77,27.25 32.67,27.35 32.67,30.17 31.93,30.9 31.93,33.32 30.07,35.17 27.73,35.17 24.64,38.26 24.64,46.22 23.55,47.31 23.55,51.52 26.22,54.19 26.22,61.78 28.68,64.24 54.67,64.24 56.64,62.27 76.66,62.27 84.27,69.88 84.27,78.46 91.71,85.91 91.71,97.28 97.38,102.95 98.18,102.95 98.78,103.56 98.78,104.96 99.67,105.85 99.67,109.18 102.29,111.8 v2(102.29,112.45)
  BOTTOM w0.102: v2(35.09,20.66) 34.55,20.11 JSATA2.20
HDD_FALL_INT: length 177.5
  TOP w0.089: v2(127.49,120.74) 127.42,120.74 126.95,121.2 UH1.AW17
  TOP w0.102: v2(95.03,104.92) 95.63,104.92 96.31,105.6 96.82,105.6 97.79,106.57 98.66,106.57 v2(99.14,107.06) ; v2(9.31,45.87) R503.2
  TOP w0.254: R503.2 6.11,45.18 U88.12
  IN2 w0.127: v2(9.31,45.87) 11.11,45.87 13.78,48.53 17.68,48.53 24.19,55.04 24.19,62.62 27.84,66.28 54.44,66.28 54.87,66.71 56.1,66.71 58.51,64.3 74.02,64.3 82.49,72.78 82.49,82.2 89.68,89.39 89.68,99.92 94.55,104.79 94.89,104.79 v2(95.03,104.92)
  BOTTOM w0.089: 112.37,112.05 112.93,112.05 113.83,111.15 114.6,111.15 114.98,111.53 119.36,111.53 119.61,111.78 119.61,113.3 120.5,114.19 120.5,116.48 121.39,117.37 122.28,117.37 124.13,119.22 124.13,119.92 124.84,120.63 124.84,120.88 125.05,121.1 125.6,121.1 126.09,120.61 127.36,120.61 v2(127.49,120.74)
  BOTTOM w0.102: v2(99.14,107.06) 99.43,106.76 v1(100.18,106.76) 102.02,106.76 102.58,107.32 102.58,108.9 103.88,110.19 106.54,110.19 106.81,110.47 106.81,110.92 107.94,112.05 112.37,112.05
HDD_IFDET: length 56.6
  TOP w0.102: v2(11.49,51.41) U6.2 9.3,51.41 9,51.71 9,52.95 R317.1
  IN3 w0.127: v2(11.49,51.41) 11.03,50.95 11.03,39.2 9.5,37.68 9.5,33.47 13.68,29.29 17.94,29.29 18.95,28.28 18.95,27.22 19.92,26.26 19.92,25.16 20.72,24.35 22.32,24.35 24.3,22.37 24.9,22.37 25.53,21.74 33.7,21.74 34.52,20.91 34.52,20.59 v2(35.16,19.96)
  BOTTOM w0.102: v2(35.16,19.96) 35.05,19.85 JSATA2.19
HOST_DEBUG_TX: length 32.8
  IN3 w0.127: v2(197.07,111.89) 198.01,110.95 198.01,110.59 197.49,110.07 195.62,110.07 195.3,109.75 195.3,108.78 194.29,107.76 194.29,107.18 193.81,106.7 193.41,106.7 v2(192.13,105.42)
  BOTTOM w0.102: v2(197.07,111.89) 196.85,111.89 196.57,111.61 U51.B44 ; v2(192.13,105.42) 190.77,104.06 190,104.06 189.27,103.33 185.37,103.33 185.09,103.62 183.48,103.62 183.01,103.14 181.52,103.14 181.16,102.79 JDEG2.8 181.16,101.13 180.92,100.88 180.92,100.52 180.45,100.05 180.45,95.33 R848.2
HOST_SD_WP#: length 287.3
  TOP w0.089: UH1.AU44 113.56,120.02 113.05,120.52 112.62,120.52 112.54,120.61
  TOP w0.102: v2(317.32,34.23) 317.54,34.01 v1(317.54,32) 317.54,31.6 316.74,30.8 JIO1.71 ; 112.54,120.61 111.91,120.61 v2(111.79,120.72)
  IN2 w0.089: 141.76,115.53 141.52,115.29 138.26,115.29 135.4,118.15 131.74,118.15 131.69,118.1 129.62,118.1 129.49,118.23 120.08,118.23 119.27,119.05 117.77,119.05 117.61,119.21 117.33,119.21 116.3,120.24 115.18,120.24 114.68,119.74 114.32,119.74 113.45,120.61 112.37,120.61
  IN2 w0.127: v2(111.79,120.72) 111.91,120.61 112.37,120.61 ; 141.76,115.53 154.73,115.53 155.31,116.1 162.46,116.1 163,115.57 164.64,115.57 165.41,116.34 168.31,116.34 172.24,120.28 178.6,120.28 180.14,121.81 183.81,121.81 184.33,122.33 187.34,122.33 188.17,123.16 188.97,123.16 189.73,123.91 189.94,123.91 190.38,124.35 191.6,124.35 191.89,124.65 193.4,124.65 194.15,125.39 195.97,125.39 197.05,126.48 199.06,126.48 199.44,126.1 199.44,125.93 199.76,125.6 200.25,125.6 201.31,126.66 207.08,126.66 207.27,126.47 215.6,126.47 216.02,126.9 220.32,126.9 220.87,126.35 223.5,126.35 226.7,123.15 226.7,118.95 228.02,117.62 229.05,117.62 231.75,114.91 231.75,110.42 234.12,108.05 234.12,104.4 232.2,102.48 231.56,102.48 229.11,100.03 229.11,97.54 228.68,97.11 228.68,93.6 232.4,89.87 236.55,89.87 241.75,84.67 241.75,83.65 246.46,78.95 246.46,78 247.18,77.27 250.11,77.27 257.34,70.04 257.34,67.82 259.33,65.83 259.33,64.09 277.11,46.32 279.53,46.32 283.36,42.5 288.9,42.5 291.24,40.15 292.71,40.15 297,35.86 300.17,35.86 300.8,35.22 304.16,35.22 304.62,35.68 308.5,35.68 308.64,35.54 308.64,35.02 310.3,33.36 311.09,33.36 312.37,34.64 316.92,34.64 v2(317.32,34.23)
HSYNC_DOCK: length 77.1
  TOP w0.102: JMXM1.192 172.75,80.52 172.84,80.61 172.84,80.68 173.08,80.92 173.08,81.15 173.87,81.94 174.22,81.94 176.52,84.24 176.52,85.48 v2(177.39,86.34)
  IN3 w0.127: v2(172.63,145.64) 172.78,145.49 172.78,145.06 173.88,143.96 173.88,136.39 174.82,135.45 174.82,135.03 174.83,135.02 174.83,133.1 174.77,133.04 174.77,131.21 174.2,130.64 174.2,128.09 174.66,127.62 174.66,124.69 175.25,124.1 175.25,121.03 176.71,119.57 176.71,116.4 177.65,115.46 177.65,114.75 177.94,114.46 177.94,114.08 177.8,113.94 177.8,110.09 178.58,109.32 178.58,108.19 178.49,108.1 178.49,104.96 178.48,104.95 178.48,103.82 178.58,103.72 178.58,103.54 180.59,101.53 180.59,99.6 179.9,98.91 179.9,94.51 178.62,93.23 178.62,91.35 178.43,91.16 178.43,87.79 177.79,87.15 177.79,86.75 v2(177.39,86.34)
  BOTTOM w0.102: JDOCK1.65 174.75,146.92 174.47,146.64 173.86,146.64 173.63,146.64 v2(172.63,145.64)
HW_GPS_DISABLE#: length 191.3
  TOP w0.102: R779.2 182.13,105.08 181.72,104.67 v2(181.72,104.58) ; DZ2.1 320.39,29.48 320.79,29.09 v1(320.79,28.35) 320.63,28.2 v2(319.79,28.2)
  IN2 w0.127: v2(319.79,28.2) 318.83,27.23 318.16,27.23 317.45,27.93 313.36,27.93 311.26,25.83 304.35,25.83 303.58,26.59 297.88,26.59 297.22,25.92 292.4,25.92 289.79,28.54 289.79,30.46 288.85,31.4 288.85,33.71 284.86,37.71 280.62,37.71 280.27,38.06 280.27,38.93 277.73,41.48 275.13,41.48 258.53,58.08 251.69,58.08 248.96,60.8 248.96,65.91 249.53,66.48 249.53,70.59 247.84,72.28 245.45,72.28 244.67,73.06 243.42,73.06 240.59,75.89 240.59,76.45 237.45,79.6 221.37,79.6 217.67,83.29 210.48,83.29 205.91,87.87 205.91,93.29 203.01,96.18 202.64,96.18 202.46,96.36 201.43,96.36 200.49,97.3 199,97.3 198.45,97.85 196.89,97.85 196.37,97.33 193.79,97.33 192.17,98.95 186.5,98.95 185.55,99.91 185.15,99.91 182.95,102.11 182.95,103.34 v2(181.72,104.58)
  BOTTOM w0.102: v2(181.72,104.58) 182.05,104.91 182.05,105.31 U46.A35
HW_GPS_DISABLE#_R: length 2
  TOP w0.102: DZ2.2 v2(322.16,29.48)
  BOTTOM w0.102: v2(322.16,29.48) 321.97,29.68 JNGFF2.18
I2C_1_SCL: length 297.5
  TOP w0.089: UH1.AR41 115.08,119.28 114.66,119.7 114.51,119.7 114.32,119.52 114.32,119.33 114.18,119.18 113.56,119.18 113.34,119.4 112.37,119.4
  TOP w0.102: v2(110.79,120.92) 110.79,120.78 112.17,119.4 112.37,119.4 ; R3758.1 RZ37.2 295.7,43.2 295.7,43.52 295.47,43.75 292.68,43.75 291.3,42.37 v2(291.3,40.69)
  IN1 w0.109: v2(110.79,120.92) 110.79,121.83 113.32,124.36 114.38,124.36 114.65,124.63 114.65,125.09 115.43,125.87 116.44,125.87 118.15,127.59 123.87,127.59 124.25,127.97 126.64,127.97 128.08,129.41 128.36,129.41 132.03,133.08 132.03,135.82 132.6,136.39 134.51,136.39 135.49,135.41 142.58,135.41 143.49,136.32 146.13,136.32 146.85,137.03 150.38,137.03 157.31,143.97 v2(159.11,143.97)
  IN4 w0.109: v2(240.26,115.67) 239.86,116.07 239.86,116.47 240.34,116.95 240.34,122.78 239.65,123.47 239.65,124.86 227.14,137.37 218.04,137.37 211.14,144.27 206.15,144.27 204.77,142.88 191.05,142.88 189.32,144.61 189.32,145.89 188.89,146.32 182.67,146.32 181.08,147.91 176,147.91 174.17,149.74 170.93,149.74 169.05,147.87 163.45,147.87 161.87,146.29 160.4,146.29 159.69,145.58 159.69,144.24 159.42,143.97 v2(159.11,143.97)
  BOTTOM w0.102: v2(291.3,40.69) 291.09,40.9 282.52,40.9 280.55,42.87 274.4,42.87 v1(273.38,43.89) 264.48,52.79 264.48,54.22 260.21,58.49 256.77,58.49 256.35,58.07 251.22,58.07 247.93,61.35 247.93,66.47 249.33,67.87 249.33,78.57 245.83,82.08 245.83,88.35 245.58,88.59 245.58,90.03 247.56,92.02 248.08,92.02 248.37,92.31 248.37,93.2 250.08,94.91 250.08,101.08 248.61,102.55 248.61,103.65 247.28,104.98 247.12,104.98 243.87,108.23 241.88,110.22 241.3,110.8 241.3,114.62 v2(240.26,115.67)
I2C_1_SCL_R: length 11.8
  TOP w0.102: R3758.2 294.87,39.78 RZ117.2 294.86,39.57 295.19,39.24 v1(296.94,39.24) 297.31,38.87 297.31,37.54 296.93,37.15 293.98,37.15 293.83,37 293.83,35.2 294.18,34.85 JKBTP1.2
I2C_1_SDA: length 292.1
  TOP w0.089: UH1.AR44 113.54,118.87 113.24,119.17 112.37,119.17
  TOP w0.102: v2(110.21,121.13) 110.21,119.45 110.5,119.17 112.37,119.17 ; v2(292.57,40.73) 293.38,41.54 R3752.1 RZ36.2
  IN1 w0.109: v2(110.21,121.13) 110.21,121.59 113.22,124.6 114.12,124.6 114.42,124.9 114.42,125.19 115.43,126.2 116.33,126.2 118.07,127.95 123.64,127.95 123.91,128.22 126.56,128.22 130.37,132.04 130.65,132.04 131.79,133.18 131.79,135.92 133.19,137.31 133.92,137.31 135.59,135.65 142.49,135.65 143.5,136.66 146.14,136.66 146.75,137.27 150.28,137.27 157.39,144.37 158.88,144.37 v2(159.11,144.61)
  IN4 w0.109: v2(159.11,144.61) 159.15,144.61 159.35,144.81 159.35,145.58 160.3,146.52 161.78,146.52 163.36,148.1 168.95,148.1 170.86,150.01 174.44,150.01 175.89,148.56 180.9,148.56 181.67,147.79 181.67,147.76 182.11,147.32 182.14,147.32 182.88,146.58 188.97,146.58 189.55,145.99 189.55,144.84 191.27,143.12 204.67,143.12 206.05,144.5 211.24,144.5 218.14,137.61 227.24,137.61 239.89,124.95 239.89,123.57 240.57,122.88 240.57,116.56 v2(240.33,116.31)
  BOTTOM w0.102: v2(240.33,116.31) 241.53,115.11 241.53,110.89 242.05,110.38 246.33,106.09 246.49,106.09 248.19,104.4 248.9,103.68 248.9,102.58 250.31,101.17 250.31,94.82 248.59,93.1 248.59,92.21 248.17,91.79 247.67,91.79 245.81,89.93 245.81,88.69 246.57,87.92 246.57,81.65 249.56,78.67 249.56,67.78 248.16,66.38 248.16,61.45 251.31,58.3 256.26,58.3 256.68,58.72 260.3,58.72 264.71,54.32 264.71,53.07 v1(271.99,45.78) 274.63,43.15 280.6,43.15 282.58,41.17 292.13,41.17 v2(292.57,40.73)
I2C_1_SDA_R: length 12.9
  TOP w0.102: R3752.2 RZ116.2 293.93,39.59 294.54,38.98 296.44,38.98 296.98,38.44 v1(296.98,37.87) 296.98,37.67 296.69,37.38 293.89,37.38 293.6,37.1 293.6,35.24 292.72,34.35 JKBTP1.3
I_ADP: length 108.7
  TOP w0.254: PR716.1 269.92,38.91 v2(270.1,39.1)
  IN1 w0.109: v2(270.1,39.1) 267.58,39.1 265.45,41.22 265.45,43.13 263.71,44.87 262.85,44.87 261.03,46.69 260.43,46.69 254.98,52.15 254.98,52.43 253.18,54.23 252.11,54.23 244.91,61.43 244.91,71.23 240.2,75.93 240.2,77.28 236.55,80.93 229.47,80.93 227.46,82.94 227.46,85.29 224.72,88.02 224.72,97.64 216.32,106.05 216.32,107.8 215.74,108.39 211.22,108.39 210.43,109.18 209.78,109.18 v2(209.63,109.32)
  BOTTOM w0.102: v1(209.33,107.38) 208.88,107.83 R134.1 208.98,108.66 209.63,109.32 v2(209.63,109.32)
I_ADP_R: length 2.3
  BOTTOM w0.102: R134.2 207.39,109.24 207.16,109.24 207.04,109.36 v1(206.91,109.36) U51.A12
I_BATT: length 125.9
  TOP w0.254: PR726.1 v2(267.87,35.2)
  IN1 w0.109: v2(267.87,35.2) 264.95,38.12 264.95,42.97 263.91,44 262.17,44 259.98,46.19 259.98,46.32 254.46,51.84 251.08,51.84 249.15,53.76 249.15,56.41 244.43,61.13 244.43,68.77 239.65,73.56 239.65,77.16 236.35,80.46 229.27,80.46 226.98,82.75 226.98,85.1 224.25,87.83 224.25,96.83 219.86,101.22 219.54,101.22 218.26,102.51 218.26,102.55 217.42,103.39 217.09,103.39 216.85,103.63 216.85,104.5 215.27,106.08 215.27,106.85 215.92,107.5 v2(215.91,107.5)
  IN2 w0.127: v2(215.91,107.5) 215.92,107.5 215.94,107.53 215.94,108.11 215.43,108.62 215.43,110.31 215.58,110.45 215.58,112.53 215.33,112.77 212.99,112.77 211.86,113.9 209.92,113.9 209.76,113.74 209.41,113.74 208.22,114.93 205.21,114.93 204.62,115.52 202.71,115.52 201.61,114.41 v2(200.76,114.41)
  BOTTOM w0.102: v2(200.76,114.41) 200.77,114.41 200.77,114.45 200.8,114.45 201,114.65 U51.B61
ILIM_3PH_A: length 2.3
  TOP w0.203: PR1138.2 256.95,50.24 256.95,50.03 256.75,49.83 v1(256.75,49.47) 256.75,49.33 256.95,49.13 PU1100.7
ILIM_3PH_B: length 3.7
  TOP w0.203: PR1139.1 256.32,38.56 v1(256.32,40.63) 256.32,40.76 256.49,40.94 256.49,41.55 256.55,41.6 PU1100.32
ILMT_0.95V: length 3.3
  TOP w0.254: PR308.1 330.81,21.61 PR306.2 329.91,20.09 329.56,19.73 PU300.3
IMVP_VR_ON: length 365
  TOP w0.102: v2(56.43,3.7) PR1807.2 ; PR1198.2 263.69,43.64 v2(263.74,43.59) ; v2(218.93,98.25) 219.42,98.75 219.42,100.51 218.31,101.62 218.31,101.69 RC327.2 219.26,101.77 219.46,101.57 219.86,101.57 220.2,101.91 220.2,102.46 220.41,102.67 220.41,103.42 220.17,103.66 218.36,103.66 218.07,103.37 UC5.4 216.71,103.94 217.12,104.35 219.03,104.35 219.22,104.16 220.25,104.16 220.55,104.46 220.55,105.61 220.9,105.95 UC6.2 ; v2(75.19,3.89) PR507.2
  IN1 w0.109: v2(252.71,34.73) 252.71,35.51 257.41,40.21 257.41,46.1 253.15,50.37 249.87,50.37 249.76,50.48 245.94,50.48 245.94,50.47 245.75,50.47 242.44,53.78 242.44,65.53 241.22,66.76 240.87,66.76 239.7,67.93 239.7,68.64 236.61,71.73 236.61,72.18 231.45,77.34 226.42,77.34 219.66,84.09 219.66,97.52 v2(218.93,98.25) ; v2(241.79,4.51) 241.29,5.01 229.19,5.01 227.6,3.42 126.61,3.42 75.66,3.42 v2(75.19,3.89)
  IN3 w0.127: v2(259.46,30.45) 255.4,30.45 252.71,33.14 v2(252.71,34.73)
  IN4 w0.109: v2(259.46,30.45) 255.74,30.45 254.07,28.79 250.49,28.79 249.39,27.69 249.39,9.37 249.47,9.29 249.47,8.5 247.3,6.33 246.52,6.33 246.18,6.67 242.72,6.67 241.79,5.74 v2(241.79,4.51) ; v2(75.19,3.89) 74.43,4.66 56.94,4.66 56.43,4.15 v2(56.43,3.7)
  BOTTOM w0.102: v2(252.71,34.73) 252.71,35.51 252.91,35.71 258.61,35.71 258.66,35.65 259.2,35.65 v1(261.39,37.84) 261.94,38.39 261.94,42.8 262.73,43.59 v2(263.74,43.59)
IMVP_VR_ON_EC: length 29.3
  TOP w0.102: UC5.1 215.41,102.29 215.65,102.53 216.92,102.53 217.16,102.29 218,102.29 RC327.1 218.58,102.68 218.96,103.07 v2(219.88,103.07)
  IN1 w0.109: v2(215.88,109.35) 215.88,108.58 216.56,107.9 216.56,106.29 219.78,103.07 v2(219.88,103.07)
  IN4 w0.109: v2(206.16,115.4) 206.39,115.18 209.19,115.18 210.08,114.29 212.49,114.29 213.29,113.49 214.57,113.49 214.65,113.57 215.66,113.57 216.37,112.86 216.37,109.92 215.88,109.42 v2(215.88,109.35)
  BOTTOM w0.102: v2(206.16,115.4) 205.95,115.19 U51.A1
IRQ_SERIRQ: length 210.1
  TOP w0.089: UH1.BA17 126.95,121.87 126.36,121.28 v2(126.36,121.05)
  IN2 w0.089: v2(126.36,121.05) 126.66,121.35 126.66,122.95 127.24,123.53 128.63,123.53 129.46,124.35 130.28,124.35 130.89,124.96 131.76,124.96 v2(131.93,125.13) 131.93,125.37 132.76,126.2
  IN2 w0.127: v2(217.66,116.42) 217.37,116.14 215.67,116.14 215.47,116.34 211.09,116.34 210.29,117.13 209.99,117.13 209.8,117.32 205.51,117.32 204.77,116.57 197.87,116.57 197.14,117.3 197.14,117.48 196.89,117.73 195.96,117.73 195.45,117.22 192.92,117.22 192.4,116.7 192.4,115.23 191.91,114.74 191.21,114.74 190.29,113.81 190.29,113.14 189.51,112.36 188.48,112.36 186.54,114.3 184.74,114.3 183.71,113.26 v2(183.23,113.26) ; v2(216.66,133.5) 216.63,133.5 216.27,133.14 215.75,133.14 215.75,133.12 214.93,132.29 213.37,132.29 213.03,131.95 209.19,131.95 208.45,131.21 204.42,131.21 204.32,131.31 196.13,131.31 195.66,130.83 190.16,130.83 188.56,129.23 187.61,129.23 187.15,129.69 178.9,129.69 178.52,130.07 167.36,130.07 165.75,131.68 164.63,131.68 163.77,132.54 159.7,132.54 159.48,132.77 158.89,132.77 156.98,130.86 154.19,130.86 151.58,133.47 146.83,133.47 146.19,132.84 146.19,132.41 144.25,130.47 142.24,130.47 141.14,129.37 139.53,129.37 138.4,130.5 136.67,130.5 135.58,129.41 135.58,128.75 133.22,126.4 132.96,126.4 132.76,126.2 ; v2(219.66,102.02) 219.66,100.72 218.29,99.35 212.34,99.35 210.75,100.93 209.09,100.93 208.5,101.52 203.6,101.52 202.67,102.45 201.65,102.45 201.18,102.92 200.63,102.92 200.5,102.92 199.64,103.78 198.33,103.78 197.87,104.24 197.87,104.59 198.23,104.95 v2(198.53,104.95)
  IN3 w0.127: v2(219.66,102.02) 220.66,103.02 220.66,104.66 220.37,104.94 220.37,106.12 219.88,106.61 219.88,107.28 220.37,107.77 220.37,110.27 220.25,110.4 220.25,111.28 218.24,113.29 218.24,115.09 217.7,115.64 217.7,116.38 v2(217.66,116.42) 217.66,116.92 218.08,117.34 218.08,120.53 218.08,121.16 217.56,121.68 217.56,123.49 217.7,123.63 217.7,124.57 217.11,125.15 217.11,128.75 216.45,129.41 216.45,133.32 216.63,133.5 v2(216.66,133.5)
  BOTTOM w0.089: v2(131.93,125.13) 131.93,125.14 131.92,125.13 131.92,123.79 132.2,123.51 RH340.1
  BOTTOM w0.102: U51.A28 198.75,105.07 198.64,104.95 v2(198.53,104.95) ; U46.B21 v2(183.23,113.26)
ITP_PMODE_CPU: length 141.3
  TOP w0.089: 137.71,121.15 136.32,121.15 135.86,120.69 135.69,120.69 135.36,120.36 134.8,120.36 134.26,119.82 UH1.AT2 ; 140.31,121.56 140.66,121.21 v2(140.66,119.72)
  TOP w0.102: 140.31,121.56 T192.1 138.09,121.15 137.71,121.15 ; RC144.2 159.59,16.15 158.78,16.96 158.78,18.07 146.92,29.92 146.92,59.6 156.64,69.31 157.64,69.31 161.83,73.5 161.83,74.74 v2(162.28,75.2)
  IN3 w0.089: v2(140.66,119.72) 140.85,119.53 140.85,118.47 141.38,117.94 141.38,115.96 141.14,115.72 141.14,113.68 139.18,111.73 139.18,108.14 141.15,106.18 141.15,105.49 141.76,104.88
  IN3 w0.127: v2(162.28,75.2) 162.04,75.2 161.59,75.65 157.08,75.65 151.62,81.11 150.74,81.11 143.49,88.36 143.49,88.84 142.51,89.82 142.51,96.47 144.25,98.21 144.25,102.39 141.76,104.88
JDIMM1_EVENT#: length 24.2
  TOP w0.102: v2(102.65,47.92) 102.87,48.15 RD3.1 ; v2(122.53,47.85) 122.53,48.1 122.72,48.29 123.52,48.29 123.66,48.43 JDIMM1.134
  IN2 w0.127: v2(102.65,47.92) 103.51,47.92 104.3,47.14 121.82,47.14 v2(122.53,47.85)
JDIMM2_EVENT#: length 39.6
  TOP w0.102: RD4.1 103.19,49.93 102.73,50.39 v2(102.73,50.54)
  IN2 w0.127: v2(135.42,47.8) 135.42,48.24 131.61,52.05 104.25,52.05 v2(102.73,50.54)
  BOTTOM w0.102: v2(135.42,47.8) 135.42,47.82 134.82,48.43 JDIMM2.134
JDIMM3_EVENT#: length 3.4
  TOP w0.102: RD5.1 v1(108.46,48.41) 109.64,48.41 109.66,48.43 JDIMM3.134
JDIMM4_EVENT#: length 23.1
  TOP w0.102: v2(102.7,49.25) 102.9,49.04 RD12.1
  IN2 w0.127: v2(121.04,47.82) 120.6,47.39 104.5,47.39 102.7,49.19 v2(102.7,49.25)
  BOTTOM w0.102: JDIMM4.134 119.56,48.43 120.25,47.73 120.95,47.73 v2(121.04,47.82)
JTAG_CLK: length 44.8
  IN3 w0.127: v2(199.05,114.37) 199.05,113.73 200.03,112.75 200.03,110.31 199.37,109.65 199.37,108.6 199.05,108.28 199.05,106.87 200.68,105.24 200.68,104.14 199.62,103.08 199.62,102 v2(199.56,101.94)
  BOTTOM w0.102: R860.2 184.1,93.3 184.38,93.58 184.38,93.59 185.3,94.51 185.3,95.05 184.13,96.22 184.13,98.99 183.16,99.96 JDEG2.4 183.16,102.43 183.74,103.01 184.84,103.01 185.12,102.72 188.61,102.72 188.7,102.63 190.66,102.63 192.3,101 v1(194.26,101) 199.26,101 199.56,101.3 v2(199.56,101.94) ; v2(199.05,114.37) 198.5,114.92 U51.B56
JTAG_RST#: length 16.7
  IN2 w0.127: v2(193.08,116.42) 193.91,115.59 198.19,115.59 198.37,115.41 198.37,114.84 198.06,114.53 v2(197.6,114.53)
  BOTTOM w0.102: v2(197.6,114.53) 197.6,114.52 197.71,114.4 197.71,113.47 197.46,113.22 196.36,113.22 196.25,113.11 U51.B47 ; JTAG1.1 R1981.2 R836.1 C735.1 v1(191.79,117.7) 191.79,117.2 192.57,116.42 v2(193.08,116.42)
JTAG_TDI: length 38.3
  IN2 w0.127: v2(197.76,117.27) 197.76,117.4 197.18,117.98 195.77,117.98 195.19,118.55 194.75,118.55 193.93,117.73 192.67,117.73 191.78,116.83 191.78,116.25 191.49,115.97 189.31,115.97 v2(187.41,114.07)
  IN3 w0.127: v2(187.41,114.07) 187.24,113.91 187.24,112.47 187.34,112.38 187.34,109.66 186.57,108.89 185.39,108.89 184.89,108.39 184.89,107.72 184.25,107.07 184.25,105.05 184.61,104.69 184.61,103.3 184.13,102.81 v2(184.13,102.6)
  BOTTOM w0.102: U51.A51 197.75,117.28 197.75,117.27 v2(197.76,117.27) ; v2(184.13,102.6) 184.13,102.27 184.16,102.23 JDEG2.2 184.16,101.33 185.4,100.1 185.4,97.26 186.48,96.18 186.48,94.25 187.02,93.71 R858.2
JTAG_TDO: length 71.4
  TOP w0.102: v2(211.37,105.49) 212.07,104.8 212.07,103.64 211.74,103.31 v2(210.98,103.31)
  IN1 w0.109: v2(211.37,105.49) 211.37,105.62 211.05,105.94 211.05,106.45 210.27,107.23 210.25,107.23 208.84,108.63 208.84,109.58 208.46,109.96 208.46,110.67 208.23,110.91 206.86,110.91 206.83,110.88 206.49,110.88 206.45,110.92 206,110.92 204.82,112.11 203.43,112.11 202.67,112.87 200.05,112.87 199.14,113.79 198.81,113.79 v2(198.62,113.97)
  IN3 w0.127: v2(210.98,103.31) 210.67,103 210.51,103 209.51,102.01 206.66,102.01 205.21,100.56 205.21,99.27 205.96,98.52 v2(205.96,97.63)
  BOTTOM w0.102: JDEG2.5 182.66,101.06 182.54,100.93 182.54,99.59 183.46,98.67 183.46,95.74 182.52,94.8 R861.2 182.52,94.61 182.97,94.15 182.97,93.44 183.24,93.17 183.24,91.37 183.71,90.9 200.82,90.9 202.16,92.23 202.16,92.61 202.78,93.24 203.16,93.24 204.3,94.37 204.3,95.94 v1(204.67,96.32) 205.96,97.61 v2(205.96,97.63) ; v2(198.62,113.97) 198.64,113.97 198.36,114.25 198.36,114.26 198.25,114.37 198.25,115.22 198,115.47 U51.B55
JTAG_TMS: length 74.7
  IN2 w0.127: v2(185.58,93.87) 186.07,94.36 186.69,94.36 187.09,93.97 187.09,93.38 188.13,92.34 188.13,89.2 185.81,86.87 185.81,86.29 186.48,85.62 200.61,85.62 v2(201.7,86.7)
  IN3 w0.127: v2(201.7,86.7) 203.15,88.15 203.15,91.92 203.47,92.24 203.47,93.51 201.54,95.44 201.54,98.75 200.83,99.46 200.83,103.39 201.52,104.08 201.52,105.3 200.11,106.71 200.11,109.47 200.97,110.34 200.97,112.7 199.72,113.95 199.72,114.57 199.65,114.65 199.65,115.9 198.67,116.87 198.67,117.49 199.09,117.91 v2(199.1,117.91)
  BOTTOM w0.102: R859.2 184.99,93.29 v2(185.58,93.87) 186.25,94.55 186.25,95.53 185.02,96.76 185.02,99.8 183.66,101.16 JDEG2.3 ; v2(199.1,117.91) 198.97,117.91 v1(198.68,117.62) 198.68,117.04 198.75,116.97 U51.A53
KB_DET#: length 273.8
  TOP w0.089: 125.12,126.2 125.12,124.43 124.61,123.92 UH1.BD22
  TOP w0.102: RC74.1 120.32,130.67 120.01,130.36 v2(120.01,129.9) ; 125.12,126.2 125.12,126.48 v2(125.21,126.56) ; JKBTP1.20 296.64,25.85 297.77,26.98 297.77,28.94 v2(296.46,30.25)
  IN2 w0.127: v2(250.04,90.51) 249.62,90.09 248.84,90.09 246.45,92.48 245.75,92.48 242.99,95.23 242.99,96.96 238.04,101.92 238.04,103.86 238.52,104.34 239.25,104.34 239.5,104.59 239.5,105.35 238.72,106.13 238.19,106.13 233.84,110.48 233.84,116.58 232.23,118.18 232.23,119.77 231.06,120.94 231.06,124.42 229.76,125.71 229.76,131.43 229.34,131.85 229.34,133.03 225.22,137.15 216.5,137.15 215.58,136.24 212.93,136.24 212.28,135.59 202.14,135.59 201.7,135.15 194.66,135.15 193.23,133.71 187.38,133.71 186.96,134.13 184.98,134.13 184.85,134.26 180.08,134.26 179.84,134.5 174.5,134.5 174.3,134.7 172.43,134.7 171.94,134.21 168.95,134.21 167.91,135.25 167.56,135.25 167.29,134.98 166,134.98 165.04,135.94 161.95,135.94 159.7,138.2 156.61,138.2 155.3,139.5 153.63,139.5 152.55,138.42 150.07,138.42 149.39,137.74 142.49,137.74 139.86,135.11 135.29,135.11 132.17,131.99 129.34,131.99 128.11,130.75 127.52,130.75 126.14,129.38 126.14,127.49 v2(125.21,126.56)
  IN3 w0.127: v2(250.04,90.51) 250.03,90.52 250.16,90.64 252.51,90.64 254.21,88.94 254.21,87.67 255.5,86.38 255.5,73.07 259.56,69.02 259.56,65.46 266.55,58.46 273.1,51.91 273.5,51.91 285.18,40.23 285.18,38.65 287.3,36.53 288.29,36.53 292.04,32.79 294.58,32.79 296.46,30.9 v2(296.46,30.25)
  IN4 w0.109: v2(125.21,126.56) 125.21,127.37 124.81,127.76 122.14,127.76 v2(120.01,129.9)
LAN_ACTLED_YEL#: length 3.8
  TOP w0.102: Q325.1 240.35,117.13 239.79,116.57 v1(239.59,116.57) 237.93,116.57 237.83,116.67 U32.17
LAN_ACTLED_YEL#_Q: length 37.8
  TOP w0.102: R1171.1 227.98,146.44 v2(227.93,146.39) ; Q325.6 240.35,119.08 240.39,119.04 240.39,119.02 240.4,119.02 240.4,118.35 239.92,117.88 239.56,117.88 v2(239.46,117.77)
  IN2 w0.127: v2(227.93,146.39) 228.58,145.74 228.58,140.94 240.9,128.62 240.9,118.96 239.82,117.88 239.57,117.88 v2(239.46,117.77)
LAN_DISABLE#_R: length 113.6
  TOP w0.102: R555.2 R557.1 R549.2 255.49,115.91 255.25,115.91 v2(254.74,115.4) 254.64,115.29 254.64,114.22 254.46,114.04 253.19,114.04 252.91,113.76 252.71,113.76 252.53,113.58 U31.3
  IN1 w0.109: v2(239.21,117.24) 239.37,117.24 239.37,117.18 239.46,117.09 242.9,117.09 244.42,115.56 248.49,115.56 248.71,115.78 249.53,115.78 249.92,115.4 v2(254.74,115.4) ; v2(178.67,122.99) 180.21,121.45 180.21,116.38 179.24,115.4 175.59,115.4 174.96,114.77 174.96,107.88 v2(175.43,107.41)
  IN4 w0.109: v2(239.21,117.24) 239.04,117.42 238.41,118.05 238.41,120.24 234.67,123.97 229.28,123.97 229.06,123.75 224.23,123.75 223.19,124.79 213.69,124.79 212.99,125.5 212.99,125.6 212.75,125.84 212.41,125.84 212.17,125.6 212.17,125.38 211.59,124.8 206.39,124.8 205.89,125.31 198.35,125.31 197.96,124.93 194.29,124.93 193.62,124.26 192.46,124.26 191.09,122.89 180.56,122.89 180.2,123.25 178.93,123.25 v2(178.67,122.99)
  BOTTOM w0.102: U46.B53 175.28,107.26 v2(175.43,107.41)
