# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CS#3: length 69.8
  TOP w0.089: v2(173.96,48.57) 173.96,47.88 174.29,47.56 CPU1.AE5
  TOP w0.165: v2(136.28,57.59) 137.1,57.59 137.27,57.42 v1(137.27,57.2) 137.27,56.89 137.11,56.74 136.12,56.74 136.02,56.64 136.02,56.29 136.15,56.16 136.88,56.16 137.01,56.04 137.01,54.46 136.88,54.34 136.33,54.34 136.21,54.46 136.21,55.37 136.08,55.49 135.2,55.49 134.86,55.83 133.84,55.83 133.5,56.17 JDIMM1.157
  IN1 w0.089: 163.65,47.15 164.61,46.19 171.35,46.19 171.6,46.44 171.6,47.88 171.68,47.96 173.64,47.96 173.96,48.29 v2(173.96,48.57)
  IN1 w0.178: v2(136.28,57.59) 136.3,57.57 136.61,57.57 136.79,57.74 136.79,57.82 136.91,57.95 137.37,57.95 137.5,57.82 137.5,57.69 137.62,57.57 138.08,57.57 138.21,57.69 138.21,57.82 138.34,57.95 138.79,57.95 138.92,57.82 138.92,57.69 139.05,57.57 139.5,57.57 139.63,57.69 139.63,57.82 139.76,57.95 140.21,57.95 140.34,57.82 140.34,57.69 140.47,57.57 140.93,57.57 141.05,57.69 141.05,57.83 141.18,57.95 141.64,57.95 141.76,57.83 141.76,57.69 141.89,57.57 142.35,57.57 142.48,57.69 142.48,58.34 142.6,58.47 143.06,58.47 143.19,58.34 143.19,57.69 143.31,57.57 143.77,57.57 143.9,57.69 143.9,58.34 144.02,58.47 144.48,58.47 144.61,58.34 144.61,57.69 144.74,57.57 145.19,57.57 145.32,57.69 145.32,58.34 145.45,58.47 145.9,58.47 146.03,58.34 146.03,57.69 146.16,57.57 146.62,57.57 146.74,57.69 146.74,57.88 146.87,58.01 147.33,58.01 147.45,57.88 147.45,57.69 147.58,57.57 147.7,57.57 148.82,56.45 149.86,56.45 154.12,52.19 155.16,52.19 155.44,51.9 155.62,51.9 156.06,52.34 156.24,52.34 156.57,52.02 156.57,51.84 156.13,51.4 156.13,51.22 156.45,50.89 156.63,50.89 157.07,51.34 157.25,51.34 157.57,51.01 157.57,50.83 157.13,50.39 157.13,50.21 157.45,49.89 157.63,49.89 158.08,50.33 158.25,50.33 158.58,50.01 158.58,49.83 158.17,49.42 158.17,49.17 158.64,48.7 158.93,48.7 159.06,48.83 159.06,48.93 159.19,49.06 159.68,49.06 159.81,48.93 159.81,48.83 159.94,48.7 162.1,48.7 162.6,48.2 162.85,48.2 163.08,48.44 163.33,48.44 163.59,48.19 163.59,47.93 163.35,47.7 163.35,47.45 163.65,47.15
DDR_A_D0: length 73.8
  TOP w0.089: CPU1.BR6 174.88,24.04 175.14,23.78 175.14,22.94 174.56,22.36 v2(174.05,22.36)
  TOP w0.14: JDIMM1.7 131.95,16.68 131.1,15.83 128.64,15.83 v2(127.98,16.5)
  IN1 w0.147: v2(127.98,16.5) 131.89,12.58 149.51,12.58 150.34,11.74 163.08,11.74 164.67,10.15 171.12,10.15 174.25,13.28 174.25,17.72 173.58,18.38 173.58,21.34 174.05,21.8 v2(174.05,22.36)
  BOTTOM w0.14: v2(127.98,16.5) 128.41,16.06 131.04,16.06 131.9,16.93 JDIMM2.8
DDR_A_D1: length 74.2
  TOP w0.089: v2(173.21,21.48) 173.94,21.48 175.37,22.91 175.37,24 CPU1.BT6
  TOP w0.14: JDIMM1.4 127.76,15.93 128.23,15.45 129.68,15.45 v2(129.87,15.26)
  IN1 w0.147: v2(173.21,21.48) 173.21,18.23 173.87,17.56 173.87,13.44 170.96,10.53 166.32,10.53 166.17,10.67 166.17,11.19 166.04,11.32 165.71,11.32 165.58,11.19 165.58,10.67 165.43,10.53 164.83,10.53 164.47,10.88 164.47,11.09 165.26,11.88 165.26,12.09 165.06,12.3 164.85,12.3 164.06,11.51 163.85,11.51 163.21,12.15 155.55,12.15 154.64,13.06 132.07,13.06 v2(129.87,15.26)
  BOTTOM w0.14: v2(129.87,15.26) 129.46,15.68 JDIMM2.3
DDR_A_D2: length 70.5
  TOP w0.089: v2(172.35,23.02) 172.89,23.02 173.18,23.32 173.18,23.65 173.31,23.77 173.31,24.53 173.39,24.6 173.39,24.88 173.17,25.11 CPU1.BP3
  TOP w0.14: v2(126.71,19.68) 126.46,19.93 JDIMM1.20
  IN1 w0.147: v2(126.71,19.68) 126.71,19.29 126.58,19.16 125.99,19.16 125.87,19.29 125.87,21.89 125.74,22.02 125.4,22.02 125.28,21.89 125.28,18.53 125.4,18.41 127.28,18.41 127.41,18.53 127.41,18.98 127.54,19.1 127.93,19.1 128.06,18.98 128.06,18.53 128.19,18.41 133.27,18.41 134.24,17.43 136.22,17.43 136.35,17.3 136.35,17.2 136.48,17.08 136.81,17.08 136.94,17.2 136.94,17.54 137.06,17.66 137.4,17.66 137.53,17.54 137.53,16.81 137.65,16.69 137.99,16.69 138.12,16.81 138.12,17.54 138.24,17.66 138.58,17.66 138.71,17.54 138.71,16.81 138.83,16.69 139.17,16.69 139.29,16.81 139.29,16.91 139.42,17.04 139.76,17.04 139.88,16.91 139.88,16.83 140.03,16.69 152.98,16.69 153.66,17.36 164.64,17.36 167.05,19.77 168.11,19.77 169.21,20.87 169.21,20.98 171.25,23.02 v2(172.35,23.02)
  BOTTOM w0.14: v2(126.71,19.68) 126.21,20.17 JDIMM2.21
DDR_A_D3: length 75
  TOP w0.089: v2(172.25,22.44) 172.25,22.44 171.94,22.75 171.94,23.19 172.6,23.85 172.6,24.18 173.07,24.65 CPU1.BR3
  TOP w0.14: v2(127.4,17.93) 128.35,18.88 129.88,18.88 131.18,20.17 JDIMM1.21
  IN1 w0.147: v2(127.4,17.93) 127.4,17.1 127.53,16.97 130.5,16.97 130.8,17.27 132.8,17.27 134.27,15.81 136.01,15.81 136.74,15.09 138.04,15.09 138.53,14.6 159.47,14.6 159.61,14.75 159.61,15.31 159.74,15.44 160.08,15.44 160.2,15.31 160.2,14.75 160.35,14.6 164.94,14.6 167.48,12.06 170.32,12.06 172.34,14.08 172.34,16.92 171.15,18.11 171.15,21.27 172.25,22.38 v2(172.25,22.44)
  BOTTOM w0.14: JDIMM2.20 131.69,19.93 130.48,18.72 128.19,18.72 v2(127.4,17.93)
DDR_A_D4: length 70.4
  TOP w0.089: 173.99,21.28 175.58,22.87 175.58,24.36 175.48,24.46 175.48,25.34 175.1,25.72 174.64,25.72 CPU1.BN5
  TOP w0.14: v2(172.66,21.02) 173.73,21.02 173.99,21.28 ; JDIMM1.3 131.58,15.68 v2(131.17,15.26)
  IN1 w0.147: v2(172.66,21.02) 172.71,20.97 172.71,18.19 173.5,17.41 173.5,13.59 170.81,10.9 166.99,10.9 165.18,12.72 160.95,12.72 160.23,13.44 136.37,13.44 136.22,13.59 136.22,13.96 136.1,14.09 135.76,14.09 135.63,13.96 135.63,13.57 135.51,13.44 135.17,13.44 135.04,13.57 135.04,14.09 134.92,14.22 134.58,14.22 134.45,14.09 134.45,13.57 134.33,13.44 133.99,13.44 133.87,13.57 133.87,14.52 133.74,14.65 133.4,14.65 133.28,14.52 133.28,13.57 133.15,13.44 132.38,13.44 132.25,13.57 132.25,13.94 132.63,14.32 132.63,14.94 132.3,15.27 132.06,15.27 131.67,14.88 131.29,14.88 131.17,15.01 v2(131.17,15.26)
  BOTTOM w0.14: v2(131.17,15.26) 131.83,15.93 JDIMM2.4
DDR_A_D5: length 70.5
  TOP w0.089: v2(174.5,22.81) 174.15,23.15 174.15,24.6 CPU1.BP6
  TOP w0.14: JDIMM1.8 126.27,16.93 v2(126.66,16.53)
  IN1 w0.147: v2(126.66,16.53) 126.66,14.6 129.05,12.21 149.35,12.21 150.19,11.37 162.92,11.37 164.52,9.77 171.27,9.77 174.62,13.13 174.62,22.68 v2(174.5,22.81)
  BOTTOM w0.14: JDIMM2.7 125.74,16.68 125.88,16.53 v2(126.66,16.53)
DDR_A_D6: length 76.2
  TOP w0.089: v2(170.29,21.32) 169.7,21.92 169.7,23.08 170.65,24.04 170.65,24.79 171.36,25.5 171.36,25.51 171.55,25.71 172.24,25.71 CPU1.BP2
  TOP w0.14: JDIMM1.16 125.52,18.93 126.2,18.24 126.2,17.86 126.57,17.5 129.73,17.5 v2(130.11,17.88)
  IN1 w0.147: v2(170.29,21.32) 170.06,21.32 169.58,20.84 169.58,20.71 168.26,19.4 167.21,19.4 166.24,18.44 164.8,16.99 153.81,16.99 153.14,16.31 148.84,16.31 148.71,16.18 148.71,15.82 148.59,15.69 148.25,15.69 148.13,15.82 148.13,16.18 148,16.31 147.66,16.31 147.54,16.18 147.54,15.93 147.41,15.8 147.07,15.8 146.95,15.93 146.95,16.18 146.82,16.31 146.36,16.31 146.23,16.18 146.23,15.48 146.11,15.35 145.77,15.35 145.64,15.48 145.64,16.18 145.52,16.31 145.18,16.31 145.06,16.18 145.06,15.48 144.93,15.35 144.59,15.35 144.47,15.48 144.47,16.18 144.34,16.31 144,16.31 143.88,16.18 143.88,15.48 143.75,15.35 143.41,15.35 143.29,15.48 143.29,16.16 143.14,16.31 142.85,16.31 142.7,16.16 142.7,15.48 142.57,15.35 142.24,15.35 142.11,15.48 142.11,16.16 141.96,16.31 141.67,16.31 141.52,16.16 141.52,15.48 141.39,15.35 141.06,15.35 140.93,15.48 140.93,16.16 140.78,16.31 140.49,16.31 140.34,16.16 140.34,15.48 140.21,15.35 139.88,15.35 139.75,15.48 139.75,16.16 139.6,16.31 139.31,16.31 139.16,16.16 139.16,15.62 139.04,15.49 138.7,15.49 138.57,15.62 138.57,16.2 138.45,16.33 138.11,16.33 137.98,16.2 137.98,15.97 137.86,15.84 137.52,15.84 137.39,15.97 137.39,16.16 137.25,16.31 136.71,16.31 135.97,17.05 134.09,17.05 133.11,18.03 130.26,18.03 v2(130.11,17.88)
  BOTTOM w0.14: JDIMM2.17 125.65,19.17 126.35,18.48 126.35,17.75 126.6,17.5 129.73,17.5 v2(130.11,17.88)
DDR_A_D7: length 73.4
  TOP w0.089: v2(171.23,21.98) 171.24,21.98 170.98,22.23 170.98,22.95 171.92,23.88 171.92,24.34 172.01,24.43 172.51,24.43 172.51,24.43 172.54,24.45 172.74,24.65 172.74,25.02 172.86,25.14 172.86,25.86 172.99,25.99 CPU1.BN3
  TOP w0.14: v2(128.74,17.92) 129.19,18.37 129.72,18.37 130.52,19.17 JDIMM1.17
  IN1 w0.147: v2(171.23,21.98) 171.24,21.97 171.24,21.94 170.77,21.47 170.77,20.84 168.95,19.02 167.36,19.02 165.19,16.85 164.95,16.61 159.15,16.61 159.02,16.49 159.02,15.31 158.89,15.18 158.56,15.18 158.43,15.31 158.43,16.49 158.3,16.61 157.97,16.61 157.84,16.49 157.84,15.1 157.71,14.97 156.28,14.97 156.15,15.1 156.15,16.49 156.03,16.61 155.52,16.61 155.39,16.49 155.39,15.1 155.27,14.97 154.03,14.97 153.9,15.1 153.9,15.76 153.77,15.88 153.39,15.88 153.27,15.76 153.27,15.1 153.14,14.97 151.05,14.97 150.9,15.12 150.9,15.81 150.77,15.93 150.44,15.93 150.31,15.81 150.31,15.1 150.18,14.97 149.85,14.97 149.72,15.1 149.72,15.81 149.59,15.93 149.26,15.93 149.13,15.81 149.13,15.12 148.98,14.97 138.69,14.97 138.2,15.46 137.02,15.46 135.81,16.68 133.93,16.68 132.95,17.65 130.59,17.65 130.29,17.35 128.62,17.35 128.49,17.48 128.49,17.8 128.62,17.92 v2(128.74,17.92)
  BOTTOM w0.14: JDIMM2.16 131.68,18.93 131.15,18.4 129.22,18.4 v2(128.74,17.92)
DDR_A_D8: length 60.5
  TOP w0.089: v2(173.27,27.72) 173.64,27.35 CPU1.BL4
  TOP w0.14: v2(126.78,21.32) 125.92,21.32 125.32,21.93 JDIMM1.28
  IN1 w0.089: 168.54,22.32 169.3,23.07 169.3,23.72 171.62,26.04 171.62,26.73 172.61,27.72 v2(173.27,27.72)
  IN1 w0.147: v2(126.78,21.32) 126.45,21.32 126.32,21.19 126.32,20.29 126.45,20.17 126.95,20.17 127.08,20.29 127.08,20.77 127.21,20.9 127.56,20.9 127.69,20.77 127.69,20.29 127.82,20.17 133.93,20.17 134.12,19.98 135.81,19.98 136.54,19.24 139.79,19.24 140.66,18.37 144.99,18.37 145.44,18.81 152.87,18.81 153.67,19.61 164.65,19.61 166.51,21.47 167.7,21.47 168.54,22.32
  BOTTOM w0.14: v2(126.78,21.32) 125.93,22.17 JDIMM2.29
DDR_A_D9: length 62.1
  TOP w0.089: v2(174.64,27.73) 174.29,27.38 CPU1.BL5
  TOP w0.14: JDIMM1.24 126.38,20.93 126.77,20.53 127.14,20.53 v2(127.98,19.7)
  IN1 w0.089: 169.77,22.07 170.17,22.47 170.17,23.36 173.25,26.44 173.92,26.44 174.64,27.16 v2(174.64,27.73)
  IN1 w0.147: v2(127.98,19.7) 128.8,18.87 133.44,18.87 134.02,18.29 135.9,18.29 136.07,18.12 139.32,18.12 140.3,17.14 152.79,17.14 154.06,18.41 157.88,18.41 158.01,18.28 158.01,17.94 158.13,17.82 164.45,17.82 166.86,20.22 167.92,20.22 169.77,22.07
  BOTTOM w0.14: JDIMM2.25 126.27,21.17 127.18,20.27 127.41,20.27 v2(127.98,19.7)
DDR_A_D10: length 71.8
  TOP w0.089: CPU1.BL2 171.61,27.28 170.21,25.87 v2(170.21,25.26)
  TOP w0.14: v2(128.29,23.07) 128.29,23.42 128.41,23.55 129.71,23.55 129.84,23.68 129.84,24.37 129.72,24.49 129.44,24.49 129.3,24.35 129.3,24.15 129.16,24.01 128.88,24.01 128.74,24.15 128.74,24.35 128.6,24.49 128.04,24.49 127.91,24.37 127.91,23.63 127.79,23.5 127.5,23.5 127.37,23.63 127.37,24.07 127.23,24.21 126.91,24.21 126.78,24.09 126.78,23.71 126.66,23.58 126.41,23.58 126.3,23.69 125.96,23.69 125.82,23.83 125.82,24.05 126.18,24.41 126.18,24.53 125.96,24.75 125.77,24.75 125.45,24.42 JDIMM1.38
  IN1 w0.089: v2(170.21,25.26) 169.35,25.26 167.28,23.2
  IN1 w0.147: v2(128.29,23.07) 129.07,22.29 136.2,22.29 137.34,21.15 145.74,21.15 146.1,21.52 163.95,21.52 165.63,23.2 167.28,23.2
  BOTTOM w0.14: JDIMM2.37 125.32,24.17 125.73,24.59 125.92,24.59 126.06,24.45 126.06,24.18 125.96,24.07 125.96,23.62 126.09,23.49 126.35,23.49 126.48,23.62 126.48,24.07 126.65,24.25 127.1,24.25 127.2,24.15 127.2,23.63 127.31,23.52 127.7,23.52 127.8,23.62 127.8,24.37 127.97,24.54 128.45,24.54 128.59,24.4 128.59,24.19 128.73,24.05 129.01,24.05 129.15,24.19 129.15,24.4 129.29,24.54 129.73,24.54 129.86,24.41 129.86,23.68 129.73,23.55 128.38,23.55 128.29,23.46 v2(128.29,23.07)
DDR_A_D11: length 66.3
  TOP w0.089: CPU1.BM1 171.69,26.74 v2(171.1,26.16)
  TOP w0.14: v2(129.63,23.13) 129.95,23.13 130.08,23.25 130.08,24.59 129.93,24.73 127.6,24.73 127.32,24.46 126.6,24.46 125.63,25.42 JDIMM1.42
  IN1 w0.089: 165.21,23.31 165.46,23.57 167.25,23.57 170.07,26.39 170.88,26.39 v2(171.1,26.16)
  IN1 w0.147: v2(129.63,23.13) 129.6,23.13 129.47,23 129.47,22.8 129.6,22.67 130.13,22.67 130.25,22.8 130.25,23.04 130.38,23.17 130.72,23.17 130.84,23.04 130.84,22.8 130.97,22.67 131.3,22.67 131.43,22.8 131.43,23.04 131.56,23.17 131.89,23.17 132.02,23.04 132.02,22.8 132.15,22.67 132.48,22.67 132.61,22.8 132.61,23.04 132.74,23.17 133.07,23.17 133.2,23.04 133.2,22.8 133.33,22.67 133.66,22.67 133.79,22.8 133.79,23.04 133.92,23.17 134.26,23.17 134.39,23.04 134.39,22.85 134.56,22.67 136.33,22.67 136.81,23.14 136.99,23.14 137.24,22.89 137.24,22.71 136.86,22.34 136.86,22.16 137.1,21.92 137.28,21.92 137.66,22.3 137.84,22.3 138.08,22.05 138.08,21.88 137.96,21.76 137.96,21.62 138.06,21.53 145.58,21.53 145.95,21.89 163.79,21.89 165.21,23.31
  BOTTOM w0.14: JDIMM2.41 125.68,25.17 126.36,24.49 127.31,24.49 127.6,24.78 129.92,24.78 130.12,24.58 130.12,23.25 130,23.13 v2(129.63,23.13)
DDR_A_D12: length 63.6
  TOP w0.089: v2(174.01,27.72) 174.01,27.74 CPU1.BK4
  TOP w0.14: JDIMM1.29 131.65,22.17 129.88,20.4 129.32,20.4 v2(128.61,19.7)
  IN1 w0.089: v2(174.01,27.72) 174.01,27.62 169.87,23.48 169.87,22.7 169.43,22.26
  IN1 w0.147: 169.43,22.26 167.77,20.6 166.71,20.6 165.04,18.93 165.04,18.93 164.29,18.19 159.87,18.19 159.74,18.32 159.74,18.73 159.62,18.86 159.25,18.86 159.12,18.73 159.12,18.56 159,18.44 158.58,18.44 158.45,18.56 158.45,18.73 158.32,18.86 153.98,18.86 152.64,17.51 140.45,17.51 139.47,18.49 136.23,18.49 135.94,18.78 135.4,18.78 135.3,18.67 134.18,18.67 133.6,19.25 129.06,19.25 v2(128.61,19.7)
  BOTTOM w0.14: v2(128.61,19.7) 129.07,20.15 130.37,20.15 131.36,21.14 131.36,21.54 131.75,21.93 JDIMM2.28
DDR_A_D13: length 61.4
  TOP w0.089: CPU1.BK5 v2(173.96,28.51)
  TOP w0.14: v2(129.89,19.71) 131.35,21.17 JDIMM1.25
  IN1 w0.089: v2(173.96,28.51) 173.63,28.18 173.63,27.51 169.6,23.48 169.6,22.97 168.96,22.32
  IN1 w0.147: v2(129.89,19.71) 129.9,19.7 133.87,19.7 134.52,19.04 135.14,19.04 135.44,19.35 135.91,19.35 136.39,18.87 139.63,18.87 140.61,17.89 145.28,17.89 145.43,18.04 145.43,18.27 145.55,18.4 145.89,18.4 146.01,18.27 146.01,18.04 146.16,17.89 146.46,17.89 146.6,18.04 146.6,18.31 146.73,18.44 147.07,18.44 147.19,18.31 147.19,18.04 147.34,17.89 147.64,17.89 147.78,18.04 147.78,18.31 147.91,18.44 148.24,18.44 148.37,18.31 148.37,18.04 148.52,17.89 148.81,17.89 148.96,18.04 148.96,18.31 149.09,18.44 149.52,18.44 149.65,18.31 149.65,18.02 149.78,17.89 150.11,17.89 150.24,18.02 150.24,18.31 150.37,18.44 150.7,18.44 150.83,18.31 150.83,18.1 150.96,17.98 151.29,17.98 151.42,18.1 151.42,18.31 151.54,18.44 153.03,18.44 153.82,19.23 164.81,19.23 166.66,21.09 167.72,21.09 168.96,22.32
  BOTTOM w0.14: v2(129.89,19.71) 130.61,19.71 131.82,20.93 JDIMM2.24
DDR_A_D14: length 66.4
  TOP w0.089: CPU1.BK1 169.76,25.75 v2(169.76,24.81)
  TOP w0.14: JDIMM1.41 131.97,25.17 131.71,24.91 131.71,24.54 130.2,23.03 130.2,23.01 129.84,22.65 127.33,22.65 v2(126.91,23.08)
  IN1 w0.089: v2(169.76,24.81) 169.19,24.81 167.26,22.88 165.75,22.88
  IN1 w0.147: v2(126.91,23.08) 128.07,21.92 136.04,21.92 137.18,20.78 140.74,20.78 140.89,20.63 140.89,20.47 141.01,20.35 141.35,20.35 141.48,20.47 141.48,20.65 141.6,20.78 141.94,20.78 142.07,20.65 142.07,20.47 142.19,20.35 142.53,20.35 142.66,20.47 142.66,20.65 142.78,20.78 143.12,20.78 143.24,20.65 143.24,20.47 143.37,20.35 143.71,20.35 143.83,20.47 143.83,20.65 143.96,20.78 144.3,20.78 144.42,20.65 144.42,20.47 144.55,20.35 144.89,20.35 145.01,20.47 145.01,20.65 145.14,20.78 145.95,20.78 146.32,21.14 164.01,21.14 165.75,22.88
  BOTTOM w0.14: v2(126.91,23.08) 127.36,22.63 129.84,22.63 131.73,24.52 131.73,25.25 131.9,25.42 JDIMM2.42
DDR_A_D15: length 67.8
  TOP w0.089: v2(167.51,22.57) 167.51,24.81 171.08,28.39 172.06,28.39 CPU1.BK2
  TOP w0.14: JDIMM1.37 131.86,24.17 131.7,24.01 131.7,23.67 131.57,23.54 131.05,23.54 130.91,23.4 130.91,23.12 131.05,22.98 131.57,22.98 131.7,22.85 131.7,22.52 131.58,22.41 129.12,22.41 129,22.28 129,21.98 129.12,21.85 130.04,21.85 130.16,21.72 v2(130.16,21.42)
  IN1 w0.147: v2(130.16,21.42) 130.28,21.54 135.88,21.54 137.02,20.4 140.27,20.4 140.7,19.97 146.34,19.97 146.49,20.12 146.49,20.64 146.61,20.77 146.95,20.77 147.08,20.64 147.08,20.12 147.22,19.97 147.52,19.97 147.67,20.12 147.67,20.64 147.79,20.77 148.13,20.77 148.25,20.64 148.25,20.12 148.4,19.97 148.7,19.97 148.84,20.12 148.84,20.64 148.97,20.77 164.17,20.77 165.97,22.57 v2(167.51,22.57)
  BOTTOM w0.14: v2(130.16,21.42) 130.25,21.51 130.25,21.73 130.13,21.85 128.17,21.85 128.04,21.98 128.04,22.26 128.17,22.39 129.94,22.39 131.98,24.42 JDIMM2.38
DDR_A_D16: length 62.2
  TOP w0.089: v2(170.06,28.25) 170.06,29.04 170.65,29.64 171.13,29.64 171.49,29.28 171.98,29.28 172.26,29.55 173.55,29.55 173.64,29.64 CPU1.BG4
  TOP w0.14: v2(127.65,25.21) 127.17,24.72 126.71,24.72 126.14,25.29 126.14,25.93 125.64,26.42 JDIMM1.46
  IN1 w0.089: v2(170.06,28.25) 170.06,27.23 166.98,24.16 165.08,24.16 164.81,23.9
  IN1 w0.147: v2(127.65,25.21) 127.5,25.21 127.38,25.08 127.38,24.13 127.5,24 127.86,24 127.98,24.13 127.98,24.47 128.11,24.59 128.45,24.59 128.57,24.47 128.57,24.13 128.7,24 137.3,24 138.94,22.36 145.24,22.36 145.6,22.72 163.64,22.72 164.81,23.9
  BOTTOM w0.14: JDIMM2.45 125.65,26.17 125.84,25.98 125.84,25.39 126.47,24.76 127.2,24.76 v2(127.65,25.21)
DDR_A_D17: length 61.3
  TOP w0.089: v2(170.5,28.7) 170.5,29.24 170.73,29.46 171.05,29.46 171.41,29.1 172.06,29.1 172.2,29.24 173.69,29.24 CPU1.BG5
  TOP w0.14: JDIMM1.50 125.34,27.42 126.97,25.8 v2(126.97,25.21)
  IN1 w0.089: 164.78,23.35 165.38,23.96 167.27,23.96 170.5,27.19 v2(170.5,28.7)
  IN1 w0.147: 164.78,23.35 163.77,22.35 145.76,22.35 145.4,21.98 138.79,21.98 137.15,23.62 127.18,23.62 126.97,23.83 v2(126.97,25.21)
  BOTTOM w0.14: v2(126.97,25.21) 126.97,25.61 125.4,27.17 JDIMM2.49
DDR_A_D18: length 64.7
  TOP w0.089: v2(173.31,31.02) 173.64,30.7 CPU1.BF4
  TOP w0.14: JDIMM1.63 130.98,30.68 130.18,29.88 128.7,29.88 128.18,29.36 127.59,29.36 v2(126.89,28.65)
  IN1 w0.089: v2(173.31,31.02) 172.42,30.14 170.42,30.14 168.08,27.79 166.06,27.79 163.97,25.71
  IN1 w0.147: 163.97,25.71 163.27,25.01 144.66,25.01 144.29,24.64 139.89,24.64 137.07,27.46 128.08,27.46 v2(126.89,28.65)
  BOTTOM w0.14: JDIMM2.62 130.73,30.42 130.18,29.88 128.7,29.88 128.07,29.25 127.48,29.25 v2(126.89,28.65)
DDR_A_D19: length 65.2
  TOP w0.089: CPU1.BF5 174.29,30.7 v2(173.96,31.02)
  TOP w0.14: v2(129.88,26.95) 129.43,26.5 126.61,26.5 125.73,27.38 125.73,29.02 125.32,29.42 JDIMM1.58
  IN1 w0.089: v2(173.96,31.02) 172.79,29.86 170.55,29.86 168.14,27.45 166.18,27.45 164.2,25.46
  IN1 w0.147: 164.2,25.46 163.36,24.63 144.81,24.63 144.45,24.27 139.74,24.27 137.45,26.56 134.47,26.56 134.32,26.7 134.32,26.96 134.2,27.09 133.86,27.09 133.74,26.96 133.74,26.67 133.61,26.54 133.27,26.54 133.15,26.67 133.15,26.96 133.02,27.09 132.68,27.09 132.56,26.96 132.56,26.67 132.43,26.54 132.09,26.54 131.97,26.67 131.97,26.86 131.84,26.98 131.51,26.98 131.38,26.86 131.38,26.7 131.23,26.56 130.28,26.56 v2(129.88,26.95)
  BOTTOM w0.14: JDIMM2.59 125.55,29.68 125.73,29.5 125.73,28.81 127.13,27.4 129.61,27.4 129.88,27.13 v2(129.88,26.95)
DDR_A_D20: length 67.4
  TOP w0.089: v2(169.16,27.35) 169.16,28.41 170.56,29.82 171.2,29.82 171.56,29.46 171.91,29.46 172.3,29.84 CPU1.BG2
  TOP w0.14: v2(129.02,25.21) 129.02,25.53 128.9,25.66 127.33,25.66 127.21,25.79 127.21,26.13 127.33,26.26 129.79,26.26 131.15,27.62 131.42,27.62 131.86,27.17 JDIMM1.49
  IN1 w0.089: v2(169.16,27.35) 169.16,26.59 166.94,24.37 164.78,24.37 164.55,24.14
  IN1 w0.147: 164.55,24.14 163.51,23.1 145.45,23.1 145.08,22.73 139.1,22.73 137.46,24.38 130.25,24.38 130.12,24.5 130.12,24.65 129.99,24.78 129.62,24.78 129.37,24.53 129.02,24.53 128.9,24.66 128.9,25.08 v2(129.02,25.21)
  BOTTOM w0.14: v2(129.02,25.21) 128.9,25.21 128.77,25.33 128.77,26.3 128.9,26.42 129.96,26.42 130.33,26.79 130.33,27.11 130.09,27.35 130.09,28.06 130.22,28.19 130.49,28.19 130.62,28.06 130.62,27.64 130.75,27.52 131.05,27.52 131.18,27.64 131.18,28.14 131.31,28.27 131.6,28.27 131.73,28.14 131.73,27.55 131.85,27.42 JDIMM2.50
DDR_A_D21: length 68.1
  TOP w0.089: v2(168.71,26.9) 168.67,26.94 168.67,28.18 170.48,29.99 171.27,29.99 171.43,29.84 CPU1.BG1
  TOP w0.14: v2(130.42,25.21) 129.84,25.79 129.84,25.97 130.13,26.26 130.31,26.26 131.08,25.5 131.08,25.26 130.95,25.13 130.95,24.65 131.06,24.53 131.32,24.53 131.44,24.65 131.44,25.02 131.73,25.31 131.73,25.63 130.71,26.65 130.71,26.83 130.93,27.06 131.11,27.06 132,26.17 JDIMM1.45
  IN1 w0.089: 164.43,24.45 164.72,24.74 167.06,24.74 168.71,26.39 v2(168.71,26.9)
  IN1 w0.147: v2(130.42,25.21) 130.42,24.88 130.55,24.75 130.97,24.75 131.1,24.88 131.1,25.26 131.23,25.39 131.56,25.39 131.69,25.26 131.69,24.88 131.82,24.75 132.15,24.75 132.28,24.88 132.28,25.26 132.41,25.39 132.74,25.39 132.87,25.26 132.87,24.88 133,24.75 133.33,24.75 133.46,24.88 133.46,25.26 133.58,25.39 133.92,25.39 134.05,25.26 134.05,24.9 134.19,24.75 137.61,24.75 139.26,23.11 144.93,23.11 145.29,23.47 163.45,23.47 164.43,24.45
  BOTTOM w0.14: JDIMM2.46 131.94,26.42 131.2,27.16 131.04,27.16 130.77,26.9 130.77,26.7 131.64,25.84 131.64,25.54 131.46,25.36 131.46,24.68 131.26,24.48 131.04,24.48 130.9,24.62 130.9,25.04 131.01,25.15 131.01,25.67 130.38,26.3 130.18,26.3 129.9,26.02 129.9,25.73 v2(130.42,25.21)
DDR_A_D22: length 67.2
  TOP w0.089: CPU1.BF1 171.69,30.7 v2(171.36,31.02)
  TOP w0.14: v2(129.51,28.69) 129.63,28.69 129.76,28.81 129.76,28.99 129.63,29.12 128.8,29.12 128.67,29.24 128.67,29.51 128.8,29.64 130.21,29.64 130.33,29.52 130.33,29.13 130.51,28.94 131.24,28.94 131.33,29.03 131.33,29.3 130.84,29.8 130.84,30.19 131.04,30.4 131.6,30.4 131.72,30.27 131.72,29.8 131.85,29.68 JDIMM1.59
  IN1 w0.089: 163.78,26.32 165.85,28.39 167.97,28.39 170.19,30.62 171.2,30.62 171.36,30.77 v2(171.36,31.02)
  IN1 w0.147: 163.78,26.32 163.22,25.76 144.34,25.76 143.98,25.4 140.2,25.4 137.34,28.26 136.9,28.26 136.75,28.41 136.75,28.58 136.62,28.7 136.29,28.7 136.16,28.58 136.16,28.41 136.01,28.26 133.8,28.26 133.65,28.41 133.65,28.58 133.52,28.7 133.19,28.7 133.06,28.58 133.06,28.39 132.93,28.26 132.6,28.26 132.47,28.39 132.47,28.58 132.34,28.7 132.01,28.7 131.88,28.58 131.88,28.39 131.75,28.26 131.42,28.26 131.29,28.39 131.29,28.58 131.17,28.7 130.83,28.7 130.7,28.58 130.7,28.39 130.58,28.26 129.63,28.26 129.51,28.39 v2(129.51,28.69)
  BOTTOM w0.14: v2(129.51,28.69) 129.51,28.96 129.38,29.09 128.77,29.09 128.64,29.21 128.64,29.48 128.8,29.64 129.82,29.64 130.73,28.72 130.73,28.65 130.86,28.52 131.24,28.52 131.37,28.65 131.37,29.08 130.7,29.75 130.7,30.05 130.83,30.18 131.51,30.18 131.66,30.03 131.66,29.69 131.92,29.42 JDIMM2.58
DDR_A_D23: length 68.7
  TOP w0.089: v2(172.01,31.02) 172.34,30.7 CPU1.BF2
  TOP w0.14: JDIMM1.62 125.52,30.42 125.97,29.97 125.97,29.7 126.07,29.6 126.75,29.6 126.88,29.47 126.88,29.18 126.79,29.09 126.2,29.09 125.97,28.86 125.97,28.4 126.1,28.28 126.61,28.28 126.74,28.15 126.74,27.93 126.61,27.81 126.1,27.81 125.97,27.68 125.97,27.48 126.21,27.24 126.84,27.24 126.98,27.38 127.29,27.38 127.42,27.51 127.42,28.01 127.55,28.14 128.03,28.14 128.16,28.27 v2(128.16,28.66)
  IN1 w0.089: v2(172.01,31.02) 171.4,30.42 170.36,30.42 168,28.06 165.93,28.06 163.93,26.06
  IN1 w0.147: 163.93,26.06 163.25,25.38 144.5,25.38 144.13,25.02 140.05,25.02 137.19,27.88 128.94,27.88 v2(128.16,28.66)
  BOTTOM w0.14: v2(128.16,28.66) 128.04,28.66 127.91,28.54 127.91,28.29 128.04,28.16 128.58,28.16 128.71,28.04 128.71,27.77 128.58,27.65 127.75,27.65 127.23,28.16 126.71,28.16 125.97,28.91 125.97,29.03 126.09,29.15 127,29.15 127.13,29.28 127.13,29.48 127,29.61 126.05,29.61 125.97,29.69 125.97,30.5 125.8,30.68 JDIMM2.63
DDR_A_D24: length 62.7
  TOP w0.089: CPU1.BD2 171.96,31.98 170.04,31.98 169.38,31.33 169.38,30.87 168.74,30.23 v2(168.74,29.68)
  TOP w0.14: JDIMM1.66 125.59,31.42 126.07,30.94 126.07,30.25 126.45,29.87 128.31,29.87 v2(128.74,30.3)
  IN1 w0.089: 162.39,26.59 163.2,26.59 166.09,29.48 167.91,29.48 168.03,29.61 168.67,29.61 v2(168.74,29.68)
  IN1 w0.147: v2(128.74,30.3) 128.7,30.3 128.24,29.84 128.24,29.61 128.32,29.53 137.24,29.53 137.44,29.34 137.64,29.34 137.87,29.56 138.05,29.56 138.29,29.33 138.29,29.15 138.06,28.92 138.06,28.71 138.79,27.98 139.52,27.98 139.85,27.66 139.85,27.21 140.02,27.03 140.42,27.03 140.68,26.78 140.68,26.35 140.8,26.22 141.28,26.22 141.4,26.35 141.4,26.46 141.53,26.59 141.87,26.59 141.99,26.46 141.99,26.35 142.12,26.22 142.46,26.22 142.58,26.35 142.58,26.46 142.71,26.59 143.05,26.59 143.17,26.46 143.17,26.35 143.3,26.22 143.63,26.22 143.76,26.35 143.76,26.46 143.89,26.59 162.39,26.59
  BOTTOM w0.14: JDIMM2.67 125.39,31.68 126.34,30.73 126.34,30.11 126.57,29.88 128.32,29.88 v2(128.74,30.3)
DDR_A_D25: length 61.5
  TOP w0.089: v2(168.29,29.23) 168.29,30.36 169.04,31.11 169.04,31.59 169.8,32.36 CPU1.BD1
  TOP w0.14: v2(127.46,30.3) 127.46,30.4 125.44,32.42 JDIMM1.70
  IN1 w0.089: v2(168.29,29.23) 166.23,29.23 163.22,26.21 162.72,26.21
  IN1 w0.147: v2(127.46,30.3) 126.85,30.92 126.17,30.92 125.96,30.72 125.96,30.03 126.34,29.66 127.63,29.66 128.13,29.16 137.08,29.16 140.39,25.85 143.79,25.85 144.16,26.21 162.72,26.21
  BOTTOM w0.14: v2(127.46,30.3) 127.46,30.7 125.49,32.68 JDIMM2.71
DDR_A_D26: length 61.3
  TOP w0.089: v2(173.31,33.54) 173.64,33.21 CPU1.BC4
  TOP w0.14: JDIMM1.80 127.31,34.92 v2(128.64,33.59)
  IN1 w0.147: v2(128.64,33.59) 128.64,33.38 128.81,33.21 130.42,33.21 130.55,33.34 130.55,33.84 130.67,33.97 131.01,33.97 131.14,33.84 131.14,33.34 131.26,33.21 131.6,33.21 131.73,33.34 131.73,33.59 131.85,33.72 132.19,33.72 132.31,33.59 132.31,33.34 132.44,33.21 132.78,33.21 132.9,33.34 132.9,33.59 133.03,33.72 133.37,33.72 133.49,33.59 133.49,33.34 133.62,33.21 134.02,32.81 136.27,32.81 136.73,32.35 138.93,32.35 142.41,28.87 162.82,28.87 167.05,33.1 167.49,33.1 167.87,32.72 172.49,32.72 v2(173.31,33.54)
  BOTTOM w0.14: v2(128.64,33.59) 127.56,34.68 JDIMM2.79
DDR_A_D27: length 63.7
  TOP w0.089: v2(173.96,33.54) 174.29,33.21 CPU1.BC5
  TOP w0.14: JDIMM1.79 131.75,34.68 130.2,33.13 127.86,33.13 v2(127.45,33.54)
  IN1 w0.147: v2(173.96,33.54) 172.83,32.41 167.53,32.41 165.88,30.76 165.43,30.76 163.17,28.5 142.25,28.5 138.78,31.97 136.58,31.97 136.12,32.43 132.91,32.43 132.5,32.84 128.16,32.84 v2(127.45,33.54)
  BOTTOM w0.14: JDIMM2.80 131.82,34.92 130.04,33.14 127.85,33.14 v2(127.45,33.54)
DDR_A_D28: length 63.4
  TOP w0.089: v2(173.94,31.88) 173.94,32.01 CPU1.BD5
  TOP w0.14: JDIMM1.71 127.77,32.68 v2(127.29,32.19)
  IN1 w0.089: v2(173.94,31.88) 173.53,31.47 169.42,31.47 167.95,30.01 165.88,30.01 163.21,27.34 162.26,27.34
  IN1 w0.147: 162.26,27.34 141.77,27.34 138.3,30.81 128.48,30.81 127.29,32 v2(127.29,32.19)
  BOTTOM w0.14: v2(127.29,32.19) 127.29,31.81 127.61,31.49 130.82,31.49 131.76,32.42 JDIMM2.70
DDR_A_D29: length 60.7
  TOP w0.089: v2(169.64,30.57) 169.64,31.14 170.27,31.77 173.05,31.77 CPU1.BD4
  TOP w0.14: v2(130.01,30.31) 131.38,31.68 JDIMM1.67
  IN1 w0.089: v2(169.64,30.57) 169.44,30.78 169.1,30.78 168.12,29.79 166.03,29.79 163.21,26.96 162.23,26.96
  IN1 w0.147: v2(130.01,30.31) 130.01,30.03 130.14,29.91 130.5,29.91 130.62,30.03 130.62,30.31 130.75,30.44 131.09,30.44 131.21,30.31 131.21,30.03 131.34,29.91 131.68,29.91 131.8,30.03 131.8,30.31 131.93,30.44 132.26,30.44 132.39,30.31 132.39,30.03 132.52,29.91 132.85,29.91 132.98,30.03 132.98,30.31 133.11,30.44 133.44,30.44 133.57,30.31 133.57,30.06 133.72,29.91 136.14,29.91 136.29,30.06 136.29,30.31 136.42,30.44 136.75,30.44 136.88,30.31 136.88,30.03 137.01,29.91 137.34,29.91 137.47,30.03 137.47,30.31 137.6,30.44 137.93,30.44 138.06,30.31 138.06,30.06 138.2,29.91 138.67,29.91 139.09,29.49 139.09,29.28 138.65,28.84 138.65,28.66 138.88,28.42 139.06,28.42 139.52,28.88 139.7,28.88 139.94,28.64 139.94,28.46 139.84,28.37 139.84,28.19 140.08,27.95 140.26,27.95 140.35,28.04 140.53,28.04 140.77,27.81 140.77,27.63 140.68,27.54 140.68,27.36 140.92,27.12 141.09,27.12 141.17,27.2 141.38,27.2 141.61,26.96 162.23,26.96
  BOTTOM w0.14: v2(130.01,30.31) 131.13,31.42 JDIMM2.66
DDR_A_D30: length 60.8
  TOP w0.089: CPU1.BC1 171.69,33.3 v2(171.45,33.54)
  TOP w0.14: JDIMM1.83 131.73,35.68 129.99,33.94 v2(129.99,33.69)
  IN1 w0.147: v2(129.99,33.69) 129.99,33.94 129.86,34.07 129.53,34.07 129.4,34.2 129.4,34.82 129.53,34.95 129.9,34.95 130.03,34.82 130.03,34.48 130.15,34.35 130.59,34.35 130.71,34.48 130.71,34.82 130.84,34.95 131.27,34.95 131.4,34.82 131.4,34.23 131.53,34.11 131.86,34.11 131.98,34.23 131.98,34.82 132.11,34.95 132.66,34.95 132.78,34.82 132.78,34.22 132.91,34.1 133.57,34.1 133.87,33.8 133.87,33.49 134,33.37 134.18,33.18 136.43,33.18 136.43,33.18 136.63,33.18 136.76,33.05 136.76,32.9 136.88,32.77 137.29,32.77 137.42,32.9 137.42,33.54 137.55,33.66 138.05,33.66 138.18,33.54 138.18,32.92 138.31,32.8 139.02,32.8 142.56,29.25 162.75,29.25 166.92,33.42 167.68,33.42 168.06,33.04 170.95,33.04 v2(171.45,33.54)
  BOTTOM w0.14: v2(129.99,33.69) 129.99,34.17 131.75,35.92 JDIMM2.84
DDR_A_D31: length 58.4
  TOP w0.089: CPU1.BC2 172.34,33.21 v2(172.01,33.54)
  TOP w0.14: v2(126.48,35.76) 126.31,35.92 JDIMM1.84
  IN1 w0.147: v2(126.48,35.76) 126.48,35.45 127.07,34.86 127.07,34.31 127.2,34.18 127.54,34.18 127.66,34.31 127.66,35.2 127.79,35.32 128.12,35.32 128.25,35.2 128.25,34.28 128.38,34.16 128.71,34.16 128.84,34.28 128.84,35.18 128.99,35.32 132.87,35.32 133.73,34.47 134.1,34.1 138.25,34.1 142.72,29.63 162.68,29.63 166.99,33.93 171.62,33.93 v2(172.01,33.54)
  BOTTOM w0.102: v2(126.48,35.76) 126.4,35.68 JDIMM2.83
DDR_A_D32: length 69.9
  TOP w0.089: CPU1.AB1 168.59,49.96 v2(168.15,49.52)
  TOP w0.14: JDIMM1.174 125.74,60.43 126.9,61.59 126.9,62.88 127.09,63.06 129.31,63.06 v2(129.81,63.57)
  IN1 w0.089: 160.72,55.89 161.61,55 162.23,55 165.76,51.47 165.76,49.8 166.4,49.17 167.8,49.17 v2(168.15,49.52)
  IN1 w0.147: v2(129.81,63.57) 129.81,63.67 129.91,63.77 131.4,63.77 131.68,64.06 131.8,64.06 131.99,64.25 131.99,64.36 132.53,64.9 132.83,64.9 133,65.07 133,65.37 133.41,65.78 133.51,65.78 133.88,66.14 133.88,66.25 134.22,66.59 134.39,66.59 134.72,66.27 134.79,66.27 134.95,66.1 135.16,66.1 135.32,66.27 136.68,66.27 136.8,66.14 136.8,65.39 136.93,65.26 137.27,65.26 137.39,65.39 137.39,66.02 137.52,66.15 137.86,66.15 137.98,66.02 137.98,65.39 138.11,65.26 138.42,65.26 138.57,65.41 138.57,66.02 138.7,66.15 139.03,66.15 139.16,66.02 139.16,65.41 139.31,65.26 148.16,65.26 150.93,62.49 153.43,62.49 157.91,58.01 158.59,58.01 160.72,55.89
  BOTTOM w0.14: v2(129.81,63.57) 129.22,62.98 128.84,62.59 127.48,62.59 127.27,62.38 127.27,61.57 125.87,60.17 JDIMM2.173
DDR_A_D33: length 68
  TOP w0.089: CPU1.AB2 172.06,49.68 169.96,49.68 169.9,49.63 v1(169.75,49.63) 169.16,49.63 v2(168.6,49.07)
  TOP w0.14: v2(129.04,62.17) 129.04,62.17 129.95,61.27 130.68,61.27 130.77,61.17 130.77,60.83 131.71,59.9 131.71,59.48 132.01,59.17 JDIMM1.169
  IN1 w0.089: v2(168.6,49.07) 168.47,48.94 166.29,48.94 165.56,49.66 165.56,51.36 162.32,54.6 162.06,54.6
  IN1 w0.147: v2(129.04,62.17) 129.01,62.17 128.52,62.66 128.52,62.84 128.81,63.13 128.99,63.13 129.42,62.71 129.56,62.71 130.25,63.39 131.55,63.39 131.84,63.69 132.09,63.69 132.36,63.96 132.36,64.21 132.64,64.49 132.96,64.49 133.09,64.35 133.41,64.35 133.57,64.51 133.57,64.71 133.38,64.9 133.38,65.11 133.75,65.48 133.97,65.48 134.12,65.63 134.12,65.76 134.24,65.89 134.64,65.89 134.76,65.76 134.76,65.59 134.89,65.46 135.22,65.46 135.35,65.59 135.35,65.76 135.48,65.89 136.28,65.89 136.43,65.74 136.43,65.5 136.16,65.23 136.16,65.01 136.29,64.89 148,64.89 150.77,62.11 153.27,62.11 157.75,57.63 158.44,57.63 161.47,54.6 162.06,54.6
  BOTTOM w0.14: v2(129.04,62.17) 129.04,62.06 129.78,61.31 130.53,61.31 130.66,61.18 130.66,60.36 131.59,59.43 JDIMM2.170
DDR_A_D34: length 67
  TOP w0.089: v2(173.31,51.14) 173.64,50.81 CPU1.AA4
  TOP w0.14: v2(128.56,65.04) 128.56,65.02 128.15,64.61 126.88,64.61 126.33,64.06 126.33,63.73 126.03,63.43 JDIMM1.186
  IN1 w0.089: 160.67,58.11 161.22,57.55 163.99,54.79 163.99,54.47 167.88,50.58 168.1,50.58 168.55,50.12 172.29,50.12 v2(173.31,51.14)
  IN1 w0.147: 160.67,58.11 159.23,59.54 158.54,59.54 153.97,64.11 151.69,64.11 149.01,66.8 146.34,66.8 146.21,66.93 146.21,67.06 146.08,67.19 145.75,67.19 145.62,67.06 145.62,66.93 145.49,66.8 145.16,66.8 145.03,66.93 145.03,67.54 144.89,67.68 144.59,67.68 144.44,67.54 144.44,66.93 144.32,66.8 143.98,66.8 143.85,66.93 143.85,67.56 143.73,67.68 137.43,67.68 136.9,68.21 133.67,68.21 130.76,65.3 130.2,65.3 130.04,65.46 128.71,65.46 128.56,65.32 v2(128.56,65.04)
  BOTTOM w0.14: JDIMM2.187 125.58,63.68 125.84,63.94 125.84,64.43 125.98,64.57 128.14,64.57 128.56,64.99 v2(128.56,65.04)
DDR_A_D35: length 69.1
  TOP w0.089: CPU1.AA5 174.29,50.82 v2(173.96,51.14)
  TOP w0.14: JDIMM1.182 125.45,62.43 126.61,63.58 126.61,63.99 126.98,64.37 128.25,64.37 128.5,64.61 129.43,64.61 v2(129.86,65.04)
  IN1 w0.089: 160.67,57.58 163.67,54.57 163.67,54.41 167.73,50.35 167.93,50.35 168.4,49.88 172.7,49.88 v2(173.96,51.14)
  IN1 w0.147: 160.67,57.58 159.07,59.17 158.39,59.17 153.91,63.65 151.41,63.65 148.63,66.42 143.6,66.42 143.48,66.55 143.48,67.18 143.35,67.31 143.02,67.31 142.89,67.18 142.89,66.55 142.76,66.42 142.43,66.42 142.3,66.55 142.3,67.18 142.17,67.31 137.27,67.31 136.74,67.84 133.83,67.84 130.92,64.93 129.96,64.93 v2(129.86,65.04)
  BOTTOM w0.14: JDIMM2.183 125.43,62.68 125.67,62.92 125.67,63.08 126.75,64.16 129.54,64.16 129.86,64.47 v2(129.86,65.04)
DDR_A_D36: length 67.1
  TOP w0.089: CPU1.AB5 173.96,49.63 v2(173.96,49.61)
  TOP w0.14: JDIMM1.170 125.55,59.43 126.97,60.85 126.97,60.95 127.2,61.18 127.62,61.18 127.79,61.35 127.79,62.09 v2(127.71,62.16)
  IN1 w0.089: 161.89,53.85 162.46,53.85 165.16,51.14 165.16,49.43 166.07,48.52 172.01,48.52 172.48,48.99 173.34,48.99 v2(173.96,49.61)
  IN1 w0.147: 161.89,53.85 161.16,53.85 158.13,56.88 157.44,56.88 152.96,61.36 150.46,61.36 147.81,64.01 141.07,64.01 140.66,63.6 135.91,63.6 135.5,64.01 134.47,64.01 134.07,63.6 133.07,63.6 132.11,62.64 131.4,62.64 130.41,61.65 127.31,61.65 127.18,61.77 127.18,62.04 127.31,62.16 v2(127.71,62.16)
  BOTTOM w0.14: JDIMM2.169 125.64,59.17 126.77,60.31 126.77,60.73 127.71,61.67 v2(127.71,62.16)
DDR_A_D37: length 66.2
  TOP w0.089: v2(169.87,49.07) 170.26,49.46 173.14,49.46 CPU1.AB4
  TOP w0.14: v2(130.32,62.16) 130.32,61.81 130.63,61.51 130.78,61.51 131.01,61.27 131.01,60.93 131.77,60.17 JDIMM1.173
  IN1 w0.089: v2(169.87,49.07) 169.87,48.84 169.74,48.71 166.15,48.71 165.34,49.52 165.34,51.27 162.39,54.22 161.95,54.22
  IN1 w0.147: 161.95,54.22 161.32,54.22 158.28,57.26 157.59,57.26 153.12,61.74 150.62,61.74 147.84,64.51 147.43,64.51 147.3,64.39 146.96,64.39 146.84,64.51 146.37,64.51 146.24,64.39 145.76,64.39 145.64,64.51 145.22,64.51 145.09,64.39 144.6,64.39 144.48,64.51 144.06,64.51 143.94,64.39 143.48,64.39 143.36,64.51 142.98,64.51 142.86,64.39 142.33,64.39 142.21,64.51 141.98,64.51 141.86,64.39 141.55,64.39 141.43,64.51 141.04,64.51 140.83,64.31 140.63,64.31 140.43,64.51 140.2,64.51 140.07,64.38 140.07,64.1 139.95,63.97 139.6,63.97 139.47,64.1 139.47,64.34 139.32,64.49 139.03,64.49 138.88,64.34 138.88,64.1 138.76,63.97 138.42,63.97 138.29,64.1 138.29,64.38 138.17,64.51 137.83,64.51 137.7,64.38 137.7,64.1 137.58,63.97 137.24,63.97 137.11,64.1 137.11,64.38 136.99,64.51 136.65,64.51 136.53,64.38 136.53,64.1 136.4,63.97 136.06,63.97 135.94,64.1 135.94,64.48 135.81,64.61 135.3,64.61 135.08,64.38 134.67,64.38 134.54,64.51 134.54,64.99 134.41,65.12 134.08,65.12 133.95,64.99 133.95,64.1 133.82,63.97 132.91,63.97 131.95,63.02 131.25,63.02 130.91,62.68 130.78,62.68 130.53,62.93 130.31,62.93 130.03,62.64 130.03,62.46 v2(130.32,62.16)
  BOTTOM w0.14: JDIMM2.174 131.19,60.43 130.92,60.69 130.92,61.56 v2(130.32,62.16)
DDR_A_D38: length 70.1
  TOP w0.089: CPU1.AA2 172.34,50.81 v2(172.03,51.14)
  TOP w0.14: v2(127.32,65.04) 127.84,65.55 129.99,65.55 131.43,64.11 131.43,63.25 132,62.68 JDIMM1.183
  IN1 w0.089: 160.93,58.38 161.55,57.76 161.55,57.64 164.29,54.9 164.29,54.54 167.93,50.91 168.07,50.91 168.59,50.39 171.64,50.39 172.03,50.77 v2(172.03,51.14)
  IN1 w0.147: v2(127.32,65.04) 128.13,65.84 130.76,65.84 133.51,68.59 137.05,68.59 137.59,68.06 145.04,68.06 145.53,67.57 146.34,67.57 146.73,67.18 149.16,67.18 151.85,64.49 154.13,64.49 158.7,59.92 159.39,59.92 160.93,58.38
  BOTTOM w0.14: v2(127.32,65.04) 127.78,65.49 130.01,65.49 130.34,65.16 130.34,64 131.91,62.43 JDIMM2.182
DDR_A_D39: length 67.2
  TOP w0.089: v2(171.39,51.14) 171.69,50.81 CPU1.AA1
  TOP w0.14: JDIMM1.187 131.82,63.68 131.67,63.83 131.67,64.6 130.77,65.49 130.77,66.4 130.67,66.51 v2(130.04,66.51)
  IN1 w0.089: 161.2,58.64 161.84,58 161.84,57.72 164.54,55.02 164.54,54.57 167.95,51.16 168.14,51.16 168.68,50.62 171.14,50.62 171.39,50.87 v2(171.39,51.14)
  IN1 w0.147: 161.2,58.64 159.54,60.3 158.85,60.3 154.29,64.86 152.03,64.86 149.07,67.83 148.7,67.83 148.43,67.55 148.02,67.55 147.9,67.68 147.9,67.82 147.77,67.94 147.43,67.94 147.3,67.82 147.3,67.68 147.17,67.55 146.89,67.55 146.5,67.94 145.69,67.94 145.2,68.43 139.83,68.43 139.71,68.56 139.71,69.37 139.58,69.5 139.25,69.5 139.12,69.37 139.12,68.56 138.99,68.43 138.66,68.43 138.53,68.56 138.53,69.37 138.4,69.5 138.07,69.5 137.94,69.37 137.94,68.83 137.81,68.7 137.48,68.7 137.35,68.83 137.35,69.37 137.22,69.5 136.89,69.5 136.76,69.37 136.76,69.09 136.63,68.97 134.69,68.97 134.56,69.09 134.56,69.37 134.44,69.5 134,69.5 133.88,69.37 133.88,69.09 133.75,68.97 133.36,68.97 130.61,66.22 130.11,66.22 130.04,66.29 v2(130.04,66.51)
  BOTTOM w0.14: JDIMM2.186 131.63,63.43 130.71,64.34 130.71,65.84 v2(130.04,66.51)
DDR_A_D40: length 69.6
  TOP w0.089: CPU1.V5 173.7,51.89 170.87,51.89 v2(170.12,51.14)
  TOP w0.14: v2(128.74,66.51) 128.16,65.93 127.34,65.93 125.83,64.43 JDIMM1.190
  IN1 w0.089: v2(170.12,51.14) 170.12,51 169.96,50.83 168.77,50.83 168.24,51.37 167.99,51.37 164.77,54.59 164.77,55.16 162.18,57.74 162.18,58.3 161.52,58.96
  IN1 w0.147: v2(128.74,66.51) 128.74,67.27 128.9,67.43 129.21,67.43 129.34,67.31 129.34,67.11 129.47,66.99 129.82,66.99 129.95,67.11 129.95,67.31 130.08,67.43 130.38,67.43 130.51,67.31 130.51,67.15 130.61,67.05 130.8,67.05 133.7,69.95 140.03,69.95 140.16,69.83 140.16,69.01 140.29,68.89 140.62,68.89 140.75,69.01 140.75,69.26 140.88,69.39 141.21,69.39 141.34,69.26 141.34,69.01 141.47,68.89 141.8,68.89 141.93,69.01 141.93,69.26 142.05,69.39 142.39,69.39 142.52,69.26 142.52,69.03 142.66,68.89 145.38,68.89 145.88,68.39 149.14,68.39 152.22,65.32 154.47,65.32 159.04,60.75 159.73,60.75 161.52,58.96
  BOTTOM w0.14: v2(128.74,66.51) 128.74,66.34 128.16,65.76 127.26,65.76 126.37,64.87 125.75,64.87 125.56,64.68 JDIMM2.191
DDR_A_D41: length 69.3
  TOP w0.089: v2(168.59,52.04) 168.66,52.11 v1(169.6,52.11) 171.98,52.11 CPU1.V2
  TOP w0.14: v2(129.92,68.26) 129.92,67.83 130.18,67.57 130.61,67.57 131.28,66.9 131.28,66.12 131.73,65.68 JDIMM1.195
  IN1 w0.089: 162.05,59.49 162.69,58.85 162.69,58.03 165.31,55.42 165.31,54.55 168.05,51.81 168.36,51.81 v2(168.59,52.04)
  IN1 w0.147: 162.05,59.49 160.04,61.5 159.35,61.5 154.76,66.09 152.5,66.09 149.45,69.15 147.86,69.15 147.73,69.27 147.73,70.06 147.6,70.19 147.27,70.19 147.14,70.06 147.14,69.27 147.01,69.15 146.68,69.15 146.55,69.27 146.55,70.36 146.4,70.51 146.11,70.51 145.96,70.36 145.96,69.77 145.83,69.64 145.5,69.64 145.37,69.77 145.37,70.36 145.22,70.51 144.93,70.51 144.78,70.36 144.78,69.77 144.66,69.64 144.32,69.64 144.19,69.77 144.19,70.39 144.07,70.52 143.73,70.52 143.6,70.39 143.6,69.83 143.48,69.7 143.14,69.7 143.01,69.83 143.01,70.39 142.89,70.52 142.55,70.52 142.42,70.39 142.42,70.27 142.3,70.14 141.96,70.14 141.84,70.27 141.84,70.39 141.71,70.52 141.37,70.52 141.24,70.39 141.24,70.27 141.11,70.14 140.91,70.14 140.34,70.7 133.39,70.7 130.95,68.26 v2(129.92,68.26)
  BOTTOM w0.14: JDIMM2.194 131.72,65.43 131.37,65.78 131.37,66.23 129.92,67.68 v2(129.92,68.26)
DDR_A_D42: length 68.5
  TOP w0.089: CPU1.U1 171.69,53.33 v2(171.41,53.66)
  TOP w0.14: JDIMM1.208 125.7,68.92 126.26,69.49 126.26,70.1 127.04,70.88 127.04,71.45 v2(127.07,71.48)
  IN1 w0.089: 164.61,60.42 164.61,58.23 168.4,54.44 168.4,54.09 169.33,53.16 170.91,53.16 v2(171.41,53.66)
  IN1 w0.147: v2(127.07,71.48) 127.51,71.03 129.95,71.03 133.24,74.32 140.16,74.32 140.29,74.19 140.29,73.49 140.42,73.37 140.75,73.37 140.88,73.49 140.88,74.19 141.01,74.32 141.34,74.32 141.47,74.19 141.47,73.41 141.6,73.29 143.19,73.29 143.59,73.69 150.01,73.69 150.27,73.42 150.27,72.58 154.09,68.76 155.87,68.76 160.46,64.16 161.15,64.16 164.61,60.7 164.61,60.42
  BOTTOM w0.14: JDIMM2.207 125.43,68.67 126.71,69.95 126.71,71.15 127.03,71.48 v2(127.07,71.48)
DDR_A_D43: length 70.6
  TOP w0.089: v2(172.03,53.66) 172.34,53.32 CPU1.U2
  TOP w0.14: JDIMM1.203 131.51,67.67 130.14,69.04 128.37,69.04 v2(127.56,69.85)
  IN1 w0.089: 164.24,60.15 164.24,58.35 168.16,54.42 168.16,53.97 169.23,52.9 171.28,52.9 v2(172.03,53.66)
  IN1 w0.147: 164.24,60.15 164.24,60.54 160.99,63.79 160.3,63.79 155.71,68.38 153.94,68.38 149.51,72.8 141.55,72.8 141.36,72.99 140.04,72.99 139.92,73.12 139.92,73.82 139.79,73.94 133.4,73.94 130.11,70.65 127.54,70.65 127.41,70.53 127.41,70.16 127.56,70.01 v2(127.56,69.85)
  BOTTOM w0.14: v2(127.56,69.85) 127.56,69.7 128.05,69.21 130.73,69.21 132.02,67.92 JDIMM2.204
DDR_A_D44: length 71.3
  TOP w0.089: CPU1.V1 171.67,52.49 v2(168.14,52.49)
  TOP w0.14: JDIMM1.191 131.97,64.68 131.04,65.6 131.04,66.64 130.57,67.11 129.26,67.11 129.06,67.32 129.06,67.82 v2(128.65,68.23)
  IN1 w0.089: v2(168.14,52.49) 167.94,52.29 167.82,52.29 165.55,54.56 165.55,55.45 162.91,58.09 162.91,59.17 162.31,59.76
  IN1 w0.147: 162.31,59.76 160.2,61.88 159.51,61.88 154.92,66.47 152.66,66.47 152.43,66.7 152.43,66.83 152.52,66.92 152.52,67.1 152.28,67.33 152.1,67.33 152.04,67.27 151.86,67.27 151.62,67.51 151.62,67.69 151.68,67.75 151.68,67.93 151.44,68.17 151.26,68.17 151.2,68.11 151.02,68.11 150.79,68.34 150.79,68.52 150.85,68.58 150.85,68.76 150.61,69 150.43,69 150.37,68.94 150.19,68.94 150.04,69.09 150.04,69.57 149.89,69.72 149.72,69.72 149.53,69.52 149.39,69.52 149.28,69.62 149.28,70.33 148.98,70.63 148.8,70.63 148.7,70.53 148.7,69.65 148.57,69.52 148.23,69.52 148.11,69.65 148.11,70.77 147.98,70.89 147.55,70.89 147.43,70.77 147.43,70.69 147.3,70.56 146.88,70.56 146.75,70.69 146.75,70.77 146.62,70.89 140.7,70.89 140.52,71.08 133.24,71.08 130.86,68.7 128.58,68.7 128.45,68.57 128.45,68.42 v2(128.65,68.23)
  BOTTOM w0.14: JDIMM2.190 131.38,64.43 131.04,64.77 131.04,66.12 129.92,67.24 129.64,67.24 v2(128.65,68.23)
DDR_A_D45: length 67.5
  TOP w0.089: CPU1.V4 173.64,52.5 173.98,52.84 174.32,52.84 174.57,53.09 v2(174.57,53.65)
  TOP w0.14: v2(127.43,66.49) 126.36,65.43 JDIMM1.194
  IN1 w0.089: 161.78,59.23 162.49,58.52 162.49,57.87 165.05,55.3 165.05,54.56 168,51.61 168.37,51.61 168.84,51.14 169.56,51.14 170.54,52.12 173.04,52.12 v2(174.57,53.65)
  IN1 w0.147: v2(127.43,66.49) 127.36,66.56 127.36,67.52 127.63,67.79 128.73,67.79 128.75,67.81 131.03,67.81 133.55,70.33 140.19,70.33 140.75,69.76 142.55,69.76 143.05,69.26 145.54,69.26 146.03,68.77 149.29,68.77 152.35,65.72 154.6,65.72 159.2,61.12 159.89,61.12 161.78,59.23
  BOTTOM w0.14: v2(127.43,66.49) 127.43,66.32 127.22,66.11 127.05,66.11 126.91,65.97 126.9,65.97 126.61,65.68 JDIMM2.195
DDR_A_D46: length 67.3
  TOP w0.089: CPU1.U5 174.29,53.33 v2(173.96,53.66)
  TOP w0.14: JDIMM1.207 131.31,68.67 130.13,69.85 v2(130.1,69.85)
  IN1 w0.089: v2(173.96,53.66) 172.73,52.42 169,52.42 167.72,53.7 167.72,54.36 163.62,58.46 163.62,59.62
  IN1 w0.147: v2(130.1,69.85) 130.13,69.88 130.39,69.88 132.76,72.24 133.17,72.24 133.31,72.39 133.31,72.8 133.44,72.92 133.78,72.92 133.9,72.8 133.9,72.39 134.05,72.24 134.54,72.24 134.66,72.37 134.66,72.58 134.79,72.71 135.25,72.71 135.37,72.58 135.37,72.37 135.5,72.24 135.9,72.24 136.03,72.37 136.03,73.06 136.16,73.19 136.49,73.19 136.62,73.06 136.62,72.39 136.77,72.24 137.06,72.24 137.21,72.39 137.21,73.06 137.34,73.19 137.67,73.19 137.8,73.06 137.8,72.39 137.95,72.24 138.38,72.24 138.53,72.39 138.53,72.54 138.68,72.69 138.97,72.69 139.12,72.54 139.12,72.39 139.27,72.24 141.05,72.24 141.24,72.05 149.2,72.05 153.62,67.63 155.4,67.63 159.99,63.03 160.68,63.03 163.62,60.09 163.62,59.62
  BOTTOM w0.14: JDIMM2.208 131.94,68.92 130.9,69.96 130.21,69.96 v2(130.1,69.85)
DDR_A_D47: length 70.7
  TOP w0.089: CPU1.U4 173.64,53.32 v2(173.3,53.66)
  TOP w0.14: v2(128.84,69.85) 128.84,70.03 128.56,70.31 127.45,70.31 127.38,70.38 126.96,70.38 126.5,69.92 126.5,68.78 125.65,67.92 JDIMM1.204
  IN1 w0.089: 163.4,60.85 163.95,60.3 163.95,58.39 167.94,54.4 167.94,53.84 169.1,52.67 172.32,52.67 v2(173.3,53.66)
  IN1 w0.147: 163.4,60.85 160.83,63.41 160.15,63.41 155.55,68 153.78,68 149.36,72.43 141.4,72.43 141.21,72.61 139.67,72.61 139.54,72.74 139.54,73.44 139.41,73.57 139.02,73.57 138.89,73.44 138.89,73.19 138.76,73.07 138.35,73.07 138.22,73.19 138.22,73.44 138.09,73.57 133.55,73.57 130.26,70.28 129.26,70.28 128.84,69.86 v2(128.84,69.85)
  BOTTOM w0.14: v2(128.84,69.85) 128.84,69.9 128.38,70.35 127.36,70.35 127.1,70.1 127.1,69.71 126.18,68.79 126.18,68.04 125.82,67.67 JDIMM2.203
DDR_A_D48: length 75.6
  TOP w0.089: CPU1.R2 172,54.65 170.31,54.65 169.66,55.29 v2(169.06,55.29)
  TOP w0.14: JDIMM1.212 125.79,69.92 125.92,70.05 125.92,70.91 126.05,71.04 126.48,71.04 126.61,71.17 126.61,71.38 126.48,71.51 126.05,71.51 125.92,71.64 125.92,71.83 126.05,71.95 130.7,71.95 130.82,72.08 130.82,72.33 130.7,72.46 130.35,72.46 130.04,72.77 130.04,73.09 v2(130.03,73.1)
  IN1 w0.089: v2(169.06,55.29) 168.3,55.29 165.4,58.2 165.4,61.62 164.78,62.23
  IN1 w0.147: 164.78,62.23 161.65,65.37 160.96,65.37 156.36,69.96 154.59,69.96 151.48,73.07 151.48,73.93 150.51,74.89 147.93,74.89 147.79,75.04 147.1,75.04 146.96,74.89 146.6,74.89 146.34,75.15 145.91,75.15 145.65,74.89 145.26,74.89 145.01,75.15 144.54,75.15 144.29,74.89 144.01,74.89 143.88,75.02 143.88,75.4 143.76,75.52 143.39,75.52 143.26,75.4 143.26,75.09 143.13,74.96 142.79,74.96 142.67,75.09 142.67,75.4 142.54,75.52 138.5,75.52 138.35,75.67 138.35,75.96 138.23,76.09 137.89,76.09 137.76,75.96 137.76,75.67 137.62,75.52 137.46,75.52 136.89,76.09 133.75,76.09 133.61,75.94 133.61,75.77 133.36,75.52 132.74,75.52 130.32,73.1 v2(130.03,73.1)
  BOTTOM w0.14: v2(130.03,73.1) 130.03,73.07 129.31,72.35 128.05,72.35 127.62,71.91 126.87,71.91 126.39,71.44 126.39,70.72 125.35,69.67 JDIMM2.211
DDR_A_D49: length 73
  TOP w0.089: v2(173.82,56.16) 174.25,55.72 CPU1.P5
  TOP w0.14: JDIMM1.216 125.55,70.92 125.68,71.05 125.68,72.61 125.81,72.74 126.02,72.74 126.12,72.64 126.12,72.35 126.25,72.22 126.47,72.22 126.6,72.35 126.6,72.51 126.74,72.65 127.01,72.65 127.15,72.51 127.15,72.33 127.28,72.21 127.59,72.21 127.71,72.33 127.71,72.51 127.85,72.65 128.13,72.65 128.27,72.51 128.27,72.37 128.4,72.24 128.93,72.24 129.06,72.37 129.06,72.65 128.85,72.86 v2(128.85,73.1)
  IN1 w0.089: v2(173.82,56.16) 173.14,55.48 170.19,55.48 170.01,55.66 168.77,55.66 168.68,55.57 168.28,55.57 165.68,58.16 165.68,61.86 165.05,62.5
  IN1 w0.147: v2(128.85,73.1) 128.87,73.12 128.87,73.14 129.39,73.66 130.35,73.66 133.15,76.46 138.46,76.46 139.03,75.9 144.34,75.9 144.72,75.52 150.41,75.52 151.85,74.08 151.85,73.23 152.04,73.04 152.39,73.04 152.66,72.77 152.66,72.42 154.75,70.33 156.52,70.33 161.11,65.74 161.8,65.74 165.05,62.5
  BOTTOM w0.14: v2(128.85,73.1) 128.85,72.97 128.5,72.61 127.98,72.61 127.52,72.15 126.77,72.15 126.15,71.54 126.15,71.17 125.65,70.67 JDIMM2.215
DDR_A_D50: length 72.7
  TOP w0.089: v2(169.89,54.51) 169.96,54.44 173.09,54.44 CPU1.R4
  TOP w0.14: v2(128.31,71.49) 128.31,71.48 127.87,71.04 127.87,70.72 128.02,70.57 128.48,70.57 128.73,70.82 128.94,70.82 129.07,70.7 129.07,70.4 129.2,70.28 130.43,70.28 130.56,70.15 130.56,69.8 130.68,69.67 131,69.67 131.13,69.8 131.13,70.2 131.25,70.33 131.58,70.33 131.71,70.2 131.71,69.8 131.84,69.67 JDIMM1.211
  IN1 w0.089: v2(169.89,54.51) 168.83,54.51 165.13,58.21 165.13,61.35 164.52,61.96
  IN1 w0.147: 164.52,61.96 161.49,64.99 160.8,64.99 156.21,69.58 154.44,69.58 151.1,72.92 151.1,73.77 150.35,74.51 143.08,74.51 142.68,74.11 142.42,74.11 142.3,74.24 142.3,75.02 142.17,75.15 137.3,75.15 136.75,75.7 134.06,75.7 133.51,75.15 132.9,75.15 129.74,71.99 128.29,71.99 128.15,71.85 128.15,71.65 v2(128.31,71.49)
  BOTTOM w0.14: v2(128.31,71.49) 128.85,70.95 130.38,70.95 131.41,69.92 JDIMM2.212
DDR_A_D51: length 72.8
  TOP w0.089: v2(173.18,56.16) 173.62,55.72 CPU1.P4
  TOP w0.14: v2(128.59,74.89) 128.59,75.18 128.71,75.3 129.88,75.3 130.01,75.43 130.01,75.6 129.89,75.73 128.79,75.73 128.66,75.85 128.66,76.04 128.8,76.17 130.27,76.17 131.48,74.96 131.48,74.68 131.99,74.17 JDIMM1.229
  IN1 w0.089: v2(173.18,56.16) 172.68,55.65 170.85,55.65 166.69,59.82 166.69,60.23
  IN1 w0.147: v2(128.59,74.89) 129,75.3 129.82,75.3 133.33,78.81 138.52,78.81 138.9,78.43 142.38,78.43 143.38,77.43 143.72,77.43 143.87,77.58 143.87,77.63 143.99,77.76 144.33,77.76 144.45,77.63 144.45,77.58 144.6,77.43 144.98,77.43 145.36,77.06 151.05,77.06 153.39,74.72 153.39,74.37 155.89,71.87 157.16,71.87 161.75,67.28 162.44,67.28 166.69,63.03 166.69,60.23
  BOTTOM w0.14: v2(128.59,74.89) 129.03,75.33 130.06,75.33 131.46,73.92 JDIMM2.228
DDR_A_D52: length 70.6
  TOP w0.089: CPU1.R5 174.61,55.31 174.61,56.04 v2(174.49,56.17)
  TOP w0.14: JDIMM1.215 131.85,70.67 131.73,70.8 131.73,71.36 131.6,71.48 131.36,71.48 131.23,71.36 131.23,70.65 131.1,70.52 130.81,70.52 130.68,70.65 130.68,71.27 130.56,71.39 130.26,71.39 130.14,71.27 130.14,71.03 130.01,70.9 129.72,70.9 129.59,71.03 v2(129.59,71.48)
  IN1 w0.089: v2(174.49,56.17) 172.47,54.15 168.94,54.15 164.94,58.15 164.94,61.01 164.25,61.7
  IN1 w0.147: 164.25,61.7 161.33,64.61 160.65,64.61 156.05,69.21 154.28,69.21 150.72,72.76 150.72,73.61 150.2,74.14 143.23,74.14 143.11,74.01 143.11,73.87 142.98,73.74 142.05,73.74 141.92,73.87 141.92,74.64 141.79,74.77 137.15,74.77 136.6,75.32 135.73,75.32 135.58,75.17 135.58,75.06 135.45,74.94 135.12,74.94 134.99,75.06 134.99,75.17 134.84,75.32 134.22,75.32 133.67,74.77 133.05,74.77 129.78,71.5 129.61,71.5 v2(129.59,71.48)
  BOTTOM w0.14: v2(129.59,71.48) 130.67,71.48 131.23,70.92 JDIMM2.216
DDR_A_D53: length 71.4
  TOP w0.089: CPU1.P2 172.34,55.84 v2(172.01,56.17)
  TOP w0.14: v2(127.27,74.86) 127.39,74.86 127.58,74.67 127.58,74.37 127.49,74.27 127.02,74.27 126.75,74.54 126.75,75.06 126.62,75.19 126.37,75.19 126.24,75.06 126.24,74.91 126.04,74.7 126.04,74.49 126.62,73.9 126.62,73.72 126.44,73.54 126.26,73.54 126.12,73.67 125.86,73.67 125.69,73.5 125.69,73.13 125.49,72.92 JDIMM1.224
  IN1 w0.089: 167.05,60.23 167.05,59.71 170.93,55.83 171.67,55.83 v2(172.01,56.17)
  IN1 w0.147: v2(127.27,74.86) 127.27,75.08 127.87,75.68 129.66,75.68 133.51,79.52 133.65,79.52 133.77,79.4 133.77,79.31 133.9,79.19 134.26,79.19 134.38,79.31 134.38,79.54 134.51,79.67 135.7,79.67 136.18,79.19 138.68,79.19 139.06,78.81 142.53,78.81 143.09,78.25 143.38,78.25 143.53,78.4 143.53,78.49 143.66,78.62 143.99,78.62 144.12,78.49 144.12,78.4 144.27,78.25 144.51,78.25 144.82,78.56 145.19,78.56 146.3,77.45 151.19,77.45 153.76,74.87 153.76,74.53 156.04,72.24 157.31,72.24 161.91,67.65 162.59,67.65 167.05,63.19 167.05,60.23
  BOTTOM w0.14: JDIMM2.225 125.58,73.17 v2(127.27,74.86)
