# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AC_PRESENT: length 114.1
  TOP w0.102: v2(199.09,117.27) 199.11,117.26 199.11,117.25 198.65,117.71 198.65,118.77 199.71,119.84 199.71,121.89 v2(199.8,121.98) ; v2(195.7,121.63) 195.7,121.83 196.7,122.83 198.54,122.83 199.05,123.34 199.05,124.29 198.48,124.86 197.21,124.86 196.9,125.17 196.9,126.07 198.26,127.44 198.26,130.97 196.9,132.33 196.65,132.33 v1(194.67,134.31) 194.67,134.99 194.22,135.44 v2(193.46,135.44) ; v2(126.7,131.47) 126.32,131.09 126.32,129.01 127.11,128.23 RH85.2
  IN2 w0.127: v2(199.8,121.98) 198.6,121.98 197.61,120.99 196.57,120.99 196.31,121.25 196.31,121.27 195.95,121.63 v2(195.7,121.63) ; v2(193.46,135.44) 193.27,135.25 192,135.25 191.22,134.47 188.98,134.47 188.28,135.17 186.99,135.17 186.51,135.66 184.3,135.66 183.93,135.29 183,135.29 182.44,135.85 180.45,135.85 179.86,135.26 177,135.26 176.26,136 174.28,136 173.39,136.89 170.6,136.89 170.13,137.37 169.1,137.37 168.47,136.75 167.98,136.75 166.98,135.75 166.32,135.75 165.36,136.7 162.27,136.7 160.01,138.96 157.61,138.96 157.08,139.49 157.08,139.92 156.11,140.89 153.76,140.89 152.21,139.34 149.61,139.34 148.84,138.58 142.25,138.58 139.55,135.88 133.5,135.88 132.06,134.44 132.06,133.18 131.63,132.75 128.89,132.75 128.12,131.97 127.14,131.97 126.7,131.53 v2(126.7,131.47)
  BOTTOM w0.102: U51.A54 199.25,117.11 199.09,117.27 v2(199.09,117.27) ; v2(195.7,121.63) 195.69,121.64 195.69,121.72 R835.2
AC_PRESENT_R: length 5.7
  TOP w0.089: 128.24,126.2 128.24,125.5 128.6,125.14 128.6,124.41 128.31,124.12 128.31,123.78 128.39,123.7 128.39,123.05 128.32,122.99 128.32,122.88 128.04,122.6 UH1.BB15
  TOP w0.102: 128.24,126.2 128.24,126.59 v1(128.2,126.64) 128.02,126.82 RH85.1
ACAV_DOCK_SRC#: length 264.2
  TOP w0.254: PU105.1 336.96,39.82 336.78,39.64 336.03,39.64 335.74,39.93 335.64,39.93 335.26,40.3 335.26,42.35 333.75,43.87 333.75,44.76 v2(332.85,45.65) 332.79,45.65 332.37,46.07 332.37,46.7 332.96,47.28 PR1013.2 PR1017.1
  IN2 w0.254: v2(167.75,154.73) 169.11,153.37 184.75,153.37 188.33,149.79 190.42,149.79 191.84,148.37 195.19,148.37 198.07,145.49 202.54,145.49 203.73,144.3 203.73,143.52 204.18,143.06 204.94,143.06 206.43,144.55 210.91,144.55 213.26,142.2 225.72,142.2 v2(237.02,130.89) ; v2(241.27,90.02) 241.68,90.02 244.3,87.4 244.3,85.47 243.78,84.94 243.78,83.87 244.83,82.82 247.82,82.82 253.05,77.59 253.05,76.68 258.93,70.8 258.93,68.48 260.92,66.49 260.92,64.75 277.13,48.54 281.64,48.54 285.59,44.6 291.24,44.6 294.49,41.35 294.49,40.65 297.65,37.5 299.81,37.5 301.04,38.73 308.4,38.73 309.97,40.3 315.42,40.3 315.98,40.86 320.24,40.86 321.18,39.92 323.51,39.92 326.23,42.64 330.83,42.64 331.45,43.26 331.45,44.25 v2(332.85,45.65)
  IN4 w0.254: v2(244.64,96.31) 244.64,96.31 245.61,97.28 245.61,103.42 244.55,104.48 244.55,106.69 243.69,107.55 243.69,110.06 243.18,110.56 243.18,113.49 242.37,114.31 242.37,125.55 v2(237.02,130.89)
  BOTTOM w0.254: JDOCK1.42 167.75,154.9 167.75,154.9 v2(167.75,154.73) ; v2(244.64,96.31) 244.64,96.15 242.76,94.27 242.76,92.07 v1(242.56,91.86) 241.87,91.18 241.87,90.57 241.32,90.02 v2(241.27,90.02)
ACAV_IN: length 253.4
  TOP w0.102: v2(219.63,76.72) 218.98,76.07 U17.1
  TOP w0.254: PR721.1 PR720.1 PR722.2 274.73,38.86 274.7,38.88 v2(274.7,39.18) ; PR1021.1 v2(336,47.58)
  IN2 w0.127: v2(204.24,117.27) 204.68,117.27 205.29,117.88 205.42,117.88 206.03,118.49 209.35,118.49 210.04,117.8 211.04,117.8 211.25,118.01 211.89,118.01 212.86,118.98 215.22,118.98 217.22,116.98 218.42,116.98 219.33,116.07 221.87,116.07 222.87,115.08 223.05,114.89 223.05,113.43 225.53,110.95 225.53,110.82 225.89,110.46 227.17,110.46 229.84,107.78 229.84,103.65 225.34,99.14 225.34,97.58 225.61,97.31 225.61,95.26 225.29,94.94 225.29,93.54 227.88,90.96 227.88,88.08 227.78,87.98 v2(227.78,87.94) ; v2(219.63,76.72) 219.71,76.8 233.48,76.8 236.31,73.96 237.29,73.96 240.57,70.68 243.75,70.68 246.93,67.51 246.93,60.01 250.86,56.08 255.2,56.08 261.07,50.21 263.69,50.21 268.36,45.54 268.36,43.77 272.6,39.52 274.35,39.52 v2(274.7,39.18) 275.87,39.18 276.21,38.83 276.21,34.73 277.64,33.3 277.64,32.27 277.64,32.27 277.64,30.17 280.1,27.7 287.77,27.7 292.41,23.06 302.99,23.06 303.8,23.87 307.15,23.87 309.42,21.6 325.32,21.6 326.09,22.37 330.42,22.37 331.37,23.32 335.35,23.32 337.54,25.52 337.54,33.74 337.21,34.08 337.21,46.01 336,47.22 v2(336,47.58)
  BOTTOM w0.102: v2(219.63,76.72) 220.88,77.97 v1(222.14,77.97) 225.66,81.49 225.66,86.63 226.92,87.9 227.74,87.9 v2(227.78,87.94) ; U51.A64 204.25,117.26 v2(204.24,117.27)
ACAV_IN_NB: length 263.5
  TOP w0.102: v2(266.74,32.61) 266.74,32.43 266.38,32.07 v1(266.38,29.93) 266.38,27.91 267.09,27.2 PR743.2
  TOP w0.254: PR1019.2 333.34,59.52 332.83,60.03 v2(332.77,60.03)
  IN1 w0.109: v2(312.93,25.57) 312.75,25.57 312.34,25.99 300.4,25.99 299.79,25.38 299.79,24.62 298.8,23.63 286.12,23.63 279.12,30.63 279.12,35.9 278.36,36.66 276.64,36.66 274.29,39.01 274.29,39.2 274.09,39.4 273.23,39.4 272.74,38.91 272.74,34.8 269.27,31.33 267.25,31.33 266.74,31.83 v2(266.74,32.61) 266.95,32.82 267.86,32.82 268.33,33.29 268.33,37.45 265.22,40.57 265.22,43.03 263.62,44.63 262.76,44.63 261.43,45.96 260.83,45.96 254.74,52.05 254.74,52.34 253.08,54 252.01,54 244.67,61.34 244.67,71.13 239.88,75.92 239.88,77.26 236.45,80.69 229.37,80.69 227.22,82.84 227.22,85.2 224.49,87.93 224.49,96.93 219.88,101.53 219.57,101.53 218.71,102.39 218.71,103.01 215.68,106.04 v2(215.68,106.35)
  IN2 w0.127: v2(203.41,107.17) 203.98,106.6 204.82,106.6 205.45,107.23 209.65,107.23 209.86,107.23 210.78,106.32 215.64,106.32 v2(215.68,106.35) ; v2(332.77,60.03) 333.97,61.23 339.45,61.23 340.2,60.49 340.2,59.7 343.9,55.99 343.9,51.54 341.49,49.13 337.48,49.13 336.38,48.03 335.29,48.03 334.91,47.64 334.91,43.52 335.3,43.13 335.3,40.49 336.06,39.72 336.06,30.82 335.7,30.46 335.7,26.78 334.84,25.92 333.32,25.92 333.01,26.22 332.33,26.22 331.4,27.15 328.46,27.15 327.04,25.73 318,25.73 317.91,25.64 315.65,25.64 315.2,26.09 313.45,26.09 v2(312.93,25.57)
  BOTTOM w0.102: v2(203.41,107.17) 203.5,107.08 U51.B20
ACAVDK_SRC: length 4.8
  TOP w0.102: PR1017.2 332.96,49.1 332.5,48.64 332.5,47.25 331.93,46.69 v1(331.93,46.55)
  TOP w0.254: PU1001.4 333.2,49.36 PR1017.2
ACAVIN: length 2
  TOP w0.254: PU1001.8 335.2,50.27 v2(335.72,49.75) 336,49.47 PR1021.2
ADC_BYPASS: length 2.7
  TOP w0.102: C36.1 253.6,85.82 v1(253.16,86.26) 252.61,86.8 U8.44
ADC_M: length 21.5
  TOP w0.102: v2(251.95,96.22) 252.36,95.81 U8.9 255.83,95.81 R410.2 R411.2 ; U8.42 251.01,88.84 v2(249.34,90.51) 249.28,90.44 249.28,89.17 248.96,88.86 247.37,88.86 246.99,88.48 246.99,87.61 U8.37
  BOTTOM w0.102: v2(249.34,90.51) 250.04,91.2 250.37,91.2 v1(251.27,92.1) 251.62,92.45 251.62,93.34 251.95,93.67 v2(251.95,96.22)
ALW_PWRGD_3V_5V: length 223.8
  TOP w0.102: v2(341.85,31.35) 342.05,31.55 v2(344.11,31.55) ; UC4.2 192.3,104.18 193.4,103.08 196.32,103.08 196.57,102.83 v2(196.57,102.32)
  IN2 w0.127: v2(327.85,49.72) 327.63,49.5 325.55,49.5 323.31,47.26 321.27,47.26 320.66,46.65 319.68,46.65 319.07,47.26 318.72,47.26 316.03,49.96 312.55,49.96 310.28,47.68 296.18,47.68 294.88,48.98 294.67,48.98 294.67,48.98 285.99,48.98 283.95,51.02 278.98,51.02 263.4,66.6 263.4,67.52 261.47,69.44 261.47,71.78 258.28,74.98 258.28,78.52 255.12,81.68 255.12,85.2 253.95,86.37 253.95,89.16 251.25,91.86 251.25,92.09 250.35,92.99 250.2,92.99 249.79,93.4 249.79,96.16 248.58,97.37 248.58,101.68 247.54,102.72 v2(247.51,102.72) ; v2(226.81,109.37) 227.52,108.66 227.52,107.37 225.83,105.68 223.58,105.68 222.79,104.89 222.03,104.89 220.3,103.16 220.3,101 218.4,99.1 212.23,99.1 210.65,100.68 208.98,100.68 208.64,101.02 207.82,101.02 207.24,100.44 205.39,100.44 204.81,101.01 202.56,101.01 202.18,101.39 201.7,101.39 201.51,101.58 201.1,101.58 200.85,101.83 200.85,102.34 200.53,102.66 198.97,102.66 198.92,102.71 196.97,102.71 v2(196.57,102.32)
  BOTTOM w0.102: v2(247.51,102.72) 247.1,102.72 246.22,103.6 245.6,103.6 244.76,104.45 244.76,106.05 241.03,109.77 227.22,109.77 v2(226.81,109.37) ; PR108.1 344.21,31.45 v2(344.11,31.55) ; v2(341.85,31.35) 340.42,31.35 336.54,35.23 336.54,43.7 336.08,44.15 335.55,44.15 334.98,44.72 334.98,46.43 334.08,47.33 333.62,47.33 331.23,49.72 v1(329.29,49.72) v2(327.85,49.72)
ALWON: length 211.8
  TOP w0.102: v2(343.17,30.72) 343.17,30.13 v1(344.17,29.13) 345.48,27.82 346.14,27.82 PR113.1
  IN2 w0.127: v2(333.69,48.37) 333.12,48.94 329.87,48.94 329.35,48.42 328.12,48.42 325.57,45.87 322.99,45.87 320.64,43.52 318.01,43.52 317.1,44.43 315.64,44.43 313.82,46.25 310.75,46.25 310.46,45.96 296.47,45.96 295.41,47.01 286.5,47.01 283.51,50 278.56,50 262.38,66.18 262.38,67.09 260.39,69.08 260.39,71.42 257.16,74.65 257.16,75.92 254.08,79.01 254.08,84.81 252.94,85.95 252.94,88.56 250.32,91.18 250.25,91.18 248.26,93.17 v2(248.26,95.55)
  IN4 w0.109: v2(202.04,117.81) 203.7,117.81 204.06,118.16 204.95,118.16 204.97,118.14 205.8,118.14 206.14,118.48 209.86,118.48 210.59,119.21 210.94,119.21 212.54,117.61 212.54,117.22 213.33,116.43 215.48,116.43 216.7,115.21 217.83,115.21 219.69,113.35 219.69,112.09 225.97,105.81 229.11,105.81 230.66,104.26 236.68,104.26 237.24,104.82 237.24,105.33 237.8,105.89 239.07,105.89 239.58,105.38 239.93,105.38 241.64,103.67 241.64,102.56 242.5,101.7 242.5,99.58 242.1,99.18 242.1,97.51 242.58,97.03 242.58,96.75 243.75,95.59 248.23,95.59 v2(248.26,95.55)
  BOTTOM w0.102: v2(343.17,30.72) 343.17,31.38 342.68,31.86 340.23,31.86 336.77,35.32 336.77,46.13 336.36,46.54 335.52,46.54 333.69,48.37 v2(333.69,48.37) ; v2(202.04,117.81) 202.04,117.81 202.04,117.81 202.42,117.43 202.42,117.05 202.25,116.88 U51.A60
AUD_AZACPU_SCLK: length 162.6
  TOP w0.089: 141.76,113.51 141.5,113.51 141.27,113.75 v2(138.92,113.75) ; CPU1.G27 191.07,60.81 v2(191.36,61.1)
  TOP w0.102: RH38.1 144.92,118.94 145.53,118.33 145.53,115.34 v1(144.28,114.09) 143.7,113.51 141.76,113.51
  IN3 w0.089: v2(138.92,113.75) 137.22,112.05 137.22,106.17 137.62,105.77 137.62,99.6 137.56,99.55 137.56,99.28 ; v2(191.36,61.1) 190.54,61.1 190.19,60.75 189.46,60.75 189.39,60.83 189.39,63.88 188.47,64.79 180.7,64.79 180.5,64.99 178.73,64.99 177.21,66.5 173.97,66.5 172.06,68.41 167.92,68.41
  IN3 w0.127: 167.92,68.41 159.59,68.41 159.46,68.54 159.46,70.76 159.33,70.89 159.08,70.89 158.95,70.76 158.95,68.54 158.83,68.41 158.57,68.41 158.44,68.54 158.44,70.76 158.32,70.89 158.06,70.89 157.94,70.76 157.94,68.54 157.81,68.41 157.56,68.41 157.43,68.54 157.43,70.76 157.3,70.89 157.05,70.89 156.92,70.76 156.92,68.54 156.79,68.41 156.54,68.41 156.41,68.54 156.41,70.76 156.29,70.89 156.03,70.89 155.9,70.76 155.9,68.54 155.78,68.41 155.52,68.41 155.4,68.54 155.4,70.76 155.27,70.89 155.02,70.89 154.89,70.76 154.89,68.54 154.76,68.41 154.51,68.41 154.38,68.54 154.38,70.76 154.25,70.89 154,70.89 153.87,70.76 153.87,66.44 153.75,66.31 153.49,66.31 153.36,66.44 153.36,69.81 153.24,69.93 152.98,69.93 152.86,69.81 152.86,66.44 152.73,66.31 152.48,66.31 152.35,66.44 152.35,68.28 152.22,68.41 151.97,68.41 151.84,68.28 151.84,66.44 151.71,66.31 151.46,66.31 151.33,66.44 151.33,68.28 151.21,68.41 150.95,68.41 150.82,68.28 150.82,66.44 150.7,66.31 150.44,66.31 150.32,66.44 150.32,68.28 150.19,68.41 149.94,68.41 149.81,68.28 149.81,66.44 149.68,66.31 149.43,66.31 149.3,66.44 149.3,68.28 149.17,68.41 146.6,68.41 142.33,72.68 142.33,76.22 141.79,76.77 141.79,81.57 141.33,82.02 141.33,85.08 137.65,88.76 137.65,92.98 137.46,93.17 137.46,96.5 137.16,96.79 137.16,97.67 137.56,98.07 137.56,99.28
AUD_AZACPU_SCLK_R: length 10.4
  TOP w0.089: 141.76,118.74 141.05,118.74 140.87,118.56 137.19,118.56 136.52,117.89 134.67,117.89 134.33,117.55 UH1.AM2
  TOP w0.102: 141.76,118.74 v1(142.8,118.74) 143.77,118.74 RH38.2
AUD_AZACPU_SDI: length 16.7
  TOP w0.089: v2(192.13,60.47) 192.2,60.47 CPU1.G29
  IN2 w0.089: v2(192.13,60.47) 192.13,60.41 192.57,59.96 193.02,59.96 193.33,60.28 193.33,60.65 193.34,60.65 193.34,64.66 192.54,65.46 192.54,68 191.94,68.6 191.94,70.91
  IN2 w0.127: v2(192.32,71.39) 191.94,71.01 191.94,70.91
  BOTTOM w0.102: v2(192.32,71.39) 192.24,71.32 RC66.1
AUD_AZACPU_SDI_R: length 157
  TOP w0.089: UH1.AN2 134.54,118.03 134.59,118.08 135.21,118.08 135.34,118.21 136.52,118.21 137.21,118.89 137.93,118.89
  TOP w0.102: 137.93,118.89 139.42,118.89 139.62,119.08 140.99,119.08 141.3,119.4 142.37,119.4 v2(143.21,120.24)
  IN4 w0.109: v2(143.21,120.24) 143.26,120.29 145.83,120.29 146.18,120.64 151.13,120.64 151.32,120.45 152.29,120.45 152.54,120.69 152.54,120.71 152.9,121.08 162.63,121.08 162.78,121.22 163.19,121.22 163.74,120.67 163.74,119.84 164.04,119.55 165.94,119.55 167.58,117.9 171.79,117.9 172.39,117.29 173.23,117.29 173.66,116.87 174.97,116.87 175.44,116.4 183.45,116.4 183.78,116.73 183.78,117.46 184.4,118.09 187.76,118.09 188.44,117.41 192.21,117.41 192.47,117.14 194.73,117.14 195.63,116.25 196.28,116.25 196.89,116.86 204.4,116.86 205.1,117.56 210.99,117.56 211.18,117.75 211.7,117.75 211.99,117.46 211.99,117.07 213.12,115.94 215.28,115.94 216.51,114.7 v2(217.46,114.7)
  BOTTOM w0.102: RC66.2 189.65,72.6 190.48,73.43 190.48,75.36 194.42,79.3 194.42,80.78 195.95,82.32 199.41,82.32 200.81,80.91 201.51,80.91 v1(203.96,83.35) 204.12,83.52 204.12,84.1 209.54,89.52 210.14,89.52 211.34,90.72 215.04,90.72 216.58,92.27 216.58,93.56 217.19,94.17 217.19,94.61 217.01,94.79 217.01,97.07 216.55,97.53 216.55,98.34 216.91,98.7 216.91,99.93 217.16,100.18 217.38,100.18 218.61,101.4 218.61,102.74 218.79,102.92 218.93,103.06 218.93,104.03 218.93,104.03 218.93,104.47 219.55,105.09 220.25,105.09 220.54,105.38 220.54,106.03 221.24,106.73 221.24,107.81 218.99,110.06 218.84,110.21 218.84,112.03 217.99,112.89 217.99,114.18 v2(217.46,114.7)
AUD_AZACPU_SDO: length 166.1
  TOP w0.089: v2(139.35,114.17) 139.42,114.24 141.64,114.24 141.76,114.12 ; CPU1.G25 189.3,60.81 v2(188.99,60.5)
  TOP w0.102: 141.76,114.12 143.44,114.12 v1(144.78,115.45) 144.92,115.59 RH39.1
  IN3 w0.089: 170.29,65.49 172.51,65.49 173.08,66.06 176.57,66.06 177.82,64.81 180.42,64.81 180.76,64.47 188.13,64.47 188.57,64.03 188.57,60.89 188.96,60.5 v2(188.99,60.5) ; 136.93,99.28 136.93,100.58 137.44,101.09 137.44,105.69 137.04,106.1 137.04,106.24 137.04,112.25 138.28,113.49 138.28,113.88 138.64,114.24 139.29,114.24 v2(139.35,114.17)
  IN3 w0.127: 136.93,99.28 136.93,98.33 136.53,97.93 136.53,96.24 136.57,96.2 136.57,90.02 137.01,89.58 137.01,88.5 140.69,84.81 140.69,81.76 141.03,81.43 141.03,75.83 141.64,75.21 141.64,72.48 148.43,65.68 154.68,65.68 154.81,65.81 154.81,67.65 154.94,67.77 155.19,67.77 155.32,67.65 155.32,65.81 155.44,65.68 155.7,65.68 155.83,65.81 155.83,67.65 155.95,67.77 156.21,67.77 156.33,67.65 156.33,65.81 156.46,65.68 156.71,65.68 156.84,65.81 156.84,67.65 156.97,67.77 157.22,67.77 157.35,67.65 157.35,65.81 157.48,65.68 157.73,65.68 157.86,65.81 157.86,67.65 157.98,67.77 158.24,67.77 158.37,67.65 158.37,65.81 158.49,65.68 158.75,65.68 158.87,65.81 158.87,67.65 159,67.77 159.25,67.77 159.38,67.65 159.38,65.81 159.51,65.68 159.76,65.68 159.89,65.81 159.89,67.65 160.02,67.77 160.27,67.77 160.4,67.65 160.4,65.81 160.52,65.68 160.78,65.68 160.91,65.81 160.91,67.65 161.03,67.77 161.29,67.77 161.41,67.65 161.41,65.81 161.54,65.68 161.79,65.68 161.92,65.81 161.92,67.65 162.05,67.77 162.3,67.77 162.43,67.65 162.43,65.81 162.56,65.68 162.81,65.68 162.94,65.81 162.94,67.65 163.06,67.77 163.32,67.77 163.45,67.65 163.45,65.81 163.57,65.68 163.83,65.68 163.95,65.81 163.95,67.65 164.08,67.77 164.33,67.77 164.46,67.65 164.46,65.81 164.59,65.68 164.84,65.68 164.97,65.81 164.97,67.65 165.1,67.77 165.35,67.77 165.48,67.65 165.48,65.81 165.6,65.68 165.86,65.68 165.99,65.81 165.99,67.65 166.11,67.77 166.37,67.77 166.49,67.65 166.49,65.81 166.62,65.68 166.87,65.68 167,65.81 167,67.65 167.13,67.77 167.38,67.77 167.51,67.65 167.51,65.81 167.64,65.68 167.97,65.68 168.1,65.81 168.1,67.65 168.23,67.77 168.48,67.77 168.61,67.65 168.61,65.81 168.73,65.68 169.15,65.68 169.27,65.81 169.27,66.57 169.4,66.7 169.65,66.7 169.78,66.57 169.78,65.62 169.91,65.49 170.29,65.49
AUD_AZACPU_SDO_R: length 9.7
  TOP w0.089: 137.2,118.1 136.66,117.56 134.91,117.56 UH1.AM1
  TOP w0.102: 137.2,118.1 137.2,118.1 137.43,118.33 140.49,118.33 v1(140.59,118.24) 140.7,118.13 142.71,118.13 142.76,118.08 RH39.2
AUD_HP_NB_SENSE: length 191.5
  TOP w0.102: v2(317.64,26.31) 317.64,25.5 317.54,25.4 v1(317.43,25.4) 317.01,25.4 316.12,26.3 JIO1.89
  IN2 w0.127: v2(178.9,104.6) 179.43,104.07 179.43,103.82 181.7,101.56 182.33,101.56 182.81,101.07 182.81,100.15 183.81,99.14 185.24,99.14 186.19,98.19 190.63,98.19 191.58,97.24 192.77,97.24 193.44,96.57 196.98,96.57 197.6,95.94 198.73,95.94 199.09,95.59 200.99,95.59 202.57,94 203.52,94 204.89,92.63 204.89,86.64 206.8,84.73 207.97,84.73 211.1,81.6 212.16,81.6 213.7,80.06 219.83,80.06 221.04,78.84 237.13,78.84 239.83,76.14 239.83,75.57 240.92,74.48 240.92,73.25 241.66,72.51 244.51,72.51 245.24,71.78 247.63,71.78 249.03,70.37 249.03,66.69 248.45,66.12 248.45,60.59 251.48,57.57 258.32,57.57 274.92,40.97 276.11,40.97 277.82,39.26 277.82,39.22 278.06,38.97 278.64,38.97 280.41,37.2 284.57,37.2 287.13,34.64 287.13,32.41 289.28,30.25 289.28,28.33 292.19,25.41 297.43,25.41 298.09,26.08 303.37,26.08 304.14,25.32 311.47,25.32 312.75,26.6 312.96,26.6 312.96,26.6 315.89,26.6 316.28,26.21 317.53,26.21 v2(317.64,26.31)
  BOTTOM w0.102: v2(178.9,104.6) 179.05,104.75 U46.A41
AUD_NB_MUTE#: length 202.3
  TOP w0.102: v2(318.05,26.82) 319,27.76 v1(319,29.26) 319,29.46 319.59,30.06 319.59,33.35 319.04,33.9 319.04,34.7 318.47,35.26 317.73,35.26 317.2,35.8 JIO1.51
  IN2 w0.127: v2(179.96,104.59) 180.41,104.15 180.41,103.22 181.82,101.81 182.43,101.81 183.06,101.18 183.06,100.25 183.92,99.4 185.34,99.4 186.29,98.45 190.73,98.45 191.68,97.49 192.87,97.49 193.55,96.82 196.58,96.82 197.1,97.34 198.08,97.34 198.37,97.05 198.37,96.61 198.78,96.2 198.84,96.2 199.19,95.84 201.09,95.84 202.68,94.25 203.62,94.25 205.15,92.73 205.15,86.75 206.91,84.98 208.07,84.98 211.21,81.85 212.27,81.85 213.81,80.31 219.94,80.31 221.16,79.09 237.24,79.09 240.08,76.24 240.08,75.68 241.17,74.59 241.17,73.36 241.76,72.76 244.61,72.76 245.35,72.03 247.73,72.03 249.28,70.48 249.28,66.59 248.71,66.01 248.71,60.7 251.59,57.82 258.43,57.82 275.03,41.22 277.62,41.22 280.02,38.82 280.02,37.95 280.52,37.45 284.76,37.45 288.6,33.61 288.6,31.29 289.53,30.36 289.53,28.43 292.3,25.67 297.32,25.67 297.99,26.33 303.48,26.33 304.24,25.57 311.36,25.57 313.47,27.68 317.35,27.68 318.05,26.98 v2(318.05,26.82)
  BOTTOM w0.102: U46.A39 180.05,104.68 v2(179.96,104.59)
AUD_PWR_EN: length 2.2
  TOP w0.089: UH1.BE21 125.63,124.32 125.63,125.09 125.79,125.24 T201.1
AUX_EN_WOWL: length 58.7
  TOP w0.102: R840.1 214.99,123.47 214.99,123.91 v1(214.5,124.4) 213.67,125.22 v2(213.67,125.43)
  IN4 w0.109: v2(214.12,114.94) 213.43,114.94 212.02,116.35 211.34,116.35 210.67,117.02 205.26,117.02 204.61,116.37 197.09,116.37 196.48,115.76 195.83,115.76 195.4,115.32 193.2,115.32 191.61,116.92 188.24,116.92 188.12,117.04 185.04,117.04 183.9,115.89 176.78,115.89 175.71,114.82 v2(175.71,114.3)
  BOTTOM w0.102: v2(175.71,114.3) 175.67,114.26 U46.B67 ; v2(213.67,125.43) 214.96,124.14 214.96,115.42 214.47,114.93 214.12,114.93 214.12,114.94 v2(214.12,114.94)
AUX_EN_WOWL_R: length 4.6
  TOP w0.102: 217.03,122.59 216.99,122.59 R840.2
  TOP w0.203: R723.1 219.45,122.59 v1(219.49,122.54) 219.5,122.53 UZ25.3
  TOP w0.254: R820.2 R840.2 ; 217.03,122.59 R723.1
BAT1_LED#: length 176.4
  TOP w0.508: R131.1 310.22,9.07 v1(310.5,9.34) 310.5,10.12 306.6,14.01 303.8,14.01 300.39,17.42 300.39,18.07 300.08,18.38 300.08,20.4 298.61,21.87 298.61,24.73 v2(298.49,24.85)
  IN1 w0.508: v2(215.88,110) 216.09,110 216.49,109.61 216.49,108.64 217.36,107.77 217.36,107.2 217.74,106.83 217.74,105.73 219.56,103.9 220.01,103.9 221.09,102.83 221.09,102.1 225.9,97.29 225.9,96.08 225.89,96.07 225.89,94.97 225.54,94.63 225.54,92.91 228.52,89.94 228.52,87.62 228.52,87.62 228.52,87.11 228.52,87.11 228.52,87.04 228.52,87.04 228.52,86.53 228.52,86.53 228.52,82.5 229.65,81.36 236.97,81.36 240.71,77.62 240.71,76.04 245.43,71.32 245.43,61.67 251.28,55.82 253.75,55.82 256.78,52.79 256.94,52.79 261.57,48.16 261.57,47.06 263.17,45.46 263.74,45.46 264.37,44.83 265.74,44.83 266.04,44.52 266.04,44.27 270.47,39.84 275.44,39.84 278.05,37.23 279.24,37.23 279.53,36.94 284.83,36.94 286.94,34.83 286.94,33.23 287.01,33.16 287.01,29.63 290.49,26.14 297.19,26.14 v2(298.49,24.85)
  IN2 w0.508: v2(215.88,110) 216.02,110.14 216.02,112.71 215.51,113.22 213.17,113.22 211.85,114.54 210.07,114.54 209.24,115.37 207.05,115.37 206.42,116.01 205.91,116.01 205.55,115.65 205.55,115.62 v2(205.53,115.6)
  BOTTOM w0.305: v2(205.53,115.6) 205.46,115.53 205.46,115.34 205.24,115.11 U51.B1
BAT2_LED#: length 241.3
  TOP w0.508: v1(310.65,11.83) 310.65,11.82 ; 310.65,11.82 311.38,11.09 311.38,9.23 311.18,9.03 R130.1 ; 310.65,11.82 307.82,14.65 304.06,14.65 301.03,17.68 301.03,18.34 300.71,18.65 300.71,20.72 299.35,22.08 v2(299.35,24.8)
  IN1 w0.508: v2(299.35,24.8) 299.35,25.42 295.99,28.79 291.35,28.79 288.56,31.58 288.56,34.1 285.09,37.57 279.81,37.57 278.64,38.74 277.5,38.74 275.76,40.48 271.88,40.48 268.91,43.45 268.91,45.22 267.5,46.63 264.7,46.63 264.27,46.2 263.66,46.2 262.31,47.54 262.31,49.73 258.55,53.49 256.98,53.49 254.02,56.45 251.55,56.45 246.07,61.93 246.07,71.58 241.41,76.24 241.41,77.91 237.32,82 229.91,82 229.15,82.76 229.15,87.88 229.15,87.89 229.15,90.2 226.18,93.17 226.18,94.37 226.54,94.73 226.54,99.07 v2(226.33,99.27)
  IN3 w0.508: v2(199.94,118.04) 199.98,118.08 199.98,118.13 200.12,118.27 200.12,118.6 200.05,118.66 200.05,119.82 200.07,119.83 200.07,120.62 199.75,120.94 199.75,121.16 199.14,121.77 198.12,121.77 197.29,120.94 194.48,120.94 193.79,121.62 193.79,129.28 195.43,130.92 195.43,132.8 195.3,132.93 v2(195.3,132.99) ; v2(226.33,99.27) 230.23,103.17 230.23,108.55 229.15,109.63 229.15,110.08 228.2,111.03 228.2,112.19 228.01,112.38 228.01,113.16 228.43,113.58 228.43,114.66 228.01,115.08 228.01,116.09 228.25,116.33 228.25,118.03 227.65,118.62 227.65,125.64 228.96,126.95 228.96,127.47 226.69,129.75 v2(226.69,132.13)
  IN4 w0.508: v2(195.3,132.99) 197.55,132.99 197.59,133.03 198.1,133.03 198.37,132.76 210.37,132.76 211.41,131.72 214.37,131.72 215.1,130.99 218.83,130.99 219.1,131.27 225.83,131.27 v2(226.69,132.13)
  BOTTOM w0.254: U51.A55 199.75,116.94 200.13,117.31 200.13,117.66 200.11,117.68 200.11,117.88 v2(199.94,118.04)
BATT_WHITE_LED: length 22.4
  TOP w0.508: v2(292.59,6.75) 292.55,6.79 JLED1.4 ; v2(312.33,7.44) R130.2
  IN1 w0.508: v2(292.59,6.75) 292.88,7.04 311.94,7.04 v2(312.33,7.44)
BATT_YELLOW_LED: length 23.6
  TOP w0.508: v2(310.79,3.83) 310.24,4.38 310.24,7.42 R131.2 ; JLED1.3 292.05,4.16 v2(292.38,3.83)
  IN1 w0.508: v2(292.38,3.83) 295.15,3.83 295.32,3.67 310.63,3.67 v2(310.79,3.83)
BBS_BIT0: length 19.1
  TOP w0.089: v2(120.42,119.7) 120.47,119.65 UH1.AT29
  BOTTOM w0.089: v2(120.42,119.7) 119.76,119.04 119.21,119.04 118.33,119.92 v1(118.22,119.92) 116.93,119.92 116.57,120.28 116.57,121.24 115.75,122.05 115.75,123.01 115.02,123.74 115.02,123.85 114.7,124.16
  BOTTOM w0.102: RH311.2 111.11,130.64 111.96,130.64 114.33,128.27 114.33,127.12 114.94,126.51 114.94,125.85 114.5,125.41 114.5,124.36 114.7,124.16
BC_CLK_ECE1117: length 146.8
  TOP w0.102: JKBTP1.11 292.59,30.35 292.98,29.96 293.08,29.96 293.29,30.17 293.29,30.43 v2(293.11,30.6)
  IN3 w0.127: v2(293.11,30.6) 293.22,30.72 293.22,31.15 292.66,31.71 291.62,31.71 287.88,35.44 286.86,35.44 284.14,38.15 284.14,39.83 273.08,50.89 271.61,50.89 265.98,56.53 265.98,57.51 258.49,65 258.49,68.65 254.49,72.65 254.49,85.95 253.01,87.43 253.01,88.7 252.35,89.36 251.19,89.36 250.83,89.01 248.07,89.01 247.71,89.36 244.08,89.36 243.29,88.57 240.5,88.57 239.84,89.22 236.68,89.22 233.52,92.39 219.95,92.39 219.37,92.97 218.52,92.97 218.18,92.63 217.59,92.63 217.05,93.17 217.05,94.11 217.26,94.32 217.26,94.82 217.14,94.95 216.96,94.95 216.83,95.07 216.83,95.33 216.96,95.45 217.14,95.45 217.26,95.58 217.26,96.3 214.93,98.63 214.93,101.56 214.74,101.75 214.74,102.15 212.95,103.94 212.84,103.94 212.71,103.81 212.71,103.08 212.58,102.95 212.33,102.95 212.2,103.08 212.2,103.81 212.08,103.94 210.72,103.94 209.3,102.52 207.02,102.52 206.45,102.52 205.72,101.79 205.55,101.62 205.07,101.62 204.87,101.82 204.87,102.59 204.07,103.39 204.01,103.39 203.1,104.31 v2(203.1,104.66)
  BOTTOM w0.102: U51.A20 202.75,105.01 v2(203.1,104.66)
BC_CLK_ECE5048: length 25
  IN1 w0.109: v2(194.31,112.19) 194.33,112.19 194.35,112.21 194.43,112.21 194.61,112.03 194.61,111.95 194.72,111.84 196.28,111.84 196.38,111.74 196.38,111.52 196.28,111.41 194.72,111.41 194.61,111.3 194.61,110.76 194.46,110.62 193.38,110.62 193.17,110.4 193.17,109.28 193.46,108.99 193.46,108.58 193.17,108.29 193.17,107 193.31,106.85 193.94,106.85 194.18,107.09 194.18,107.6 194.29,107.72 194.48,107.72 194.67,107.52 194.67,107.09 194.52,106.94 194.52,106.68 194.06,106.22 v2(193.89,106.22)
  IN4 w0.109: v2(186.58,107.68) 187.14,107.11 190.21,107.11 191.1,106.22 v2(193.89,106.22)
  BOTTOM w0.102: v2(194.31,112.19) 194.31,112.19 194.48,112.36 U51.A43 ; v2(186.58,107.68) 186.5,107.59 186.08,107.59 185.7,107.97 185.21,107.97 185.16,108.01 U46.A30
BC_DAT_ECE1117: length 148.7
  TOP w0.102: JKBTP1.13 292.58,29.35 292.97,29.74 293.17,29.74 293.51,30.08 293.51,30.43 v2(293.69,30.6) ; v2(203.38,108.41) 203.38,108.4 203.38,108.4 203.36,108.4 202.99,108.03 202.99,106.98 204.35,105.62 204.35,105.6 204.59,105.37 204.83,105.37 205.2,104.99 v2(205.2,104.58) 205.01,104.39 R817.2
  IN3 w0.127: v2(205.2,104.58) 205.34,104.45 205.56,104.45 206.97,103.04 207.23,102.77 209.2,102.77 210.61,104.19 213.05,104.19 214.99,102.25 214.99,101.85 215.18,101.66 215.18,98.74 217.52,96.4 217.52,94.22 217.3,94 217.3,93.28 217.7,92.88 218.07,92.88 218.42,93.23 219.47,93.23 220.06,92.64 233.62,92.64 236.78,89.48 239.95,89.48 240.6,88.82 243.18,88.82 243.98,89.62 247.82,89.62 248.18,89.26 250.73,89.26 251.08,89.62 252.46,89.62 253.27,88.81 253.27,87.53 254.74,86.06 254.74,72.75 258.74,68.75 258.74,65.11 266.23,57.61 266.23,56.63 271.72,51.15 273.18,51.15 284.4,39.94 284.4,38.26 286.96,35.69 287.99,35.69 291.72,31.96 292.77,31.96 293.48,31.25 293.48,30.82 v2(293.69,30.6)
  BOTTOM w0.102: v2(203.38,108.41) 203.38,108.4 203.38,108.4 203.18,108.4 202.92,108.15 202.92,107.4 202.94,107.38 202.92,107.37 202.92,106.97 203,106.89 U51.B21
BC_DAT_ECE5048: length 26.1
  IN1 w0.109: v2(197.08,112.54) 197.08,112.54 196.83,112.29 194.82,112.29 194.48,112.62 194.14,112.62 193.75,112.23 v2(193.75,112.01) 192.93,111.18 192.93,106.58 193.56,105.96 193.56,105.96 v2(193.91,105.61)
  IN4 w0.109: v2(183.18,107.89) 183.44,107.89 183.46,107.91 184.09,107.91 185.12,106.88 190.11,106.88 191,105.99 193.54,105.99 193.92,105.61 v2(193.91,105.61)
  BOTTOM w0.102: R814.2 193.02,111.28 v2(193.75,112.01) ; v2(183.18,107.89) 183.55,108.26 U46.B31 ; U51.B45 196.3,112.11 196.48,112.29 196.83,112.29 197.08,112.54 v2(197.08,112.54)
BC_INT#_ECE1117: length 153.5
  TOP w0.102: v2(296.02,30.75) 296.02,29.29 295.57,28.85 JKBTP1.14
  IN2 w0.127: v2(228.71,107.87) 228.65,107.93 228.65,108.12 226.99,109.79 226.21,109.79 225.21,108.79 225.21,107.65 224.96,107.4 224.61,107.4 223.84,108.16 222.96,108.16 222.59,107.79 222,107.79 221.39,107.19 221.39,106.88 220.06,105.55 219.12,105.55 218.43,104.86 216.54,104.86 215.84,104.16 212.7,104.16 212.36,104.49 206.05,104.49 205.72,104.16 204.35,104.16 v2(203.75,104.76)
  IN3 w0.127: v2(296.02,30.75) 294.3,32.47 291.93,32.47 288.12,36.28 287.19,36.28 284.9,38.57 284.9,40.15 273.39,51.66 273,51.66 259.25,65.4 259.25,68.96 255.25,72.96 255.25,86.27 253.84,87.68 253.84,88.95 252.67,90.13 250.87,90.13 250.68,89.94 248.3,89.94 245.97,92.26 v2(245.97,92.92)
  BOTTOM w0.102: U51.A19 203.25,105.26 v2(203.75,104.76) ; v2(228.71,107.87) 229,108.15 231.02,108.15 232.65,106.52 236.86,106.52 237.19,106.85 241.3,106.85 242.87,105.29 242.87,103.3 243.3,102.86 243.3,102.22 245.96,99.56 246.41,99.56 248.21,97.75 v1(248.21,97.3) 248.21,96.99 247.84,96.62 247.84,95.18 245.97,93.31 v2(245.97,92.92)
BC_INT#_ECE5048: length 32.1
  IN1 w0.109: v2(184.26,117.37) 184.26,109.63 v2(185.49,108.4)
  IN3 w0.127: v2(190.87,120.93) 190.87,119.81 193.53,117.15 193.53,115.7 195.05,114.18 195.05,111.93 194.7,111.58 v2(194.17,111.58)
  BOTTOM w0.102: U51.A42 194.67,111.86 194.39,111.58 v2(194.17,111.58) ; v2(184.26,117.37) 184.28,117.39 185.27,117.39 185.79,117.91 188.89,117.91 v1(189.17,118.2) 189.65,118.68 189.65,119.34 189.83,119.51 190.54,119.51 190.91,119.88 190.91,120.89 v2(190.87,120.93) ; v2(185.49,108.4) 185.38,108.51 U46.A29
BCM5882_ALERT#: length 166.9
  TOP w0.102: JUSH1.14 72,39.3 72.9,38.4 75.98,38.4 76.99,39.42 76.99,71.86 93.3,88.17 98.1,88.17 99.84,89.91 100.39,89.91 104.26,93.78 107.51,93.78 107.9,93.39 108.3,93.39 v2(109.12,92.57)
  IN2 w0.127: v2(109.12,92.57) 109.12,92.77 109.45,93.11 110.21,93.11 111.1,94 132.55,94 135.04,96.49 135.97,96.49 136.53,95.93 144.89,95.93 146.71,97.76 147.12,97.76 147.83,98.47 153.29,98.47 157.27,102.45 160.7,102.45 162.7,100.44 167.34,100.44 167.61,100.71 171.45,100.71 171.77,100.38 172.66,100.38 172.99,100.06 173.83,100.06 174.15,100.38 175.19,100.38 v2(175.78,99.79)
  IN3 w0.127: v2(175.37,111.72) 175.37,111.66 174.98,111.27 174.98,106.38 175.62,105.75 175.62,103.76 175.61,103.75 175.61,99.93 175.75,99.79 175.76,99.79 v2(175.78,99.79)
  BOTTOM w0.102: v2(175.37,111.72) 175.32,111.76 U46.B62
BEEP: length 173.5
  TOP w0.102: JIO1.53 v2(316.72,35.3)
  IN1 w0.109: v2(228.62,112.87) 228.78,112.87 229.25,112.4 229.58,112.4 234.82,107.17 241.37,107.17 242.29,106.24 242.29,102.72 244.23,100.78 244.23,98.54 243.09,97.4 243.09,89.16 246.48,85.78 246.48,82.16 249.46,79.17 249.46,76.79 252.48,73.77 252.48,71.26 258.21,65.53 258.21,62.59 265.67,55.13 266.98,55.13 267.17,55.13 276.05,46.25 281.28,46.25 282.69,44.85 284,44.85 284.78,44.07 288.03,44.07 289.93,42.18 301.35,42.18 306.07,37.46 308.45,37.46 308.8,37.11 311.47,37.11 313.26,35.32 316.7,35.32 v2(316.72,35.3)
  IN2 w0.127: v2(224.26,110.32) 222.36,112.22 220.86,112.22 219.21,110.57 217.54,110.57 216.64,109.67 216.64,107.22 216.2,106.77 215.34,106.77 215.15,106.59 210.87,106.59 209.97,107.49 209.96,107.49 209.72,107.73 208.15,107.73 207.74,108.14 205.99,108.14 204.71,106.85 204.27,106.85 204,107.12 204,107.24 v2(203.42,107.82)
  BOTTOM w0.102: v2(228.62,112.87) 226.05,112.87 224.17,111 224.17,110.41 v2(224.26,110.32) ; U51.B19 204,106.74 203.81,106.93 203.81,107.46 203.7,107.58 203.57,107.58 203.43,107.72 203.43,107.81 v2(203.42,107.82)
BIA_PWM: length 7.3
  BOTTOM w0.102: R1137.1 110.76,151.47 R208.1 D66.1 D71.1 D68.1 v1(110.34,153.77)
BIA_PWM_EC: length 150.8
  TOP w0.102: v2(195.35,138.88) 195.89,139.42 v1(196.57,139.42) 196.8,139.42 197.1,139.12 198.26,139.12 198.51,139.36 199.09,139.36 199.71,138.75 199.71,134.9 201.55,133.05 201.55,123.9 200.89,123.24 200.89,119.7 202.45,118.15 202.45,116.68 201.77,116 201.77,114.6 201.82,114.55 201.82,113.72 201.21,113.1 200.45,113.1 200.15,112.8 200.15,110.71 199.79,110.34 199.79,109.28 200.39,108.68 200.61,108.68 v2(201.39,107.9)
  IN1 w0.109: v2(150.58,146.71) 150.58,146.62 149.2,145.24 137.39,145.24 136.56,144.41 135.67,144.41 134.92,143.66 129.41,143.66 128.28,144.79 128.05,144.79 127.34,145.5 126.74,145.5 122.38,149.86 116.04,149.86 113.83,152.07 113.83,155.6 112.12,157.31 109.33,157.31 108.75,156.74 108.75,153.69 v2(107.8,152.74)
  IN2 w0.127: v2(150.58,146.71) 150.99,146.29 152.17,146.29 152.46,146.58 158.3,146.58 158.89,147.16 165.36,147.16 166.81,145.71 168.41,145.71 168.87,146.17 172.42,146.17 172.88,146.63 176.08,146.63 177.53,145.18 186.12,145.18 186.69,144.61 189.35,144.61 190.09,143.87 194.57,143.87 v2(194.92,144.23)
  BOTTOM w0.102: v2(201.39,107.9) 201.39,107.9 201.39,107.91 201,107.52 U51.B25 ; v2(195.35,138.88) 195.35,143.5 194.92,143.92 v2(194.92,144.23) ; v2(107.8,152.74) 107.6,152.74 D71.2
BIA_PWM_PCH: length 94
  TOP w0.089: UH1.W36 v2(117.7,110.87)
  IN4 w0.089: v2(117.7,110.87) 117.28,110.45 114.28,110.45 113.46,111.26 112.37,111.26
  IN4 w0.109: v2(109.52,143.53) 109.52,143.46 106.54,140.48 104.12,140.48 103.37,139.73 101.87,139.73 97.9,135.76 97.9,131.71 89.96,123.77 89.96,116.8 91.84,114.92 94.73,114.92 96.59,113.06 96.59,107.56 99.61,104.54 99.61,101.62 100.56,100.67 102.72,100.67 104.64,102.58 104.64,103.51 104.05,104.1 104.05,107.52 104.95,108.42 108.11,108.42 108.11,108.42 108.3,108.42 110.28,110.4 110.28,110.51 110.28,110.51 110.28,110.71 110.28,110.96 110.58,111.26 112.37,111.26
  BOTTOM w0.102: v2(109.52,143.53) 109.52,146.02 108.11,147.43 108.11,148.18 v1(107.51,148.78) 106.98,149.3 D66.2
BIOS_REC: length 14.1
  TOP w0.089: UH1.AB33 v2(119.23,111.91)
  BOTTOM w0.089: 112.37,112.29 113.07,112.29 113.9,111.46 114.31,111.46 115.12,112.27 117.32,112.27 117.55,112.05 v1(117.87,112.05) 119.09,112.05 v2(119.23,111.91)
  BOTTOM w0.102: RH76.2 107.17,112.29 112.37,112.29
BL_PWR_SRC_ON: length 1.3
  BOTTOM w0.102: 111.87,135.4 112.06,135.4 v1(112.82,136.16)
BLK_MOSFET_GC: length 4.6
  TOP w0.102: PR1006.2 328.7,53.98 327.3,53.98 v1(326.7,54.58)
  TOP w0.254: PR1006.2 329.41,54.69 PU1001.30
BLKNG_MOSFET_GC: length 3.4
  TOP w0.254: PR1009.2 336.45,58.36 336.92,57.89 v2(336.92,57.7) 336.9,57.68 335.7,57.68 335.2,57.18 PU1001.20
BLUE_DOCK: length 79.8
  TOP w0.102: JMXM1.200 170.75,81 171.19,81.44 171.19,81.7 174.65,85.17 174.65,86.04 175.16,86.55 175.76,86.55 v2(175.81,86.6)
  IN3 w0.127: v2(168.51,146.58) 170.03,146.58 171.05,145.56 171.05,144.16 169.27,142.38 169.27,136.67 168.44,135.84 168.44,134.95 167.5,134.01 167.5,128.55 170.47,125.59 170.47,118.91 171.67,117.71 171.67,115.65 171.45,115.44 171.45,113.35 171.92,112.88 171.92,111.97 173.54,110.35 173.54,106.97 172.69,106.12 172.69,105.43 172.57,105.32 172.57,104.21 172.97,103.82 172.97,102.66 171.71,101.41 171.71,99.81 172.66,98.86 172.66,97.12 172.65,97.11 172.65,94.5 173.18,93.97 173.18,93.58 173.52,93.24 173.52,90.96 176,88.49 176,86.79 v2(175.81,86.6)
  BOTTOM w0.102: v2(168.51,146.58) 168.75,146.82 JDOCK1.45
BOARD_ID: length 12.1
  IN2 w0.127: v2(208.9,110.78) 208.43,110.78 208.29,110.92 206.98,110.92 206.93,110.87 206.49,110.87 205.35,112.01 204.07,112.01 204,112.07 203.34,112.07 203.09,111.83 203.09,111.19 v2(203.51,110.77)
  BOTTOM w0.102: R875.2 207.98,111.3 208.5,110.78 v2(208.9,110.78) 209.78,110.78 C744.1 ; U51.B10 204.93,110.78 204.81,110.78 204.5,111.09 204.12,111.09 204.11,111.09 203.83,111.09 v2(203.51,110.77)
BOOT_1.2V: length 3.4
  BOTTOM w0.102: v1(65.49,17.57) 64.96,17.05 64.96,16.97 64.7,16.71 63.68,16.71 62.97,17.42 PR200.2
BQ24780_REGN: length 11.4
  TOP w0.102: v1(273.28,39.39) 273.37,39.39 v2(273.81,38.95)
  TOP w0.254: v2(273.81,38.95) PR722.1
  IN1 w0.508: v2(273.81,38.95) 273.85,38.9 273.85,38.83 276.47,36.22 278.11,36.22 278.57,35.76 v2(278.57,31.83)
BREATH_LED#: length 273.9
  TOP w0.102: Q359.3 303.87,10.57 R955.1 304.44,11.78 299.27,16.95 299.27,17.61 298.96,17.92 298.96,19.61 298.69,19.87 296.59,21.98 v2(296.59,22.05)
  IN2 w0.127: v2(199.1,114.96) 199.92,115.77 205.04,115.77 205.83,116.56 208.69,116.56 209.99,115.25 210.79,115.25 211.11,115.57 211.63,115.57 213.5,113.7 217.42,113.7 217.8,114.08 220.4,114.08 220.62,114.3 222.24,114.3 222.55,113.99 222.55,112.86 v2(224.58,110.83)
  IN3 w0.127: v2(224.58,110.83) 224.58,112.29 224.01,112.86 224.01,115.15 223.52,115.64 223.52,123.42 224.49,124.39 224.49,131.87 209.66,146.71 209.66,151 208.42,152.23 207.64,152.23 202.71,157.16 194.64,157.16 194.29,156.8 184.45,156.8 v2(183.81,157.44)
  BOTTOM w0.102: U51.B57 199,115.06 v2(199.1,114.96) ; v2(296.59,22.05) 296.49,22.16 296.49,22.73 296.11,23.11 294.51,23.11 291.86,25.77 291.86,38.95 290.37,40.43 282.34,40.43 280.58,42.2 274.11,42.2 v1(266.61,49.7) 264.02,52.28 264.02,54.03 260.02,58.03 256.96,58.03 256.54,57.61 251.03,57.61 247.48,61.16 247.48,66.66 248.87,68.06 248.87,78.38 245.37,81.89 245.37,88.16 245.12,88.4 245.12,90.22 247.3,92.4 247.3,92.78 249.62,95.1 249.62,100.84 248.15,102.31 248.15,103.46 247.22,104.39 247.06,104.39 238.98,112.48 228.74,112.48 228.7,112.44 226.19,112.44 v2(224.58,110.83) ; v2(183.81,157.44) 183.81,157.03 183.75,156.97 JDOCK1.98
BREATH_LED#_Q: length 15.7
  TOP w0.102: R955.2 303.76,8.97 v2(303.43,8.97) ; v2(291.55,6.77) JLED1.2
  IN1 w0.109: v2(303.43,8.97) 293.05,8.97 291.55,7.47 v2(291.55,6.77)
BREATH_WHITE_LED: length 70
  TOP w0.102: R956.2 300.89,14.69 298.82,16.76 298.82,17.42 298.51,17.73 298.51,19.18 295.73,21.95 v2(295.73,22.09) ; v2(290.49,37.72) 291.18,38.41 291.18,39.47 v1(289.16,41.49) 288,42.64
  TOP w0.508: JPB1.3 288,42.64
  IN3 w0.127: v2(290.49,37.72) 290.92,37.29 299.19,37.29 300.78,38.88 306.94,38.88 308.91,36.91 308.91,33.68 311.19,31.39 311.19,26.44 310.46,25.71 308.37,25.71 306.49,23.83 296.33,23.83 295.66,23.16 295.66,22.16 v2(295.73,22.09)
BST1: length 1.7
  TOP w0.102: PR1615.1 256.02,31.66 PU1600.8
BST_3V:
  vias: v1(350.93,27.86)
BST_3V_C:
  vias: v1(353.42,26.53)
BST_5V:
  vias: v1(352.84,34.21)
BST_5V_C:
  vias: v1(352.7,35.55)
BST_+1VSP:
  vias: v1(103.99,126.11)
BST_+V0.95SP: length 4.8
  IN4 w1.016: 330.56,18.44 330.12,17.99 327.19,17.99 326.62,18.56 326.62,19.01
  vias: v2(326.14,20.41) v2(326.73,20.41) v2(331.43,19.58) v2(331.43,18.94)
BST_+V0.95SP_C:
  vias: v1(325.07,23.57)
BST_EDRAMP: length 7
  TOP w0.102: v1(73.79,14.78) 73.79,12.69 74.45,12.03 PR503.1
  TOP w0.254: PR503.1 75.54,11.03 75.54,9.42 75.31,9.19 PU500.9
BST_EOPIOP: length 7.4
  TOP w0.102: v1(55.63,13.94) 56.01,13.56 56.01,11.96 56.2,11.77 PR1803.1
  TOP w0.254: PU1800.9 58.29,9.03 58.53,9.27 58.53,10.19 57.77,10.94 57.46,10.94 56.81,11.59 PR1803.1
BST_R_EDRAMP: length 1.3
  TOP w0.102: v1(75.18,14.54) 75.77,13.94 PC500.1
BST_R_EOPIOP:
  vias: v1(57.84,14.22)
BT_RADIO_DIS#: length 52.8
  TOP w0.102: v1(217.66,124.42) 217.66,123.63 217.97,123.32 v2(217.97,123.21) ; v2(219.14,114.58) 219.17,114.58 219.39,114.35 D36.1
  IN2 w0.127: v2(217.97,123.21) 217.67,122.91 212.73,122.91 212.18,122.36 211.25,122.36 210.81,122.8 202.37,122.8 201.99,122.43 198.69,122.43 197.51,121.25 196.83,121.25 196.03,122.05 195.53,122.05 194.74,121.25 192.97,121.25 191.21,119.49 191.21,119.14 190.75,118.69 186.64,118.69 186.18,119.15 183.45,119.15 182.2,117.89 182.2,117.86 v2(181.81,117.47)
  IN3 w0.127: v2(217.97,123.21) 218.33,122.85 218.33,120.71 218.33,118.73 219.31,117.75 219.31,114.74 v2(219.14,114.58)
  BOTTOM w0.102: U46.A13 181.55,117.21 v2(181.81,117.47)
BT_RADIO_DIS#_R: length 4.5
  TOP w0.102: D36.2 220.79,114.47 220.58,114.69 220.58,115.41 220.69,115.52 v1(220.78,115.52) 220.89,115.52 221.61,114.8 v2(221.61,114.76)
  BOTTOM w0.102: JNGFF1.46 220.94,115.45 221.61,114.78 v2(221.61,114.76)
CAM_MIC_CBL_DET#: length 135.7
  TOP w0.089: v2(116.18,111.89) 116.18,110.95 115.73,110.5 115.12,110.5 114.97,110.65 114.4,110.65 114.09,110.34 UH1.U43
  TOP w0.102: JEDP1.17 119.68,143.91 119.68,144.36 v2(119.8,144.48)
  IN2 w0.089: v2(116.18,111.89) 116.4,111.89 118.39,113.87 123.8,113.87 124.03,113.65 124.03,113.34 124.29,113.07 124.54,113.07 124.8,112.81 124.8,112.56 125.01,112.35 127.55,112.35 127.7,112.5 133.17,112.5 133.5,112.18 133.5,111.82 133.92,111.4 134.47,111.4 136.06,109.81 140.64,109.81 140.86,109.59 v2(141.01,109.45)
  IN4 w0.089: v2(116.18,111.89) 115.82,111.53 113.96,111.53 113.6,111.89 112.37,111.89
  IN4 w0.109: v2(119.8,144.48) 118.22,142.9 112.91,142.9 112.43,143.38 111.78,143.38 111.11,142.7 109.43,142.7 106.7,139.98 104.72,139.98 104.01,139.26 102.07,139.26 98.48,135.67 98.48,133.44 99.01,132.92 99.01,131.26 98.61,130.86 97.72,130.86 90.43,123.57 90.43,116.99 92.03,115.39 94.96,115.39 97.06,113.29 97.06,107.76 100.08,104.74 100.08,101.82 100.76,101.14 102.53,101.14 103.23,101.84 103.23,107.37 104.75,108.89 108.11,108.89 109.8,110.59 109.8,110.74 109.81,111.16 110.54,111.89 112.37,111.89
  BOTTOM w0.102: v2(141.01,109.45) 143.26,111.7 143.26,112.87 143.06,113.07 143.06,115.22 v1(142.76,115.52) 142.28,116 RH319.2
CCD_OFF: length 1.4
  TOP w0.102: T208.1 179.56,116.94 179.55,116.94 v2(179.55,116.94)
  BOTTOM w0.102: U46.A9 v2(179.55,116.94)
CD3301_DCIN: length 6.1
  TOP w0.102: PR1011.2 v1(328.67,47.86)
  TOP w0.254: PR1011.2 329.67,49.42 330.05,49.04 PC1006.1 330.67,49.68 331.05,50.06 331.43,50.06 331.7,50.33 PU1001.1
CD3301_NBDOCK_DC_IN_SS: length 4.7
  TOP w0.254: PU1001.19 335.7,57.06 335.81,57.16 336.04,57.16 336.31,56.89 336.31,56.45 v2(336.38,56.38) 336.83,56.38 337.14,56.69 337.14,57.06 337.57,57.49 337.57,57.86 337.34,58.09 PR1024.1
CD3301_SDC_IN: length 1.9
  TOP w0.254: PU1001.6 334.2,50.06 334.3,49.96 v2(334.3,49.75) 334.3,49.31 PR1015.2
CD_PBATT_OFF: length 2.1
  TOP w0.254: PR1016.1 331.56,57.93 332.2,57.29 PU1001.26
CFG0: length 82.6
  TOP w0.089: CPU1.BN25 189.23,26.04 v2(189.55,26.36)
  TOP w0.102: JXDP1.9 v2(146.36,6.36) 146.36,6.44 145.77,7.03 145.77,7.26 145.52,7.51 144.13,7.51 143.89,7.75 143.89,11.91 144.5,12.53 149.52,12.53 150.28,11.77 150.67,11.77 150.81,11.91 151.42,11.91 v1(151.8,12.28) 152.04,12.53 RC126.1 ; v2(175.93,8.94) 175.54,9.33 175.37,9.33 175.16,9.55 174.46,9.55 RC321.1
  IN1 w0.109: v2(146.36,6.36) 148.29,4.44 173.76,4.44 175.93,6.61 v2(175.93,8.94)
  IN3 w0.089: 188,21.28 188,24.34 189.13,25.48 189.13,25.94 v2(189.55,26.36)
  IN3 w0.109: 188,21.28 188,15.97 186.43,14.41 186.43,13.45 184.8,11.82 181.23,11.82 179.44,10.03 177.02,10.03 v2(175.93,8.94)
CFG1: length 71.9
  TOP w0.089: CPU1.BN27 190.58,26.04 190.35,26.26 v2(190.35,26.37)
  TOP w0.102: JXDP1.11 146.86,6.87 146.77,6.96 v2(146.44,6.96)
  IN1 w0.109: v2(146.44,6.96) 146.07,6.96 145.86,6.74 145.86,5.93 147.58,4.2 173.86,4.2 177.27,7.61 v2(177.27,8.48)
  IN3 w0.109: v2(190.35,26.37) 189.97,25.99 189.97,23.96 190.46,23.47 190.46,17.98 193,15.44 193,12.5 191.25,10.74 181.15,10.74 179.2,8.79 178.21,8.79 177.89,8.48 v2(177.27,8.48)
CFG2: length 84
  TOP w0.089: v2(189.55,25.71) 189.88,26.04 CPU1.BN26
  TOP w0.102: v2(140.57,6.81) 139.87,7.51 139.87,12.15 v1(143.24,15.52) 144.26,16.54 RC181.1 ; v2(147.38,6.96) 147.56,6.96 147.86,6.66 JXDP1.15
  IN1 w0.109: v2(175.35,8.9) 175.7,8.55 175.7,6.7 173.67,4.67 149.12,4.67 147.82,5.98 147.82,6.53 v2(147.38,6.96)
  IN3 w0.109: v2(175.35,8.9) 175.85,8.39 176.56,8.39 177.86,9.68 179.43,9.68 181.33,11.58 184.9,11.58 186.67,13.36 186.67,14.31 188.24,15.88 188.24,24.32 189.55,25.64 v2(189.55,25.71)
  BOTTOM w0.102: v2(140.57,6.81) 143.87,6.81 144.58,7.53 146.81,7.53 v2(147.38,6.96)
CFG3: length 87.4
  TOP w0.089: v2(190.35,25.67) 191.09,25.67 191.45,26.04 CPU1.BN28
  TOP w0.102: v2(148.36,6.37) JXDP1.17 ; v2(140.6,7.45) 140.47,7.45 140.2,7.73 140.2,11.56 v1(141.99,13.36) 143.33,14.7 RC121.2
  IN1 w0.109: v2(148.36,6.37) 149.82,4.91 173.57,4.91 175.29,6.63 v2(175.29,8.27)
  IN3 w0.109: v2(190.35,25.67) 190.35,23.9 190.72,23.53 190.72,18.06 193.24,15.54 193.24,12.4 191.35,10.51 181.25,10.51 179.3,8.55 178.3,8.55 177.82,8.07 175.49,8.07 v2(175.29,8.27)
  IN3 w0.127: v2(148.36,6.37) 148.21,6.37 147.92,6.66 147.92,7.3 147.59,7.63 140.78,7.63 v2(140.6,7.45)
CFG4: length 60.9
  TOP w0.089: v2(186.01,22.04) 185.42,22.63 185.42,23.87 185.52,23.96 185.52,24.44 CPU1.BR20
  TOP w0.102: JXDP1.27 150.86,5.76 150.98,5.88 150.98,6.8 150.83,6.95 v2(150.52,6.95) ; v2(174.46,9.02) 174.17,9.02 173.64,9.56 173.46,9.56 RC322.1
  IN1 w0.109: v2(150.52,6.95) 150.96,6.51 150.96,5.57 151.39,5.15 173.47,5.15 174.88,6.55 174.88,8.61 v2(174.46,9.02)
  IN3 w0.109: v2(174.46,9.02) 174.46,9.06 175.8,10.39 175.8,10.55 175.85,10.6 179.31,10.6 181.02,12.31 181.51,12.31 181.92,12.72 181.92,21.17 182.99,22.25 182.99,23.47 183.39,23.87 184.18,23.87 v2(186.01,22.04)
CFG5: length 56.8
  TOP w0.089: v2(184.83,26.36) 185.15,26.69 CPU1.BM20
  TOP w0.102: v2(173.28,8.46) 173.27,8.47 172.51,8.47 v1(172,8.97) 172,9.94 RC323.1 ; JXDP1.29 151.36,6.33 v2(151.39,6.35)
  IN1 w0.109: v2(151.39,6.35) 152.36,5.38 173.24,5.38 174.64,6.79 174.64,8.27 174.04,8.87 173.67,8.87 173.27,8.47 v2(173.28,8.46)
  IN3 w0.109: 173.28,10.2 175.06,11.97 177.93,11.97 178.91,12.95 178.91,13.15 181.44,15.69 181.44,21.26 182.59,22.41 182.59,24.12 v2(184.83,26.36)
  IN3 w0.127: v2(173.28,8.46) 173.28,10.2
CFG6: length 62
  TOP w0.089: CPU1.BT20 185.2,24.07 185.2,21.58 185.5,21.28
  TOP w0.102: RC324.1 176.61,9.43 176.61,8.21 175.85,7.45 173.44,7.45 v2(172.83,8.06) ; v2(152.4,6.37) 152.4,5.79 152.36,5.75 JXDP1.33 ; 185.5,21.28 v2(186.01,20.77)
  IN1 w0.109: v2(172.83,8.06) 172.83,7.67 171.02,5.86 152.92,5.86 v2(152.4,6.37)
  IN3 w0.089: v2(186.01,20.77) 186.01,20.89 185.65,21.26 185.65,22.14 184.11,23.68 183.47,23.68 183.18,23.39 183.18,22.17 182.16,21.15 182.16,17.89
  IN3 w0.127: v2(172.83,8.06) 172.85,8.04 174.45,8.04 174.88,8.47 174.88,9.13 176.06,10.31 179.37,10.31 181.13,12.06 181.61,12.06 183.1,13.56 183.1,16.54 182.16,17.48 182.16,17.89
CFG7: length 61.8
  TOP w0.089: v2(186.01,22.68) 185.65,23.04 185.65,23.46 185.72,23.54 185.72,24.89 CPU1.BP20
  TOP w0.102: v1(173.4,7.96) 173.87,8.43 v2(173.87,8.46) 174.51,8.46 175.11,7.86 175.94,7.86 176.38,8.3 176.38,9.13 175.95,9.56 175.47,9.56 RC325.1 ; v2(152.54,6.97) 152.73,6.97 152.86,6.83 JXDP1.35
  IN1 w0.109: v2(152.54,6.97) 152.21,6.97 151.98,6.73 151.98,6.13 152.49,5.62 172.65,5.62 173.87,6.84 v2(173.87,8.46)
  IN3 w0.109: v2(186.01,22.68) 185.66,22.68 184.27,24.07 184.1,24.07 183.31,24.07 182.79,23.55 182.79,22.33 181.68,21.22 181.68,15.59 180.27,14.18 180.27,13.23 177.94,10.9 175.26,10.9 173.87,9.51 v2(173.87,8.46)
CFG8: length 68.1
  TOP w0.089: CPU1.BR23 187.79,24.74 188.09,24.44 188.09,23.18 v2(187.59,22.68)
  TOP w0.102: v2(146.36,8.82) JXDP1.10 146.36,11.75 v1(145.97,12.15)
  IN4 w0.089: v2(187.59,22.68) 188.57,21.69 188.57,19.62 186.84,17.89
  IN4 w0.109: v2(146.36,8.82) 145.86,8.32 145.86,8.01 145.4,7.55 145.26,7.55 144.9,7.2 144.9,6.09 146.24,4.75 178.8,4.75 182.27,8.23 185.14,8.23 185.45,8.53 185.51,8.53 186.18,9.2 186.18,17.23 186.84,17.89
CFG9: length 66.9
  TOP w0.089: CPU1.BR22 187.08,24.46 187.71,24.46 187.92,24.25 187.92,23.9 187.72,23.71 187.47,23.71 187.17,23.41 187.17,22.46 v2(187.59,22.04)
  TOP w0.102: v2(146.37,8.24) 146.86,8.73 JXDP1.12 146.86,11.78 v1(147.24,12.15)
  IN4 w0.089: v2(187.59,22.04) 188.32,21.31 188.32,19.71 186.51,17.89
  IN4 w0.109: 186.51,17.89 185.94,17.33 185.94,9.3 185.41,8.77 185.35,8.77 185.05,8.47 182.16,8.47 178.69,4.99 147.15,4.99 145.95,6.19 145.95,7.42 146.37,7.83 v2(146.37,8.24)
CFG10: length 60.8
  TOP w0.089: CPU1.BT23 187.21,24.09 186.9,23.78 186.9,21.24 186.97,21.17
  TOP w0.102: JXDP1.16 147.86,8.74 v2(147.36,8.24) ; 186.97,21.17 187.37,20.77 v2(187.59,20.77)
  IN4 w0.089: v2(187.59,20.77) 188.07,20.29 188.07,19.9 186.07,17.89
  IN4 w0.109: v2(147.36,8.24) 146.95,7.83 146.95,6.16 147.89,5.23 178.54,5.23 180.4,7.09 180.4,7.1 180.58,7.27 180.58,7.99 183.72,11.13 184.41,11.13 185.7,12.42 185.7,17.53 186.07,17.89
CFG11: length 59.1
  TOP w0.089: CPU1.BT22 186.49,23.77 186.49,21.41 ; v2(187.59,20.14) 187.59,19.61 v1(187.56,19.58)
  TOP w0.102: 186.49,21.41 186.49,21.2 187.55,20.14 v2(187.59,20.14) ; v2(148.36,8.82) JXDP1.18
  IN4 w0.089: v2(187.59,20.14) 185.47,18.02 185.47,17.89
  IN4 w0.109: v2(148.36,8.82) 147.95,8.41 147.95,6.2 148.69,5.46 178.44,5.46 180.17,7.19 180.17,7.2 180.34,7.37 180.34,8.09 183.62,11.36 184.31,11.36 185.47,12.52 185.47,17.89
CFG12: length 56.5
  TOP w0.089: v2(184.83,27.01) 184.51,26.69 CPU1.BM19
  TOP w0.102: v2(150.18,8.23) 150.43,8.23 150.86,8.66 JXDP1.28
  IN4 w0.089: v2(184.83,27.01) 184.45,26.63 184.45,17.89
  IN4 w0.109: 184.45,17.89 184.76,17.58 184.76,12.82 184.02,12.07 183.32,12.07 179.63,8.38 179.63,7.66 179.46,7.49 179.46,7.48 178.54,6.56 161.39,6.56 160.66,7.29 159.4,7.29 159.1,6.99 157.59,6.99 156.43,8.16 155.6,8.16 155.04,7.6 151.1,7.6 150.46,8.23 v2(150.18,8.23)
CFG13: length 52.7
  TOP w0.089: v2(183.65,22.65) 184.03,23.04 184.03,23.6 183.95,23.69 183.95,24.25 CPU1.BR19
  TOP w0.102: v2(151.36,8.83) JXDP1.30
  IN4 w0.089: v2(183.65,22.65) 184.19,22.11 184.19,17.89
  IN4 w0.109: 184.19,17.89 184.19,12.58 183.92,12.31 183.23,12.31 179.39,8.48 179.39,7.76 179.22,7.59 179.22,7.58 178.44,6.8 161.49,6.8 160.76,7.53 159.3,7.53 159,7.23 157.69,7.23 156.52,8.4 155.5,8.4 154.94,7.83 151.19,7.83 150.87,8.16 150.87,8.48 151.21,8.83 v2(151.36,8.83)
CFG14: length 50.8
  TOP w0.089: CPU1.BP19 184.75,25.08 184.75,24.65 184.55,24.46 184.41,24.46 184.16,24.2 184.16,23.83 184.22,23.77 184.22,22.59 v2(183.65,22.02)
  TOP w0.102: v2(152.36,8.83) JXDP1.34
  IN4 w0.089: 182.4,17.89 182.4,19.53 183.11,20.24 183.11,21.48 v2(183.65,22.02)
  IN4 w0.109: 182.4,17.89 182.4,17.36 183.72,16.05 183.72,13.68 183.07,13.03 183.07,12.82 178.92,8.67 178.92,7.96 178.24,7.27 161.69,7.27 160.96,8 159.19,8 157.65,9.55 153.08,9.55 v2(152.36,8.83)
CFG15: length 50.3
  TOP w0.089: CPU1.BT19 184.44,21.56 184.16,21.28
  TOP w0.102: JXDP1.36 152.86,8.73 152.38,8.24 v2(152.37,8.24) ; 184.16,21.28 184.16,21.26 v2(183.65,20.75)
  IN4 w0.089: 182.64,17.89 182.64,19.25 183.65,20.26 v2(183.65,20.75)
  IN4 w0.109: 182.64,17.89 182.64,17.46 183.96,16.14 183.96,13.58 183.3,12.93 183.3,12.72 179.16,8.58 179.16,7.86 178.99,7.69 178.99,7.68 178.35,7.04 161.59,7.04 160.86,7.76 159.1,7.76 157.55,9.31 153.6,9.31 152.54,8.24 v2(152.37,8.24)
CFG16: length 67.5
  TOP w0.089: v2(187.98,25.06) 187.65,25.39 CPU1.BP23
  TOP w0.102: v2(145.36,8.82) JXDP1.6
  IN4 w0.089: 187.21,17.89 188.83,19.51 188.83,21.93 188.26,22.5 188.26,24.78 v2(187.98,25.06)
  IN4 w0.109: 187.21,17.89 186.41,17.1 186.41,10.69 186.41,10.69 186.41,9.11 185.6,8.3 185.55,8.3 185.24,7.99 182.37,7.99 178.89,4.52 145.76,4.52 143.93,6.35 143.93,6.91 144.87,7.86 144.87,8.33 v2(145.36,8.82)
CFG17: length 70.9
  TOP w0.089: v2(187.98,25.71) 187.65,26.04 CPU1.BN23
  TOP w0.102: v1(144.7,12.15) 144.86,11.98 JXDP1.4 144.86,8.71 v2(144.39,8.24)
  IN4 w0.089: 187.59,17.89 189.08,19.39 189.08,22.05 188.57,22.56 188.57,25.12 v2(187.98,25.71)
  IN4 w0.109: v2(144.39,8.24) 143.69,7.54 143.69,6.45 143.69,6.26 145.66,4.28 178.99,4.28 182.47,7.76 185.34,7.76 185.64,8.06 185.7,8.06 186.65,9.01 186.65,16.96 187.59,17.89
CFG18: length 57.4
  TOP w0.089: v2(186.4,25.71) 186.73,26.04 CPU1.BN22
  TOP w0.102: v2(149.38,8.24) 149.86,8.72 JXDP1.24
  IN4 w0.089: v2(186.4,25.71) 184.66,23.97 184.66,18.01 184.78,17.89
  IN4 w0.109: 184.78,17.89 185,17.68 185,12.72 184.11,11.84 183.42,11.84 179.87,8.28 179.87,7.57 179.69,7.39 179.69,7.38 178.25,5.94 150.04,5.94 149.85,6.13 149.85,7.77 v2(149.38,8.24)
