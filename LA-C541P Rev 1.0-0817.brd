# Allegro board LA-C541P Rev 1.0-0817.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D20: length 83.9
  TOP w0.089: CPU1.BF11 v2(178.51,31.42)
  TOP w0.14: v2(112.84,28.64) 113.44,29.23 115.58,29.23 117.02,30.68 JDIMM3.63
  IN4 w0.089: 170.26,30.6 174.06,30.6 175.61,32.15 176.32,32.15 176.5,31.97 177.96,31.97 v2(178.51,31.42)
  IN4 w0.147: v2(112.84,28.64) 113.54,29.34 114.05,29.85 117.69,29.85 118.97,28.57 126.28,28.57 126.63,28.22 139.91,28.22 141.17,26.96 166.62,26.96 170.26,30.6
  BOTTOM w0.14: v2(112.84,28.64) 113.45,29.25 115.67,29.25 116.85,30.42 JDIMM4.62
DDR_B_D21: length 81.9
  TOP w0.089: CPU1.BF10 v2(177.87,31.42)
  TOP w0.14: JDIMM3.62 111.61,30.42 111.74,30.29 111.74,29.88 112.31,29.32 112.31,28.48 112.58,28.21 113.7,28.21 v2(114.16,28.66)
  IN4 w0.089: 170.52,30.34 170.6,30.42 174.13,30.42 175.68,31.97 176.17,31.97 176.35,31.79 177.5,31.79 v2(177.87,31.42)
  IN4 w0.147: 170.52,30.34 166.76,26.58 141.02,26.58 140.24,27.36 139.91,27.36 139.58,27.03 139.21,27.03 138.99,27.25 138.99,27.7 138.84,27.85 126.47,27.85 126.12,28.2 125.58,28.2 125.43,28.05 125.43,27.76 125.3,27.63 124.97,27.63 124.84,27.76 124.84,28.07 124.71,28.2 124.38,28.2 124.25,28.07 124.25,27.76 124.12,27.63 123.79,27.63 123.66,27.76 123.66,28.05 123.51,28.2 118.82,28.2 117.54,29.48 114.21,29.48 114,29.26 114,28.82 v2(114.16,28.66)
  BOTTOM w0.14: v2(114.16,28.66) 113.68,28.19 112.66,28.19 112.31,28.54 112.31,29.71 111.34,30.68 JDIMM4.63
DDR_B_D22: length 81
  TOP w0.089: CPU1.BG7 v2(175.92,30.51)
  TOP w0.14: JDIMM3.49 117.63,27.17 116.39,25.94 115.76,25.94 v2(115.02,25.21)
  IN4 w0.089: 167.08,24.16 172.35,29.43 174.85,29.43 v2(175.92,30.51)
  IN4 w0.147: v2(115.02,25.21) 115.02,25.51 114.9,25.64 113.09,25.64 112.96,25.76 112.96,26.35 113.09,26.48 116.42,26.48 116.55,26.61 116.55,26.95 116.67,27.07 117.11,27.07 117.23,26.95 117.23,26.61 117.36,26.48 117.83,26.48 118.82,25.49 118.82,25.49 119.53,24.78 123.67,24.78 124.23,25.34 126.23,25.34 126.8,24.77 137.18,24.77 137.45,24.5 141.31,24.5 141.42,24.61 165.59,24.61 166.04,24.16 167.08,24.16
  BOTTOM w0.14: JDIMM4.50 117.79,27.42 116.31,25.94 115.76,25.94 v2(115.02,25.21)
DDR_B_D23: length 80.5
  TOP w0.089: CPU1.BF7 v2(175.92,31.42)
  TOP w0.14: v2(113.31,26.98) 112,28.28 112,28.94 111.51,29.42 JDIMM3.58
  IN4 w0.089: v2(175.92,31.42) 175.66,31.42 174.23,29.99 171.21,29.99
  IN4 w0.102: 171.02,29.8 171.02,29.8
  IN4 w0.147: 171.02,29.8 171.21,29.99 ; v2(113.31,26.98) 113.05,26.98 112.92,27.11 112.92,28.08 113.05,28.21 113.71,28.21 113.83,28.08 113.83,27.49 113.96,27.36 114.32,27.36 114.44,27.49 114.44,28.11 114.57,28.23 117.72,28.23 119.98,25.97 120.5,25.97 120.63,26.1 120.63,26.74 120.75,26.87 121.28,26.87 121.4,26.74 121.4,26.48 121.53,26.35 123.53,26.35 123.68,26.5 130.18,26.5 130.31,26.63 130.31,26.91 130.44,27.03 134.42,27.03 134.55,26.91 134.55,26.63 134.67,26.5 137.25,26.5 138.09,25.66 140.73,25.66 140.9,25.83 167.05,25.83 170.73,29.51 171.02,29.8
  BOTTOM w0.14: JDIMM4.59 111.56,29.68 111.96,29.27 111.96,28.5 113.31,27.16 v2(113.31,26.98)
DDR_B_D24: length 76.7
  TOP w0.089: CPU1.BB11 v2(178.52,34.16)
  TOP w0.14: v2(112.48,35.76) 111.64,35.76 111.47,35.92 JDIMM3.84
  IN4 w0.089: v2(178.52,34.16) 177.98,34.7 176.47,34.7 176.05,35.12 171.44,35.12 170.86,34.54 167.62,34.54 163.91,30.82 163.28,30.82
  IN4 w0.147: 163.28,30.82 142.78,30.82 140.76,32.84 138.22,32.84 136.97,34.1 134.06,34.1 133.92,33.95 133.92,33.74 133.79,33.61 133.45,33.61 133.33,33.74 133.33,34.08 133.2,34.21 132.86,34.21 132.74,34.08 132.74,33.74 132.61,33.61 132.28,33.61 132.15,33.74 132.15,34.08 132.02,34.21 131.7,34.21 131.58,34.08 131.58,33.92 131.45,33.8 131.12,33.8 130.42,34.5 118.82,34.5 118.41,34.91 113.33,34.91 v2(112.48,35.76)
  BOTTOM w0.14: JDIMM4.83 112.4,35.68 v2(112.48,35.76)
DDR_B_D25: length 78.2
  TOP w0.089: CPU1.BC11 v2(178.51,33.25)
  TOP w0.14: JDIMM3.67 117.38,31.68 v2(116.01,30.31)
  IN4 w0.089: 167.29,29.2 167.68,29.6 168.09,29.6 169.99,31.5 173.04,31.5 173.78,32.24 175.28,32.24 175.29,32.24 175.38,32.24 175.47,32.34 176.1,32.34 176.47,32.71 177.58,32.71 177.72,32.85 178.1,32.85 v2(178.51,33.25)
  IN4 w0.147: 167.29,29.2 165.49,27.41 141.36,27.41 139.65,29.12 139.35,29.12 139.2,28.97 139.2,28.8 139.07,28.68 138.74,28.68 138.61,28.8 138.61,29 138.49,29.12 138.15,29.12 138.02,29 138.02,28.8 137.9,28.68 137.56,28.68 137.43,28.8 137.43,29 137.31,29.12 136.97,29.12 136.84,29 136.84,28.8 136.72,28.68 136.38,28.68 136.25,28.8 136.25,29 136.12,29.12 133.92,29.12 133.77,28.97 133.77,28.8 133.64,28.68 133.31,28.68 133.18,28.8 133.18,29 133.05,29.12 132.72,29.12 132.59,29 132.59,28.8 132.46,28.68 132.13,28.68 132,28.8 132,29 131.87,29.12 131.54,29.12 131.41,29 131.41,28.8 131.28,28.68 130.95,28.68 130.82,28.8 130.82,28.97 130.67,29.12 126.62,29.12 126.52,29.03 126.14,29.03 125.99,29.17 125.99,29.43 125.86,29.56 125.53,29.56 125.4,29.43 125.4,29.17 125.25,29.03 120.3,29.03 120.17,29.15 120.17,29.57 120.04,29.7 119.65,29.7 119.52,29.57 119.52,29.48 119.41,29.37 118.82,29.37 117.87,30.31 v2(116.01,30.31)
  BOTTOM w0.14: v2(116.01,30.31) 117.13,31.42 JDIMM4.66
DDR_B_D26: length 79.8
  TOP w0.089: CPU1.BB8 v2(176.57,34.16)
  TOP w0.14: JDIMM3.80 111.96,34.92 112.49,34.39 114.45,34.39 114.71,34.13 v2(114.71,33.65)
  IN4 w0.089: v2(176.57,34.16) 176.44,34.16 176.08,34.53 174.68,34.53 174.29,34.14 167.79,34.14 163.73,30.07 163.22,30.07
  IN4 w0.147: 163.22,30.07 142.46,30.07 140.45,32.09 137.91,32.09 137.14,32.86 130.9,32.86 130.72,33.03 126.58,33.03 126.43,33.18 126.43,33.39 126.3,33.52 125.97,33.52 125.84,33.39 125.84,33.18 125.69,33.03 125.4,33.03 125.25,33.18 125.25,33.54 125.13,33.66 124.79,33.66 124.66,33.54 124.66,33.16 124.54,33.03 124.2,33.03 124.07,33.16 124.07,33.39 123.95,33.51 123.61,33.51 123.49,33.39 123.49,33.18 123.34,33.03 120.35,33.03 120.22,33.16 120.22,33.62 120.1,33.74 119.68,33.74 119.55,33.62 119.55,33.16 119.42,33.03 119.15,33.03 118.03,34.15 114.58,34.15 114.46,34.03 114.46,33.78 114.58,33.65 v2(114.71,33.65)
  BOTTOM w0.14: JDIMM4.79 111.88,34.68 112.46,34.09 114.27,34.09 v2(114.71,33.65)
DDR_B_D27: length 79
  TOP w0.089: CPU1.BC8 v2(176.57,33.25)
  TOP w0.14: v2(113.46,30.3) 113.46,30.63 113.15,30.94 112.59,30.94 112.14,31.39 112.14,31.95 111.67,32.42 JDIMM3.70
  IN4 w0.089: v2(176.57,33.25) 176.47,33.25 176.05,32.82 175.31,32.82 175.08,32.6 173.59,32.6 173.03,32.04 172.58,32.04
  IN4 w0.102: 164.88,28.16 168.76,32.04 172.58,32.04
  IN4 w0.147: 164.88,28.16 141.67,28.16 139.96,29.87 133.57,29.87 133.42,30.02 133.42,30.33 133.29,30.45 132.96,30.45 132.83,30.33 132.83,30 132.7,29.87 132.37,29.87 132.24,30 132.24,30.33 132.11,30.45 131.78,30.45 131.65,30.33 131.65,30 131.52,29.87 131.19,29.87 131.06,30 131.06,30.33 130.93,30.45 130.6,30.45 130.47,30.33 130.47,30.02 130.32,29.87 126.61,29.87 126.03,30.45 118.95,30.45 118.2,31.21 113.42,31.21 113.29,31.08 113.29,30.43 113.42,30.3 v2(113.46,30.3)
  BOTTOM w0.14: JDIMM4.71 111.49,32.68 113.46,30.7 v2(113.46,30.3)
DDR_B_D28: length 80.8
  TOP w0.089: CPU1.BC10 v2(177.87,33.25)
  TOP w0.14: v2(114.74,30.3) 114.74,29.92 114.53,29.7 112.39,29.7 112.02,30.07 112.02,30.93 111.53,31.42 JDIMM3.66
  IN4 w0.089: v2(177.87,33.25) 177.51,32.88 176.4,32.88 176.08,32.57 175.36,32.57 175.21,32.42 173.71,32.42 173.71,32.42 173.67,32.42 172.96,31.71 169.86,31.71 167.98,29.83 167.26,29.83 166.97,29.55
  IN4 w0.147: 166.97,29.55 165.21,27.79 141.52,27.79 139.8,29.5 126.45,29.5 125.88,30.08 125.12,30.08 124.99,29.95 124.99,29.74 124.87,29.61 124.53,29.61 124.4,29.74 124.4,29.95 124.28,30.08 123.94,30.08 123.82,29.95 123.82,29.55 123.67,29.4 120.77,29.4 120.64,29.53 120.64,29.95 120.51,30.08 118.8,30.08 118.04,30.83 114.85,30.83 114.74,30.72 v2(114.74,30.3)
  BOTTOM w0.14: JDIMM4.67 111.72,31.68 112.34,31.06 112.34,30.12 112.63,29.83 114.27,29.83 v2(114.74,30.3)
DDR_B_D29: length 81.9
  TOP w0.089: CPU1.BB10 v2(177.87,34.16)
  TOP w0.14: v2(113.33,33.6) 113.74,33.19 116.26,33.19 117.75,34.68 JDIMM3.79
  IN4 w0.089: v2(177.87,34.16) 177.51,34.53 176.39,34.53 176.06,34.86 171.55,34.86 171.05,34.36 167.7,34.36 163.78,30.45 163.2,30.45
  IN4 w0.147: 163.2,30.45 142.62,30.45 140.61,32.46 138.07,32.46 137.3,33.23 131.05,33.23 130.17,34.12 118.66,34.12 118.25,34.53 114.26,34.53 v2(113.33,33.6)
  BOTTOM w0.14: JDIMM4.80 117.84,34.92 116.12,33.2 113.74,33.2 v2(113.33,33.6)
DDR_B_D30: length 81.2
  TOP w0.089: CPU1.BC7 v2(175.92,33.25)
  TOP w0.14: JDIMM3.71 117.86,32.68 117.36,33.17 116.79,33.17 116.29,32.68 113.52,32.68 113.29,32.45 v2(113.29,32.19)
  IN4 w0.089: 172.6,32.48 173.22,32.48 173.51,32.77 175.01,32.77 175.48,33.25 v2(175.92,33.25)
  IN4 w0.102: 172.6,32.48 168.68,32.48 168.11,31.92 166.44,30.24
  IN4 w0.147: 166.44,30.24 164.74,28.54 141.83,28.54 140.12,30.25 136.51,30.25 135.93,30.83 119.11,30.83 118.35,31.58 112.58,31.58 112.45,31.71 112.45,32.33 112.58,32.46 113.02,32.46 v2(113.29,32.19)
  BOTTOM w0.14: v2(113.29,32.19) 113.78,31.7 117.04,31.7 117.76,32.42 JDIMM4.70
DDR_B_D31: length 78.9
  TOP w0.089: CPU1.BB7 v2(175.92,34.16)
  TOP w0.14: JDIMM3.83 117.42,35.68 115.99,34.25 v2(115.99,33.69)
  IN4 w0.089: 163.14,29.7 163.63,29.7 167.86,33.93 174.56,33.93 174.8,34.16 v2(175.92,34.16)
  IN4 w0.147: v2(115.99,33.69) 117.96,33.69 118.99,32.66 119.53,32.66 119.65,32.53 119.65,32.11 119.78,31.99 120.13,31.99 120.26,32.11 120.26,32.53 120.39,32.66 121.27,32.66 121.48,32.44 122,32.44 122.22,32.66 123.17,32.66 123.3,32.53 123.3,32.11 123.43,31.99 123.76,31.99 123.89,32.11 123.89,32.53 124.02,32.66 124.35,32.66 124.48,32.53 124.48,32.11 124.61,31.99 124.94,31.99 125.07,32.11 125.07,32.53 125.19,32.66 125.56,32.66 125.68,32.53 125.68,32.11 125.81,31.99 126.17,31.99 126.29,32.11 126.29,32.53 126.42,32.66 127.43,32.66 127.61,32.48 127.98,32.48 128.16,32.66 128.64,32.66 128.82,32.48 129.2,32.48 129.38,32.66 129.85,32.66 130.03,32.48 130.64,32.48 130.78,32.33 130.78,32.11 130.91,31.99 131.25,31.99 131.37,32.11 131.37,32.35 131.5,32.48 131.84,32.48 131.96,32.35 131.96,32.11 132.09,31.99 132.43,31.99 132.55,32.11 132.55,32.35 132.68,32.48 133.01,32.48 133.14,32.35 133.14,32.11 133.27,31.99 133.6,31.99 133.73,32.11 133.73,32.33 133.88,32.48 136.03,32.48 136.16,32.35 136.16,32.11 136.28,31.99 136.61,31.99 136.9,32.28 137.19,32.28 137.76,31.71 140.29,31.71 142.31,29.7 163.14,29.7
  BOTTOM w0.14: JDIMM4.84 118.06,35.92 115.99,33.86 v2(115.99,33.69)
DDR_B_D32: length 87.3
  TOP w0.089: v2(178.52,50.62) CPU1.AA11
  TOP w0.14: JDIMM3.187 117.96,63.68 116.81,64.83 116.81,65.42 116.87,65.48 116.87,65.71 116.71,65.88 116.48,65.88 116.42,65.82 116.22,65.82 116.04,66 v2(116.04,66.51)
  IN4 w0.089: v2(178.52,50.62) 178.79,50.9 178.79,51.06 178.68,51.18 178.43,51.18 178.21,50.96 178.02,50.96 177.82,51.16 176.41,51.16 176.19,51.38 175.42,51.38 174.9,51.89 170,51.89 166.23,55.66 165.23,55.66 164.88,56.02
  IN4 w0.147: v2(116.04,66.51) 116.21,66.33 116.92,66.33 120.02,69.43 120.18,69.43 120.26,69.35 120.26,69.04 120.39,68.91 120.71,68.91 120.83,69.04 120.83,69.3 120.96,69.43 121.3,69.43 121.42,69.3 121.42,69.04 121.55,68.91 122.79,68.91 122.92,69.04 122.92,69.3 123.05,69.43 123.36,69.43 123.49,69.3 123.49,69.04 123.61,68.91 123.76,68.91 126.31,71.46 126.53,71.46 126.62,71.37 126.62,71.12 126.71,71.03 129.93,71.03 130.05,71.16 130.05,71.34 130.18,71.46 130.52,71.46 130.65,71.34 130.65,71.16 130.78,71.03 131.53,71.03 132.22,70.34 137.5,70.34 144.29,63.55 153.06,63.55 158.46,58.15 162.75,58.15 164.88,56.02
  BOTTOM w0.14: JDIMM4.186 117.63,63.43 116.59,64.46 116.59,65.95 v2(116.04,66.51)
DDR_B_D33: length 91.1
  TOP w0.089: v2(177.87,50.62) CPU1.AA10
  TOP w0.14: JDIMM3.183 117.98,62.68 117.73,62.93 117.73,63.57 116.32,64.98 116.32,65.18 116.04,65.46 115.79,65.46 115.65,65.6 115.65,65.66 115.49,65.82 115.26,65.82 115.09,65.66 115.09,65.6 114.95,65.46 113.75,65.46 v2(113.32,65.04)
  IN4 w0.089: v2(177.87,50.62) 177.51,50.99 176.33,50.99 176.12,51.2 175.34,51.2 174.85,51.69 169.95,51.69 166.21,55.43 165,55.43 164.68,55.75
  IN4 w0.147: 164.68,55.75 162.66,57.77 158.31,57.77 152.9,63.18 144.13,63.18 137.36,69.95 132.08,69.95 131.37,70.66 126.04,70.66 123.91,68.53 119.65,68.53 117.08,65.96 114.24,65.96 v2(113.32,65.04)
  BOTTOM w0.14: v2(113.32,65.04) 113.78,65.49 116.09,65.49 116.34,65.23 116.34,64 117.91,62.43 JDIMM4.182
DDR_B_D34: length 85.9
  TOP w0.089: v2(178.52,49.71) CPU1.AC11
  TOP w0.14: JDIMM3.173 117.94,60.17 117.75,60.36 117.75,60.87 116.6,62.02 116.6,62.25 v2(116.51,62.33)
  IN4 w0.089: v2(178.52,49.71) 178.41,49.71 177.86,49.16 176.49,49.16 176.23,48.9 175.62,48.9 175.16,49.36 174.76,49.36 174.38,48.98 173.61,48.98 173.16,49.43 168.75,49.43 166.93,51.25 165.85,51.25 164.43,52.67
  IN4 w0.147: 164.43,52.67 162.39,54.72 157.06,54.72 151.64,60.14 142.87,60.14 138.03,64.99 137.47,64.99 137.34,65.11 137.34,65.34 137.22,65.46 136.83,65.46 136.71,65.34 136.71,65.11 136.58,64.99 136.28,64.99 136.15,65.11 136.15,65.34 136.02,65.46 134.62,65.46 134.47,65.32 134.47,65.11 134.34,64.99 134.01,64.99 133.88,65.11 133.88,65.34 133.75,65.46 133.42,65.46 133.29,65.34 133.29,65.11 133.16,64.99 132.83,64.99 132.7,65.11 132.7,65.34 132.57,65.46 132.24,65.46 132.11,65.34 132.11,65.11 131.98,64.99 131.65,64.99 131.52,65.11 131.52,65.32 131.38,65.46 131.06,65.46 130.93,65.34 130.93,65.11 130.81,64.99 130.47,64.99 130.34,65.11 130.34,65.32 130.2,65.46 127.03,65.46 126.9,65.34 126.9,65.13 126.78,65.01 126.42,65.01 126.29,65.13 126.29,65.34 126.17,65.46 125.65,65.46 125.52,65.34 125.52,65.11 125.39,64.99 125.04,64.99 124.94,65.08 124.76,65.08 124.43,64.75 124.43,64.33 123.42,63.32 122.81,63.32 122.67,63.46 122.67,63.98 122.54,64.1 122.21,64.1 122.08,63.98 122.08,63.44 121.95,63.32 121.62,63.32 121.49,63.44 121.49,63.98 121.36,64.1 121.03,64.1 120.9,63.98 120.9,63.46 120.75,63.32 119.99,63.32 119.71,63.6 119.42,63.6 118.16,62.33 v2(116.51,62.33)
  BOTTOM w0.14: JDIMM4.174 117.44,60.43 117.22,60.65 117.22,61.27 116.68,61.81 116.68,62.17 v2(116.51,62.33)
DDR_B_D35: length 88.3
  TOP w0.089: v2(177.87,49.71) CPU1.AC10
  TOP w0.14: JDIMM3.169 117.88,59.17 117.43,59.62 117.43,60.68 116.5,61.62 115.6,61.62 115.33,61.88 115.33,62.31 115.34,62.31 v2(115.34,62.33)
  IN4 w0.089: v2(177.87,49.71) 177.87,49.47 177.74,49.33 176.41,49.33 176.24,49.16 175.64,49.16 175.19,49.61 174.64,49.61 174.22,49.19 173.71,49.19 173.25,49.66 168.8,49.66 166.95,51.52 166.07,51.52 164.74,52.85
  IN4 w0.147: v2(115.34,62.33) 115.34,62.51 115.59,62.76 118.06,62.76 119.5,64.21 120.08,64.21 120.21,64.33 120.21,64.72 120.34,64.85 120.67,64.85 120.8,64.72 120.8,64.61 120.92,64.48 121.26,64.48 121.38,64.61 121.38,64.72 121.51,64.85 121.85,64.85 121.97,64.72 121.97,64.61 122.1,64.48 122.44,64.48 122.56,64.61 122.56,64.72 122.69,64.85 123.14,64.85 123.27,64.72 123.27,64.46 123.48,64.26 123.83,64.26 124.02,64.45 124.02,64.87 124.61,65.46 125.09,65.46 125.21,65.58 125.21,65.71 125.34,65.84 125.56,65.84 125.66,65.94 125.66,66.43 125.79,66.56 126.24,66.56 126.36,66.43 126.36,65.97 126.49,65.84 127.04,65.84 127.25,66.05 127.63,66.05 127.84,65.84 128.22,65.84 128.42,66.05 128.81,66.05 129.01,65.84 129.4,65.84 129.6,66.05 129.99,66.05 130.19,65.84 130.38,65.84 130.51,65.97 130.51,66.34 130.64,66.46 130.98,66.46 131.11,66.34 131.11,65.97 131.23,65.84 137.7,65.84 143.03,60.52 151.79,60.52 157.22,55.09 162.5,55.09 164.74,52.85
  BOTTOM w0.14: v2(115.34,62.33) 115.34,62.31 115.33,62.31 115.33,61.88 115.67,61.54 116.05,61.54 116.54,61.04 116.54,60.8 116.83,60.51 116.83,60.32 116.72,60.21 116.72,59.98 116.89,59.82 117.12,59.82 117.23,59.92 117.42,59.92 117.92,59.43 JDIMM4.170
DDR_B_D36: length 89.4
  TOP w0.089: v2(175.92,50.62) CPU1.AA7
  TOP w0.14: v2(115.86,65.04) 115.43,64.6 114.5,64.6 114.22,64.32 113.26,64.32 112.8,63.85 112.6,63.85 112.57,63.88 112.37,63.88 112.17,63.68 112.17,63.48 112.2,63.45 112.2,63.25 111.37,62.43 JDIMM3.182
  IN4 w0.089: v2(175.92,50.62) 175.8,50.75 169.15,50.75 167.04,52.85 166.76,52.85 164.3,55.3
  IN4 w0.147: 164.3,55.3 164.3,55.31 162.59,57.02 157.99,57.02 152.59,62.43 143.82,62.43 137.56,68.69 137.35,68.69 137.27,68.6 137.27,68.5 137.14,68.37 136.81,68.37 136.68,68.5 136.68,68.57 136.55,68.7 136.15,68.7 136.02,68.57 136.02,68.5 135.89,68.37 135.48,68.37 135.4,68.46 135.4,68.59 135.29,68.7 134.85,68.7 134.76,68.61 134.76,68.47 134.67,68.37 134.23,68.37 134.14,68.46 134.14,68.6 134.05,68.7 133.56,68.7 133.43,68.57 133.43,67.99 133.3,67.86 132.97,67.86 132.85,67.99 132.85,68.57 132.72,68.7 132.27,68.7 132.16,68.59 132.16,68.5 132.03,68.37 131.56,68.37 130.53,69.4 127.27,69.4 127.14,69.52 127.14,69.78 127.01,69.9 126.69,69.9 126.56,69.78 126.56,69.52 126.43,69.39 126.19,69.39 126.1,69.49 125.93,69.49 125.62,69.17 125.62,69.03 125.7,68.94 125.7,68.81 125.54,68.64 125.09,68.64 124.23,67.78 123.74,67.78 123.61,67.65 123.61,67.39 123.49,67.27 121.54,67.27 121.41,67.39 121.41,67.65 121.28,67.78 120.93,67.78 120.81,67.65 120.81,67.39 120.68,67.27 120.32,67.27 120.2,67.39 120.2,67.65 120.1,67.75 119.93,67.75 118.66,66.48 118.66,66.33 118.44,66.1 118.29,66.1 117.61,65.43 117.61,65.11 117.49,64.99 117.04,64.99 116.82,65.21 116.45,65.21 116.23,64.99 115.9,64.99 v2(115.86,65.04)
  BOTTOM w0.14: JDIMM4.183 111.49,62.68 111.69,62.87 111.69,63.54 112.3,64.16 114.98,64.16 v2(115.86,65.04)
DDR_B_D37: length 87.1
  TOP w0.089: v2(176.57,50.62) CPU1.AA8
  TOP w0.14: JDIMM3.186 111.54,63.43 112.73,64.61 114.17,64.61 114.36,64.81 114.36,64.84 v2(114.56,65.04)
  IN4 w0.089: v2(176.57,50.62) 176.44,50.62 176.05,51.02 175.27,51.02 174.78,51.51 169.61,51.51 169.49,51.63 169.49,51.9 168.94,52.45 168.73,52.45 167.92,53.25 167.92,53.44 167.01,54.35 166.83,54.35 166.32,54.85 166.32,55.06 166.13,55.25 165.79,55.25 165.42,54.88 165.14,54.88 164.46,55.56
  IN4 w0.147: v2(114.56,65.04) 114.37,65.23 114.37,65.48 114.47,65.58 114.82,65.58 114.94,65.46 115.27,65.46 115.39,65.58 115.76,65.58 115.88,65.46 116.18,65.46 116.29,65.58 117.23,65.58 119.81,68.16 120.23,68.16 120.37,68.02 120.62,68.02 120.76,68.16 124.07,68.16 124.93,69.01 125.03,69.01 125.25,69.23 125.25,69.33 125.78,69.86 125.93,69.86 126.06,70 126.06,70.15 126.19,70.28 131.06,70.28 131.18,70.15 131.18,70 130.89,69.7 130.89,69.57 131.27,69.2 131.45,69.2 131.55,69.3 131.55,69.45 131.68,69.58 132.03,69.58 132.16,69.45 132.16,69.2 132.29,69.07 132.67,69.07 132.8,69.2 132.8,69.45 132.92,69.58 133.25,69.58 133.38,69.45 133.38,69.2 133.51,69.07 133.85,69.07 133.98,69.2 133.98,69.39 134.1,69.51 134.43,69.51 134.56,69.39 134.56,69.2 134.69,69.07 136.65,69.07 136.78,69.2 136.78,69.45 136.9,69.58 137.2,69.58 137.33,69.45 137.33,69.2 137.46,69.07 137.71,69.07 143.98,62.8 152.74,62.8 158.15,57.39 162.63,57.39 164.46,55.56
  BOTTOM w0.14: JDIMM4.187 111.48,63.68 112.37,64.57 114.18,64.57 114.56,64.96 v2(114.56,65.04)
DDR_B_D38: length 87.5
  TOP w0.089: v2(176.57,49.7) CPU1.AC8
  TOP w0.14: v2(113.71,62.16) 113.28,61.74 113.09,61.74 113.03,61.79 112.8,61.79 112.64,61.63 112.64,61.4 112.69,61.34 112.69,61.15 112.25,60.7 112.25,60.23 111.44,59.43 JDIMM3.170
  IN4 w0.089: 165.03,53.04 166.19,51.88 166.99,51.88 168.86,50 175.05,50 175.72,49.33 176.14,49.33 176.5,49.7 v2(176.57,49.7)
  IN4 w0.147: v2(113.71,62.16) 113.71,61.68 113.97,61.41 113.97,60.93 113.85,60.8 113.14,60.8 113.01,60.93 113.01,62.49 113.22,62.71 114.76,62.71 115.19,63.14 117.89,63.14 119.97,65.23 123.84,65.23 124.45,65.84 124.59,65.84 125.3,66.55 125.3,66.68 125.55,66.94 130.32,66.94 130.42,66.84 131.35,66.84 131.48,66.71 131.48,66.37 131.61,66.24 137.83,66.24 143.18,60.89 151.95,60.89 157.37,55.47 162.6,55.47 165.03,53.04
  BOTTOM w0.14: JDIMM4.169 111.64,59.17 112.98,60.51 112.98,60.65 113.71,61.39 v2(113.71,62.16)
DDR_B_D39: length 90
  TOP w0.089: v2(175.99,49.7) CPU1.AC7
  TOP w0.14: JDIMM3.174 111.59,60.43 111.86,60.7 111.86,62.07 112.7,62.91 115.14,62.91 v2(115.81,63.59)
  IN4 w0.089: 161.95,55.84 162.6,55.84 166.38,52.06 167.06,52.06 168.93,50.18 175.15,50.18 175.64,49.7 v2(175.99,49.7)
  IN4 w0.147: 161.95,55.84 157.53,55.84 152.11,61.27 143.34,61.27 137.48,67.13 137.32,67.13 137.18,66.99 137.18,66.8 137.05,66.67 136.76,66.67 136.63,66.8 136.63,67.09 136.5,67.22 134.59,67.22 134.47,67.09 134.47,66.76 134.34,66.63 131.98,66.63 131.86,66.76 131.86,67.09 131.73,67.22 130.65,67.22 130.52,67.34 130.52,67.73 130.39,67.86 130.06,67.86 129.93,67.73 129.93,67.44 129.8,67.31 129.47,67.31 129.34,67.44 129.34,67.7 129.21,67.83 128.88,67.83 128.75,67.7 128.75,67.44 128.63,67.31 128.29,67.31 128.16,67.44 128.16,67.66 128.04,67.79 127.7,67.79 127.57,67.66 127.57,67.44 127.45,67.31 127.11,67.31 126.98,67.44 126.98,67.63 126.86,67.75 126.52,67.75 126.4,67.63 126.4,67.44 126.27,67.31 125.94,67.31 125.77,67.48 125.57,67.48 124.92,66.84 124.92,66.71 124.46,66.24 124.32,66.24 123.69,65.6 120.73,65.6 120.61,65.73 120.61,65.98 120.48,66.11 119.94,66.11 119.82,65.98 119.82,65.6 118.5,64.28 117.73,63.51 117.07,63.51 116.95,63.64 116.95,63.7 116.82,63.83 116.46,63.83 116.34,63.7 116.34,63.64 116.21,63.51 115.88,63.51 v2(115.81,63.59)
  BOTTOM w0.14: JDIMM4.173 112.14,60.17 113.22,61.25 113.22,62.47 113.34,62.59 114.82,62.59 v2(115.81,63.59)
DDR_B_D40: length 89.7
  TOP w0.089: v2(176.57,52.44) CPU1.W8
  TOP w0.14: v2(114.65,68.23) 115.06,67.82 116.3,67.82 117.16,66.96 117.16,65.28 117.76,64.68 JDIMM3.191
  IN4 w0.089: 165.55,56.65 165.92,56.28 166.36,56.28 170.19,52.45 175.1,52.45 175.56,51.99 176.01,51.99 176.46,52.44 v2(176.57,52.44)
  IN4 w0.147: v2(114.65,68.23) 114.55,68.13 114.55,67.94 114.66,67.82 116.71,67.82 119.52,70.64 123.78,70.64 123.99,70.85 123.99,71.05 124.2,71.25 124.4,71.25 124.67,71.53 124.67,71.73 124.95,72 125.15,72 125.37,72.22 125.37,72.42 125.79,72.84 126.03,72.84 126.2,72.67 127.09,72.67 127.15,72.73 127.42,72.73 127.48,72.67 131.64,72.67 132.76,71.55 137.99,71.55 144.79,64.76 153.55,64.76 158.41,59.91 158.75,59.56 158.89,59.56 159.02,59.68 159.02,59.78 159.15,59.91 159.44,59.91 159.57,59.78 159.57,59.48 159.69,59.35 160.05,59.35 160.18,59.48 160.18,59.78 160.3,59.91 160.61,59.91 160.74,59.78 160.74,59.48 160.86,59.35 161.18,59.35 161.31,59.48 161.31,59.78 161.43,59.91 161.68,59.91 161.81,59.78 161.81,59.48 161.94,59.35 162.85,59.35 165.55,56.65
  BOTTOM w0.14: v2(114.65,68.23) 114.65,67.95 115.36,67.24 115.91,67.24 116.91,66.24 116.91,64.89 117.38,64.43 JDIMM4.190
DDR_B_D41: length 87.7
  TOP w0.089: v2(175.92,52.44) CPU1.W7
  TOP w0.14: v2(115.92,68.26) 116.68,68.26 117.49,67.46 117.49,65.9 117.72,65.68 JDIMM3.195
  IN4 w0.089: v2(175.92,52.44) 175.92,52.38 175.79,52.24 175.56,52.24 175.17,52.63 170.28,52.63 166.39,56.52 166.15,56.52 165.76,56.9
  IN4 w0.147: 165.76,56.9 162.86,59.81 162.31,59.81 161.84,60.28 161.57,60.28 161.42,60.43 161.42,60.54 161.29,60.67 160.96,60.67 160.83,60.54 160.83,60.41 160.7,60.28 160.37,60.28 160.24,60.41 160.24,60.54 160.12,60.67 159.78,60.67 159.65,60.54 159.65,60.41 159.53,60.28 159.17,60.28 159.05,60.41 159.05,60.54 158.92,60.66 158.7,60.66 158.55,60.51 158.33,60.51 153.71,65.13 144.94,65.13 138.15,71.93 133.56,71.93 133.42,72.07 133.42,72.38 133.28,72.52 133.09,72.52 132.79,72.23 132.61,72.23 132.37,72.47 132.37,72.65 132.67,72.95 132.67,73.13 132.43,73.37 132.25,73.37 131.92,73.03 131.73,73.03 131.58,73.18 131.58,73.41 131.45,73.54 131.14,73.54 131.02,73.41 131.02,73.17 130.89,73.04 130.58,73.04 130.45,73.17 130.45,73.41 130.32,73.54 125.54,73.54 125.47,73.48 125.24,73.24 125.24,73.06 125.25,73.05 125.25,72.84 125.04,72.63 124.84,72.63 124.82,72.65 124.64,72.65 124.4,72.41 124.4,72.23 124.42,72.21 124.42,72 124.21,71.8 124,71.8 123.99,71.81 123.81,71.81 123.57,71.58 123.57,71.4 123.59,71.38 123.59,71.17 123.43,71.01 121.45,71.01 121.32,71.14 121.32,71.48 121.19,71.61 120.86,71.61 120.73,71.48 120.73,71.14 120.6,71.01 120.29,71.01 120.16,71.14 120.16,71.46 120.06,71.56 119.91,71.56 116.74,68.38 116.56,68.38 116.44,68.51 116.44,68.59 116.31,68.72 116.05,68.72 115.92,68.59 v2(115.92,68.26)
  BOTTOM w0.14: JDIMM4.194 117.41,65.43 117.24,65.59 117.24,66.31 115.92,67.63 v2(115.92,68.26)
DDR_B_D42: length 89.4
  TOP w0.089: CPU1.V10 v2(177.87,53.37)
  TOP w0.14: JDIMM3.203 117.65,67.67 115.93,69.39 114.03,69.39 v2(113.53,69.88)
  IN4 w0.089: v2(177.87,53.37) 177.51,53.73 176.34,53.73 176.16,53.92 175.08,53.92 174.79,54.21 170.99,54.21 165.83,59.37 165.82,59.37 165.51,59.68
  IN4 w0.147: v2(113.53,69.88) 114.34,70.68 116.3,70.68 120.04,74.42 121.74,74.42 121.83,74.33 122.65,74.33 122.77,74.21 123.43,74.21 125.29,76.07 133.14,76.07 133.89,75.32 137.46,75.32 145.74,67.04 154.5,67.04 158.97,62.58 162.25,62.58 163.11,61.72 163.47,61.72 165.51,59.68
  BOTTOM w0.14: v2(113.53,69.88) 113.53,69.66 113.89,69.3 116.66,69.3 118.04,67.92 JDIMM4.204
DDR_B_D43: length 87.8
  TOP w0.089: CPU1.V11 v2(178.52,53.37)
  TOP w0.14: JDIMM3.208 111.92,68.92 112.66,69.66 v2(112.66,71.49)
  IN4 w0.089: v2(178.52,53.37) 177.98,53.91 176.41,53.91 176.23,54.09 175.15,54.09 174.8,54.44 171.02,54.44 166.13,59.33 166.13,59.58 165.8,59.91
  IN4 w0.147: v2(112.66,71.49) 113.09,71.06 116.14,71.06 119.88,74.8 121.9,74.8 121.98,74.71 122.8,74.71 122.92,74.59 123.28,74.59 125.14,76.45 126.77,76.45 127.35,77.03 129.59,77.03 130.17,76.45 133.3,76.45 134.05,75.7 137.62,75.7 145.85,67.46 154.61,67.46 159.12,62.95 162.4,62.95 163.26,62.1 163.62,62.1 165.8,59.91
  BOTTOM w0.14: JDIMM4.207 111.91,68.67 112.66,69.43 v2(112.66,71.49)
DDR_B_D44: length 87.8
  TOP w0.089: CPU1.W11 v2(178.52,52.45)
  TOP w0.14: v2(114.74,66.46) 114.21,65.93 113.35,65.93 111.84,64.43 JDIMM3.190
  IN4 w0.089: 165.06,56.25 165.45,55.86 166.28,55.86 170.07,52.07 174.97,52.07 175.49,51.55 176.15,51.55 176.5,51.9 177.68,51.9 177.83,52.05 177.97,52.05 178.17,51.85 178.33,51.85 178.38,51.9 178.82,51.9 178.9,51.98 178.9,52.08 v2(178.52,52.45)
  IN4 w0.147: v2(114.74,66.46) 114.6,66.46 114.49,66.57 114.49,66.64 114.34,66.78 114.34,66.97 114.44,67.07 114.95,67.07 115.08,66.94 115.57,66.94 115.7,67.07 116.16,67.07 116.45,66.79 116.73,66.79 119.83,69.88 120.37,69.88 120.46,69.79 120.69,69.79 120.78,69.88 123.55,69.88 123.7,69.73 123.94,69.73 126.13,71.92 130.97,71.92 131.09,71.79 131.09,71.61 131.22,71.48 131.72,71.48 132.4,70.8 137.68,70.8 144.48,64.01 153.24,64.01 158.65,58.6 162.72,58.6 165.06,56.25
  BOTTOM w0.14: JDIMM4.191 111.56,64.68 112.66,65.78 114.06,65.78 v2(114.74,66.46)
DDR_B_D45: length 86.1
  TOP w0.089: CPU1.W10 v2(177.87,52.45)
  TOP w0.14: v2(113.43,66.49) 112.36,65.43 JDIMM3.194
  IN4 w0.089: v2(177.87,52.45) 177.5,52.08 176.4,52.08 176.1,51.79 175.51,51.79 175.02,52.27 170.12,52.27 166.29,56.1 165.66,56.1 165.3,56.46
  IN4 w0.147: v2(113.43,66.49) 112.81,65.87 112.39,65.87 112.26,66 112.26,66.9 112.4,67.04 113.83,67.04 114.24,67.45 116.86,67.45 119.67,70.26 123.94,70.26 125.97,72.29 131.48,72.29 132.59,71.18 137.84,71.18 144.63,64.38 153.4,64.38 158.81,58.97 162.79,58.97 165.3,56.46
  BOTTOM w0.14: JDIMM4.195 112,65.68 112.36,66.03 113.12,66.03 113.43,66.34 v2(113.43,66.49)
DDR_B_D46: length 86.1
  TOP w0.089: v2(175.92,53.37) CPU1.V7
  TOP w0.14: JDIMM3.207 117.04,68.67 116.1,69.61 v2(116.1,69.88)
  IN4 w0.089: v2(175.92,53.37) 175.78,53.22 170.57,53.22 165.29,58.49 165.29,58.83 165.16,58.96
  IN4 w0.147: v2(116.1,69.88) 116.59,69.88 119.5,72.79 123.15,72.79 125.51,75.15 126.01,75.15 126.19,74.98 126.19,74.83 126.32,74.7 126.72,74.7 126.84,74.83 126.84,75.19 126.97,75.32 130.09,75.32 130.22,75.19 130.22,74.84 130.35,74.71 130.69,74.71 130.81,74.84 130.81,75.19 130.94,75.32 131.34,75.32 131.46,75.19 131.46,74.83 131.59,74.7 131.98,74.7 132.11,74.83 132.11,75.19 132.24,75.32 132.7,75.32 132.83,75.19 132.83,74.61 132.94,74.5 133.05,74.5 133.26,74.71 133.44,74.71 133.64,74.5 133.64,74.32 133.45,74.13 133.45,73.99 133.77,73.67 133.95,73.67 134.05,73.77 134.05,73.94 134.18,74.07 134.59,74.07 134.71,73.94 134.71,73.69 134.84,73.57 135.17,73.57 135.3,73.69 135.3,73.94 135.42,74.07 135.8,74.07 135.93,73.94 135.93,73.23 136.06,73.1 136.43,73.1 136.55,73.23 136.55,73.94 136.68,74.07 137.02,74.07 137.15,73.94 137.15,73.23 137.28,73.1 137.65,73.1 137.78,73.23 137.78,73.42 137.93,73.57 138.15,73.57 145.42,66.29 154.19,66.29 158.66,61.83 161.93,61.83 162.79,60.97 163.15,60.97 165.16,58.96
  BOTTOM w0.14: JDIMM4.208 117.94,68.92 116.67,70.2 116.42,70.2 v2(116.1,69.88)
DDR_B_D47: length 89.5
  TOP w0.089: v2(176.57,53.37) CPU1.V8
  TOP w0.14: JDIMM3.204 111.52,67.92 113.1,69.51 113.1,70.09 113.57,70.57 114.34,70.57 114.84,70.07 v2(114.84,69.88)
  IN4 w0.089: v2(176.57,53.37) 176.46,53.37 176.09,53.73 175.01,53.73 174.71,54.03 170.92,54.03 166.89,58.06 166.12,58.06 165.63,58.55 165.63,59.03 165.42,59.24
  IN4 w0.147: v2(114.84,69.88) 114.84,70.2 114.94,70.31 116.46,70.31 119.52,73.38 119.68,73.38 119.88,73.17 120.1,73.17 120.22,73.29 120.22,73.92 120.35,74.05 120.74,74.05 120.87,73.92 120.87,73.32 121,73.2 121.34,73.2 121.47,73.32 121.47,73.83 121.6,73.96 121.99,73.96 122.11,73.83 122.11,73.6 122.24,73.48 122.62,73.48 122.74,73.6 122.74,73.65 122.87,73.78 123.6,73.78 125.52,75.7 125.9,75.7 126.07,75.53 126.56,75.53 126.73,75.7 132.98,75.7 134.23,74.44 137.8,74.44 145.58,66.67 154.35,66.67 158.81,62.2 162.09,62.2 162.95,61.34 163.31,61.34 165.42,59.24
  BOTTOM w0.14: v2(114.84,69.88) 114.84,70.04 114.45,70.43 113.43,70.43 113.1,70.1 113.1,68.88 111.9,67.67 JDIMM4.203
DDR_B_D48: length 92.4
  TOP w0.089: CPU1.R11 v2(178.52,55.2)
  TOP w0.14: JDIMM3.211 117.83,69.67 117.67,69.52 117.67,69.18 117.46,68.97 117.17,68.97 116.96,69.18 116.96,70.14 116.77,70.32 115.3,70.32 115.09,70.53 115.09,71.39 v2(115.22,71.52)
  IN4 w0.089: 166.1,60.26 166.5,59.86 166.5,59.22 171.1,54.62 174.88,54.62 175.11,54.39 176.23,54.39 176.49,54.65 177.64,54.65 177.81,54.83 178.16,54.83 v2(178.52,55.2)
  IN4 w0.147: 166.1,60.26 163.81,62.55 163.45,62.55 162.59,63.41 159.31,63.41 154.8,67.92 146.04,67.92 137.8,76.15 134.23,76.15 133.48,76.9 131.71,76.9 131.57,77.05 131.57,77.72 131.44,77.85 131.1,77.85 130.98,77.72 130.98,77.05 130.83,76.9 130.44,76.9 130.31,77.03 130.31,78.12 130.18,78.24 126.84,78.24 126.71,78.12 126.71,77.03 126.58,76.9 126.17,76.9 126.04,77.03 126.04,77.5 125.92,77.62 125.68,77.62 123.72,75.67 121.15,75.67 121.03,75.54 121.03,75.38 120.9,75.25 120.55,75.25 120.43,75.38 120.43,75.54 120.3,75.67 120.11,75.67 115.96,71.52 v2(115.22,71.52)
  BOTTOM w0.14: v2(115.22,71.52) 115.22,71.24 115.98,70.48 116.85,70.48 117.41,69.92 JDIMM4.212
DDR_B_D49: length 93.1
  TOP w0.089: CPU1.P11 v2(178.52,56.11)
  TOP w0.14: JDIMM3.228 111.69,73.92 112.1,74.34 112.1,74.54 111.88,74.76 111.88,74.96 112.08,75.16 112.27,75.16 112.5,74.93 112.7,74.93 112.96,75.19 112.96,75.51 113.1,75.65 113.99,75.65 114.33,75.99 114.33,76.49 v2(114.17,76.65)
  IN4 w0.089: 167.23,63.96 168.61,62.58 168.61,60.18 171.01,57.78 174.69,57.78 175.5,56.96 176.67,56.96 176.97,56.66 177.97,56.66 v2(178.52,56.11)
  IN4 w0.147: 167.23,63.96 165.2,65.99 164.83,65.99 164.01,66.82 160.73,66.82 156.22,71.33 149.43,71.33 145.26,75.5 143.29,75.5 136.23,82.55 134.05,82.55 133.23,83.37 132.97,83.37 131.39,84.95 126.99,84.95 123.5,81.46 120.9,81.46 115.59,76.14 114.67,76.14 v2(114.17,76.65)
  BOTTOM w0.14: v2(114.17,76.65) 114.17,76.58 111.76,74.17 JDIMM4.229
DDR_B_D50: length 91.7
  TOP w0.089: CPU1.P7 175.7,55.65 v2(176.04,56.12)
  TOP w0.14: v2(115.79,74.87) 115.79,74.67 115.97,74.5 116.17,74.5 116.53,74.86 116.72,74.86 116.94,74.64 116.94,74.44 116.61,74.12 116.61,73.92 116.81,73.72 117.01,73.72 117.28,74 117.45,74 117.58,73.87 117.58,73.49 117.9,73.17 118.8,73.17 JDIMM3.225
  IN4 w0.089: v2(176.04,56.12) 175.73,56.43 175.28,56.43 175.18,56.53 171.5,56.53 167.84,60.2 167.84,61.75 166.32,63.27
  IN4 w0.147: v2(115.79,74.87) 115.95,74.87 121.41,80.33 124.07,80.33 127.56,83.82 129.56,83.82 129.68,83.7 129.68,83.19 129.81,83.07 130.19,83.07 130.32,83.19 130.32,83.7 130.45,83.82 130.8,83.82 131.23,83.39 131.23,82.31 130.95,82.03 130.46,82.03 130.33,81.9 130.33,81.37 130.46,81.25 134.26,81.25 134.64,80.87 136.32,80.87 142.82,74.37 144.56,74.37 145.51,73.42 145.51,73.04 145.04,72.57 145.04,72.15 146.98,70.2 155.75,70.2 160.26,65.69 163.54,65.69 164.4,64.83 164.76,64.83 166.32,63.27
  BOTTOM w0.14: v2(115.79,74.87) 116.75,73.91 116.75,73.91 117.74,72.92 JDIMM4.224
DDR_B_D51: length 95.9
  TOP w0.089: CPU1.R8 v2(176.57,55.2)
  TOP w0.14: v2(116.02,73.07) 116.02,72.55 115.83,72.36 114.42,72.36 114.02,71.96 112.4,71.96 112.18,71.75 112.18,71.35 112.32,71.21 112.32,70.95 112.19,70.82 111.91,70.82 111.79,70.69 111.79,70.4 111.93,70.26 112.19,70.26 112.32,70.13 112.32,69.71 112.11,69.5 111.81,69.5 111.38,69.92 JDIMM3.212
  IN4 w0.089: v2(176.57,55.2) 176.46,55.2 176.01,54.75 175.25,54.75 175.03,54.97 171.24,54.97 166.91,59.3 166.91,60.53 166.6,60.85
  IN4 w0.147: 166.6,60.85 166.58,60.85 164.12,63.3 163.76,63.3 162.9,64.16 159.62,64.16 155.11,68.67 146.35,68.67 138.12,76.9 137.36,76.9 135.77,78.49 134.01,78.49 133.89,78.62 133.89,79.41 133.76,79.53 133.3,79.53 133.18,79.41 133.18,79.15 133.05,79.03 132.63,79.03 132.5,79.15 132.5,79.59 132.38,79.71 132.01,79.71 131.88,79.59 131.88,79.12 131.75,79 131.41,79 131.28,79.12 131.28,79.59 131.16,79.71 130.78,79.71 130.65,79.59 130.65,79.12 130.52,79 130.12,79 129.99,79.12 129.99,79.59 129.87,79.71 126.7,79.71 124.06,77.07 120.38,77.07 116.37,73.07 v2(116.02,73.07)
  BOTTOM w0.14: JDIMM4.211 111.7,69.67 112.21,70.19 112.21,71.64 112.51,71.94 114.05,71.94 114.41,72.31 115.29,72.31 116.02,73.04 v2(116.02,73.07)
DDR_B_D52: length 93.5
  TOP w0.089: CPU1.R10 v2(177.87,55.2)
  TOP w0.14: v2(113.96,71.51) 114.54,72.09 115.27,72.09 116.68,70.67 116.85,70.67 116.99,70.81 116.99,71.42 117.13,71.56 117.41,71.56 117.55,71.42 117.55,70.81 117.69,70.67 JDIMM3.215
  IN4 w0.089: v2(177.87,55.2) 177.51,54.83 176.38,54.83 176.11,54.57 175.18,54.57 174.95,54.8 171.17,54.8 166.67,59.29 166.67,60.24 166.4,60.51
  IN4 w0.147: 166.4,60.51 166.38,60.51 163.97,62.92 163.6,62.92 162.75,63.78 159.47,63.78 154.96,68.29 146.19,68.29 137.96,76.52 136.71,76.52 135.92,77.32 133.27,77.32 133.12,77.47 133.12,78.38 132.99,78.51 132.66,78.51 132.53,78.38 132.53,77.47 132.38,77.32 132.07,77.32 131.94,77.45 131.94,78.49 131.82,78.62 126.14,78.62 123.56,76.04 119.96,76.04 115.86,71.95 114.39,71.95 v2(113.96,71.51)
  BOTTOM w0.14: JDIMM4.216 116.65,70.92 115.55,72.03 114.47,72.03 v2(113.96,71.51)
DDR_B_D53: length 91.4
  TOP w0.089: CPU1.P10 v2(177.87,56.11)
  TOP w0.14: v2(113.27,74.86) 112.99,74.58 112.99,74.38 113.37,74 113.37,73.8 113.17,73.6 112.97,73.6 112.59,73.99 112.34,73.99 112.16,73.8 112.16,73.17 112.03,73.05 111.48,73.05 111.36,72.92 JDIMM3.224
  IN4 w0.089: v2(177.87,56.11) 177.5,56.48 176.9,56.48 176.59,56.79 175.43,56.79 174.65,57.56 170.98,57.56 168.36,60.18 168.36,62.29 167.5,63.16
  IN4 w0.147: v2(113.27,74.86) 114.13,75.72 115.73,75.72 121.08,81.08 123.65,81.08 127.15,84.58 131.11,84.58 132.01,83.68 132.01,82.58 132.26,82.33 132.38,82.33 132.54,82.18 136.07,82.18 143.13,75.12 145.11,75.12 149.27,70.95 156.06,70.95 160.57,66.44 163.85,66.44 164.68,65.62 165.04,65.62 167.5,63.16
  BOTTOM w0.14: v2(113.27,74.86) 111.58,73.17 JDIMM4.225
DDR_B_D54: length 93.4
  TOP w0.089: CPU1.R7 v2(175.92,55.2)
  TOP w0.14: JDIMM3.216 111.48,70.92 111.68,71.13 111.68,72.56 111.85,72.73 112.09,72.73 112.26,72.56 112.26,72.31 112.37,72.2 112.74,72.2 112.83,72.29 112.83,72.58 112.99,72.74 113.28,72.74 113.43,72.59 113.43,72.35 113.57,72.21 113.85,72.21 113.99,72.35 113.99,72.54 114.13,72.68 114.43,72.68 v2(114.83,73.08)
  IN4 w0.089: 166.84,61.12 167.17,60.78 167.17,59.3 171.32,55.15 174.52,55.15 175.03,55.66 175.46,55.66 v2(175.92,55.2)
  IN4 w0.147: v2(114.83,73.08) 114.83,73.54 115,73.71 116.47,73.71 120.21,77.45 120.99,77.45 121.14,77.6 121.14,78.11 121.27,78.24 121.6,78.24 121.73,78.11 121.73,77.6 121.88,77.45 122.72,77.45 122.87,77.6 122.87,77.86 122.99,77.99 123.33,77.99 123.46,77.86 123.46,77.6 123.6,77.45 123.9,77.45 124.63,78.18 124.63,78.39 124.44,78.58 124.44,78.76 124.68,78.99 124.86,78.99 125.05,78.8 125.26,78.8 126.55,80.09 133.78,80.09 134.16,79.71 135.83,79.71 136.51,79.04 136.51,78.83 136.35,78.68 136.35,78.47 136.56,78.26 136.77,78.26 136.92,78.41 137.13,78.41 137.34,78.21 137.34,78 137.19,77.84 137.19,77.63 137.39,77.43 137.6,77.43 137.76,77.58 137.97,77.58 146.5,69.04 155.27,69.04 159.78,64.53 163.06,64.53 163.92,63.68 164.28,63.68 166.84,61.12
  BOTTOM w0.14: v2(114.83,73.08) 113.93,72.18 112.41,72.18 111.98,71.75 111.61,70.97 111.32,70.67 JDIMM4.215
DDR_B_D55: length 93
  TOP w0.089: CPU1.P8 176.3,55.65 v2(176.64,56.12)
  TOP w0.14: v2(114.59,74.89) 114.59,75.96 114.74,76.11 115.2,76.11 115.33,75.98 115.33,75.48 115.46,75.36 117.05,75.36 117.38,75.03 117.38,74.54 117.75,74.17 JDIMM3.229
  IN4 w0.089: 166.64,63.48 168.15,61.98 168.15,60.14 171.55,56.74 175.22,56.74 175.35,56.61 176.15,56.61 v2(176.64,56.12)
  IN4 w0.147: 166.64,63.48 166.64,63.48 164.92,65.21 164.55,65.21 163.69,66.07 160.42,66.07 155.91,70.58 148.36,70.58 147.03,71.9 146.82,71.9 146.5,71.58 146.32,71.58 146.09,71.82 146.09,72 146.41,72.32 146.41,72.53 145.88,73.05 145.88,73.58 144.72,74.74 142.98,74.74 136.47,81.25 134.79,81.25 134.42,81.62 132.56,81.62 132.23,81.96 132.11,81.96 131.61,82.45 131.61,83.55 130.96,84.2 127.31,84.2 123.81,80.7 121.24,80.7 115.87,75.33 115.03,75.33 v2(114.59,74.89)
  BOTTOM w0.14: v2(114.59,74.89) 115.03,75.33 116.06,75.33 117.46,73.92 JDIMM4.228
DDR_B_D56: length 93.6
  TOP w0.089: CPU1.L11 v2(178.52,58.82)
  TOP w0.14: JDIMM3.245 118.04,78.17 115.62,80.59 v2(115.62,82.45)
  IN4 w0.089: v2(178.52,58.82) 178.1,59.25 177.8,59.25 177.62,59.43 176.94,59.43 175.28,61.09 173.79,61.09 171.58,63.3 171.58,65.08 167.92,68.73
  IN4 w0.147: v2(115.62,82.45) 115.62,82.66 119.22,86.25 119.59,86.62 121.17,86.62 122.78,88.23 123.75,88.23 125.11,89.59 133.78,89.59 134.48,88.89 136.16,88.89 137.65,87.4 137.65,86.86 140.26,84.25 143.12,84.25 144.16,83.22 144.16,82.18 145.16,81.19 146.19,81.19 148.37,79 149.55,79 150.46,78.09 152.33,76.22 157.48,76.22 158.9,74.8 159.56,74.8 160.04,74.32 160.04,73.43 162.14,71.33 164.97,71.33 166.44,69.86 166.8,69.86 167.92,68.73
  BOTTOM w0.14: v2(115.62,82.45) 115.62,80.84 118.04,78.43 JDIMM4.246
DDR_B_D57: length 91.6
  TOP w0.089: CPU1.M11 v2(178.52,57.94)
  TOP w0.14: JDIMM3.233 117.66,75.17 117.15,75.68 116.34,75.68 v2(115.41,76.62)
  IN4 w0.089: 167.31,64.51 168.84,62.99 168.84,60.21 171.09,57.95 174.76,57.95 175.57,57.15 176.78,57.15 177.02,57.4 177.98,57.4 v2(178.52,57.94)
  IN4 w0.147: 167.31,64.51 165.38,66.44 165.02,66.44 164.19,67.27 160.92,67.27 156.41,71.78 149.8,71.78 149.67,71.91 149.67,72.5 149.8,72.63 150.14,72.63 150.27,72.75 150.27,73.42 150.01,73.69 147.71,73.69 145.45,75.95 143.47,75.95 140.43,78.99 136.42,83 134.25,83 133.43,83.82 133.16,83.82 131.58,85.4 126.81,85.4 123.31,81.91 120.7,81.91 116.17,77.38 115.55,77.38 115.41,77.24 v2(115.41,76.62)
  BOTTOM w0.14: JDIMM4.232 117.92,74.92 117.16,75.68 115.91,75.68 115.41,76.18 v2(115.41,76.62)
DDR_B_D58: length 92.4
  TOP w0.089: CPU1.L7 175.6,58.36 v2(175.92,58.81)
  TOP w0.14: v2(114.06,81.12) 114.06,80.64 111.84,78.43 JDIMM3.246
  IN4 w0.089: 168.67,66.4 170.46,64.61 170.46,62.43 173.11,59.79 174.94,59.79 v2(175.92,58.81)
  IN4 w0.147: 168.67,66.4 168.67,66.4 166.33,68.73 165.97,68.73 164.5,70.2 161.67,70.2 158.43,73.44 158.43,73.68 157.01,75.09 151.83,75.09 150.96,75.97 148.77,75.97 144.08,80.66 141.99,80.66 136.09,86.57 133.65,86.57 132.53,87.69 125.86,87.69 123.63,85.47 122.73,85.47 122.59,85.32 122.59,85.07 122.46,84.94 122.13,84.94 122,85.07 122,85.37 121.87,85.5 121.54,85.5 121.41,85.37 121.41,85.07 121.28,84.94 120.95,84.94 120.82,85.07 120.82,85.32 120.67,85.47 120.02,85.47 117.76,83.2 117.76,82.3 116.58,81.12 116.49,81.12 116.36,81.25 116.36,81.52 116.23,81.65 115.88,81.65 115.75,81.52 115.75,81.06 115.63,80.93 115.25,80.93 115.12,81.06 115.12,81.38 114.86,81.65 114.19,81.65 114.06,81.52 v2(114.06,81.12)
  BOTTOM w0.14: JDIMM4.245 111.66,78.17 114.06,80.58 v2(114.06,81.12)
DDR_B_D59: length 92.8
  TOP w0.089: CPU1.M8 176.25,57.62 v2(176.57,57.9)
  TOP w0.14: JDIMM3.232 111.43,74.92 112.72,76.22 112.72,76.53 113.43,77.24 114.08,77.24 v2(114.61,77.77)
  IN4 w0.089: 167.72,65.17 167.73,65.16 169.23,63.67 169.23,60.32 171.22,58.32 174.89,58.32 175.71,57.5 176.18,57.5 v2(176.57,57.9)
  IN4 w0.147: v2(114.61,77.77) 115.23,78.39 116.02,78.39 119.41,81.78 119.41,82.68 120.07,83.34 123.68,83.34 126.49,86.16 131.89,86.16 133.47,84.58 133.76,84.58 133.9,84.72 133.9,84.88 134.03,85.01 134.36,85.01 134.49,84.88 134.49,84.72 134.64,84.58 135.91,84.58 141.18,79.31 141.73,78.75 142.59,78.75 143.59,77.75 143.59,76.97 143.86,76.7 145.82,76.7 148.08,74.44 150.32,74.44 151.04,73.71 151.04,72.8 151.32,72.53 156.72,72.53 161.23,68.02 164.51,68.02 165.33,67.2 165.7,67.2 167.72,65.17
  BOTTOM w0.14: JDIMM4.233 111.79,75.17 112.78,76.17 112.78,76.64 113.48,77.33 114.17,77.33 v2(114.61,77.77)
DDR_B_D60: length 91.9
  TOP w0.089: CPU1.L10 v2(177.87,58.82)
  TOP w0.14: v2(116.79,82.48) 116.79,80.36 117.97,79.18 JDIMM3.249
  IN4 w0.089: v2(177.87,58.82) 177.51,59.19 176.83,59.19 175.29,60.73 173.6,60.73 171.15,63.18 171.15,64.98 167.92,68.2
  IN4 w0.147: 167.92,68.2 166.65,69.48 166.28,69.48 164.81,70.95 161.98,70.95 159.18,73.75 159.18,73.99 157.32,75.85 152.15,75.85 151.27,76.72 149.08,76.72 143.78,82.03 143.78,83.06 142.96,83.88 139.84,83.88 136.4,87.32 135.52,87.32 133.62,89.21 132.11,89.21 131.44,88.54 130.7,88.54 130.58,88.67 130.58,88.69 130.45,88.82 130.12,88.82 129.99,88.69 129.99,88.57 129.86,88.45 129.53,88.45 129.4,88.57 129.4,89.06 129.25,89.21 128.96,89.21 128.81,89.06 128.81,88.64 128.66,88.49 128.37,88.49 128.22,88.64 128.22,89.06 128.07,89.21 127.78,89.21 127.63,89.06 127.63,88.64 127.48,88.49 127.19,88.49 127.04,88.64 127.04,89.06 126.89,89.21 125.26,89.21 122.3,86.25 119.74,86.25 116.79,83.29 v2(116.79,82.48)
  BOTTOM w0.14: v2(116.79,82.48) 116.79,80.28 117.64,79.43 JDIMM4.250
DDR_B_D61: length 90.8
  TOP w0.089: CPU1.M10 v2(177.87,57.94)
  TOP w0.14: JDIMM3.237 117.52,76.17 v2(115.88,77.82)
  IN4 w0.089: 167.46,64.9 167.47,64.89 169.05,63.31 169.05,60.25 171.16,58.13 174.83,58.13 175.64,57.33 176.7,57.33 176.95,57.57 177.64,57.57 177.87,57.81 v2(177.87,57.94)
  IN4 w0.147: 167.46,64.9 165.54,66.82 165.18,66.82 164.35,67.65 161.07,67.65 156.56,72.16 150.95,72.16 150.67,72.44 150.67,73.56 150.16,74.06 147.93,74.06 145.67,76.32 143.63,76.32 143.14,76.81 143.14,77.67 142.44,78.38 141.58,78.38 140.8,79.15 136.57,83.38 135.34,83.38 135.19,83.53 135.19,84.12 135.12,84.2 134.73,84.2 134.62,84.09 134.62,83.59 134.54,83.5 134.31,83.5 134.14,83.66 134.14,83.84 134.05,83.93 133.91,83.93 133.64,84.2 133.32,84.2 131.74,85.78 126.65,85.78 123.8,82.93 123.15,82.28 122.72,82.28 122.59,82.41 122.59,82.8 122.47,82.93 120.19,82.93 119.88,82.62 119.88,81.73 115.97,77.82 v2(115.88,77.82)
  BOTTOM w0.14: v2(115.88,77.82) 117.77,75.92 JDIMM4.236
DDR_B_D62: length 90.8
  TOP w0.089: CPU1.M7 v2(175.91,57.87)
  TOP w0.14: JDIMM3.236 111.5,75.92 v2(113.36,77.78)
  IN4 w0.089: 167.92,65.5 169.54,63.88 169.54,62.27 172.76,59.05 174.76,59.05 175.03,58.78 175.03,58.65 175.81,57.87 v2(175.91,57.87)
  IN4 w0.147: 167.92,65.5 165.85,67.57 165.49,67.57 164.66,68.4 164.16,68.4 164.01,68.55 164.01,68.61 163.88,68.74 163.55,68.74 163.42,68.61 163.42,68.55 163.27,68.4 161.38,68.4 157.22,72.56 157.22,73.24 156.53,73.94 154.83,73.94 154.68,73.79 154.68,73.18 154.51,73.01 153.74,73.01 153.59,73.15 153.59,73.81 153.46,73.94 153.13,73.94 153,73.81 153,73.15 152.85,73.01 151.91,73.01 151.74,73.18 151.74,73.79 151.59,73.94 151.35,73.94 150.48,74.81 148.24,74.81 145.98,77.08 144.8,77.08 142.75,79.13 141.89,79.13 135.63,85.38 133.2,85.38 132.05,86.53 126.34,86.53 123.56,83.75 119.95,83.75 118.99,82.79 118.99,81.9 115.89,78.8 114.38,78.8 v2(113.36,77.78)
  BOTTOM w0.14: JDIMM4.237 111.75,76.17 v2(113.36,77.78)
DDR_B_D63: length 90.7
  TOP w0.089: CPU1.L8 176.25,58.5 v2(176.57,58.82)
  TOP w0.14: JDIMM3.250 111.68,79.43 112.89,80.63 v2(112.89,81.14)
  IN4 w0.089: v2(176.57,58.82) 176.19,59.21 175.78,59.21 174.99,60 173.2,60 170.76,62.45 170.76,64.83 167.92,67.67
  IN4 w0.147: v2(112.89,81.14) 112.89,81.37 113.54,82.03 116.95,82.03 117.38,82.46 117.38,83.36 119.9,85.87 123.26,85.87 123.88,86.49 123.88,87.29 125.42,88.83 126.5,88.83 126.63,88.71 126.63,88.2 126.76,88.07 132.01,88.07 132.13,88.2 132.13,88.7 132.26,88.83 132.79,88.83 134.68,86.94 136.25,86.94 142.15,81.04 144.24,81.04 148.93,76.35 151.11,76.35 151.99,75.47 157.17,75.47 158.8,73.84 158.8,73.6 161.82,70.57 164.66,70.57 166.13,69.11 166.49,69.11 167.92,67.67
  BOTTOM w0.14: v2(112.89,81.14) 112.89,80.33 111.74,79.18 JDIMM4.249
DDR_B_DQS0: length 89.3
  TOP w0.089: v2(177.74,25.06) 177.74,24.59 177.66,24.5 177.58,24.5 CPU1.BR9
  TOP w0.14: v2(115.78,16.6) 115.98,16.39 116.89,16.39 117.02,16.52 117.02,16.87 116.91,16.98 116.69,16.98 116.48,17.18 116.48,17.67 117.11,18.3 117.52,18.3 117.76,18.05 117.95,18.05 118.07,18.17 JDIMM3.13
  IN4 w0.089: 176.62,21.46 176.62,21.47 176.64,21.47 176.65,21.46 176.7,21.51 176.93,21.74 176.93,22.24 178.58,23.89 178.58,24.9 178.11,25.36 177.85,25.36 177.74,25.25 v2(177.74,25.06)
  IN4 w0.147: v2(115.78,16.6) 115.98,16.39 119.01,16.39 120.67,14.74 126.11,14.74 127.83,13.01 130.59,13.01 130.92,13.35 154.56,13.35 155.36,12.54 159.95,12.54 160.36,12.95 161.65,12.95 162.05,12.54 163.07,12.54 164.76,10.86 171.06,10.86 174.38,14.18 174.38,19.23 176.26,21.11 176.62,21.46
  BOTTOM w0.14: v2(115.78,16.6) 115.61,16.43 115.11,16.43 114.08,17.45 112.62,17.45 112.02,18.05 111.77,18.05 111.65,18.17 JDIMM4.13
DDR_B_DQS1: length 83.4
  TOP w0.089: v2(177.22,27.83) 176.94,27.55 176.75,27.55 176.58,27.72 176.58,27.9 CPU1.BJ9
  TOP w0.14: v2(114.97,21.43) 114.8,21.59 114.8,21.97 114.41,22.36 112.39,22.36 112.31,22.44 112.31,23.01 112.02,23.3 111.77,23.3 111.65,23.42 JDIMM3.34
  IN4 w0.089: 168.84,22.11 168.85,22.12 168.89,22.12 168.93,22.16 168.97,22.16 171.61,24.8 173.9,24.8 174.67,25.56 174.67,26.4 175.89,27.62 177.16,27.62 177.22,27.69 v2(177.22,27.83)
  IN4 w0.147: 168.84,22.11 167.96,21.23 160.66,21.23 159.19,19.75 157.79,19.75 157.64,19.9 157.64,20.21 157.35,20.51 156.55,20.51 156.25,20.21 156.25,19.9 156.1,19.75 155.52,19.75 155.08,20.19 153.66,20.19 153.22,19.75 145.82,19.75 145.37,20.2 130.5,20.2 130.3,20.4 126.47,20.4 126.36,20.29 118.47,20.29 117.88,20.88 114.72,20.88 114.52,21.08 114.52,21.32 114.63,21.43 v2(114.97,21.43)
  BOTTOM w0.14: JDIMM4.34 117.87,23.42 117.68,23.24 117.68,23.17 117.56,23.05 117.28,23.05 116.7,22.46 116.7,21.25 116.41,20.97 114.62,20.97 114.47,21.12 114.47,21.23 114.67,21.43 v2(114.97,21.43)
DDR_B_DQS2: length 83.1
  TOP w0.089: CPU1.BF9 v2(177.22,31.42)
  TOP w0.14: v2(114.6,26.94) 114.77,27.11 114.77,27.98 115.06,28.26 115.83,28.26 116.15,27.94 116.15,27.75 116.29,27.62 116.87,27.62 116.98,27.73 116.98,28.3 117.24,28.55 117.85,28.55 117.97,28.68 JDIMM3.55
  IN4 w0.089: v2(177.22,31.42) 176.86,31.06 175.64,31.06 174.39,29.8 172.15,29.8 167.04,24.69 166.71,24.69 166.68,24.72 166.62,24.72 166.59,24.75 166.58,24.75
  IN4 w0.147: 166.58,24.75 166.26,24.75 165.63,25.38 141.09,25.38 140.92,25.21 137.86,25.21 137.02,26.05 134.49,26.05 133.95,26.58 133.24,26.58 132.99,26.32 132.99,25.67 132.88,25.56 132.17,25.56 132.06,25.67 132.06,26.32 131.8,26.58 130.97,26.58 130.44,26.05 123.94,26.05 123.38,25.49 119.82,25.49 117.53,27.78 115.26,27.78 114.93,27.45 114.93,27.26 v2(114.6,26.94)
  BOTTOM w0.14: JDIMM4.55 111.5,28.68 111.64,28.53 111.64,28.4 112.66,27.38 112.66,26.94 113.27,26.33 114.84,26.33 114.95,26.45 114.95,26.58 v2(114.6,26.94)
DDR_B_DQS3: length 82.1
  TOP w0.089: CPU1.BB9 v2(177.22,34.16)
  TOP w0.14: JDIMM3.76 111.52,33.93 111.64,33.8 111.96,33.8 112.25,33.51 112.25,32.63 113.21,31.66 114.88,31.66 115.09,31.87 115.09,32.03 114.95,32.17 v2(114.59,32.17)
  IN4 w0.089: 172.22,33.08 172.25,33.08 172.27,33.05 173.04,33.05 173.14,33.16 173.22,33.16 173.22,33.16 173.48,33.16 173.48,33.16 174.81,33.16 175.45,33.8 176.86,33.8 v2(177.22,34.16)
  IN4 w0.147: 172.22,33.08 168.32,33.08 165.78,30.54 165.6,30.54 164.9,29.84 164.9,29.66 164.49,29.24 142.12,29.24 140.11,31.26 139.35,31.26 139.04,30.96 138.55,30.96 138.27,31.24 137.49,31.24 137.21,30.96 136.81,30.96 136.23,31.54 119.47,31.54 118.72,32.29 118.14,32.29 118.03,32.41 118.03,32.98 117.77,33.24 117.13,33.24 116.74,32.85 116.12,32.85 115.73,33.24 115.06,33.24 114.8,32.97 114.8,32.37 v2(114.59,32.17)
  BOTTOM w0.14: JDIMM4.76 117.77,33.93 117.66,33.81 117.18,33.81 116.89,33.52 116.89,33.14 117.19,32.84 117.19,32.63 117.01,32.45 116.8,32.45 116.35,32.9 115.07,32.9 114.76,32.59 114.76,32.34 v2(114.59,32.17)
DDR_B_DQS4: length 90.1
  TOP w0.089: v2(177.22,50.62) CPU1.AA9
  TOP w0.14: v2(113.76,63.61) 113.89,63.61 114.35,64.07 114.64,64.07 114.9,64.34 116.29,64.34 117.3,63.32 117.3,62.21 117.84,61.68 JDIMM3.179
  IN4 w0.089: 161.95,56.57 161.96,56.57 161.99,56.54 162.04,56.54 162.07,56.51 162.65,56.51 166.6,52.57 167.08,52.57 169.08,50.56 175.43,50.56 175.73,50.26 176.86,50.26 v2(177.22,50.62)
  IN4 w0.147: v2(113.76,63.61) 113.95,63.81 113.95,64.28 114.2,64.54 114.88,64.54 115.11,64.3 115.72,64.3 115.96,64.54 117.17,64.54 117.3,64.41 117.62,64.41 118.06,64.85 118.06,65.24 118.48,65.65 118.87,65.65 119.11,65.89 119.11,66.29 119.64,66.81 123.9,66.81 125.27,68.19 125.72,68.19 126.48,68.95 130.35,68.95 131.37,67.92 132.27,67.92 132.54,67.65 132.54,67.45 132.65,67.34 133.67,67.34 133.78,67.45 133.78,67.65 134.05,67.92 137.68,67.92 143.63,61.97 152.4,61.97 157.81,56.57 161.95,56.57
  BOTTOM w0.14: JDIMM4.179 111.46,61.68 111.49,61.64 111.49,61.5 111.56,61.43 112.45,61.43 112.64,61.62 112.64,61.85 112.54,61.94 112.14,61.94 111.95,62.13 111.95,63.17 112.25,63.46 112.68,63.46 112.99,63.15 113.8,63.15 113.97,63.32 113.97,63.52 113.88,63.61 v2(113.76,63.61)
DDR_B_DQS5: length 90.3
  TOP w0.089: v2(177.22,53.37) CPU1.V9
  TOP w0.14: JDIMM3.200 111.39,66.92 111.63,66.68 111.97,66.68 112.07,66.78 112.07,66.92 111.75,67.24 111.75,67.69 112.05,67.99 112.52,67.99 113.34,67.18 113.85,67.18 113.96,67.29 113.96,67.42 113.6,67.78 113.6,68.12 113.49,68.23 v2(113.17,68.23)
  IN4 w0.089: v2(177.22,53.37) 176.86,53 170.43,53 163.37,60.06 163.35,60.09 163.35,60.09 163.32,60.12 163.32,60.16 163.3,60.18
  IN4 w0.147: v2(113.17,68.23) 113.17,68.9 113.69,69.42 116.78,69.42 119.69,72.34 123.33,72.34 125.24,74.25 132.55,74.25 134.15,72.65 138.43,72.65 145.24,65.84 154,65.84 158.47,61.37 161.75,61.37 162.61,60.52 162.97,60.52 163.3,60.18
  BOTTOM w0.14: v2(113.17,68.23) 113.34,68.4 113.34,68.53 113.79,68.98 116.17,68.98 117.02,68.14 117.02,67.85 117.94,66.92 JDIMM4.200
